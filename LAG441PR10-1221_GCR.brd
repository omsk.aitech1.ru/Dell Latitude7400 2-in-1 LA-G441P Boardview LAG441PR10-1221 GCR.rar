# Allegro board LAG441PR10-1221_GCR.brd (continued)
## Nets (continued)
CHG_PROCHOT#: PR114.2 PR217.2 PU200.23
CHG_PROG: PR226.1 PU200.27
CHG_PSYS: PR229.2 PU200.30
CHG_UG1: PQ201.1 PU200.11
CHG_UG2: PQ203.1 PU200.5
CHG_VBAT1: PC245.1 PR236.1 PU200.31
CHG_VDDP: PC228.1 PR207.1 PU200.8
CHG_VIN_20V: PC200.2 PL200.2 PR200.1 PR201.2 PT200.1(TP-1)
CHG_VSYS: PC235.1 PR218.1 PU200.3
CHR_USB20_N3: LI4.1 UI5.11
CHR_USB20_N3_R: DI13.1 JUSB2.2 LI4.2
CHR_USB20_N4: LI1.1 UI4.11
CHR_USB20_N4_R: DI7.1 JUSB1.2 LI1.2
CHR_USB20_P3: LI4.4 UI5.10
CHR_USB20_P3_R: DI14.1 JUSB2.3 LI4.3
CHR_USB20_P4: LI1.4 UI4.10
CHR_USB20_P4_R: DI8.1 JUSB1.3 LI1.3
CLK_CNV_PRX_DTX_N: JNGFF3.21 UCPU1.CN31
CLK_CNV_PRX_DTX_P: JNGFF3.23 UCPU1.CP31
CLK_CNV_PTX_DRX_N: JNGFF3.71 UCPU1.CP34
CLK_CNV_PTX_DRX_P: JNGFF3.73 UCPU1.CN34
CLK_ITPXDP_N: RC61.2 UCPU1.AU1
CLK_ITPXDP_N_R: JXDP1.42 RC61.1
CLK_ITPXDP_P: RC60.2 UCPU1.AU2
CLK_ITPXDP_P_R: JXDP1.40 RC60.1
CLK_PCIE_N0: UCPU1.AW2 UT2.T19
CLK_PCIE_N1: RN43.1 UCPU1.BC1
CLK_PCIE_N1_R: JNGFF3.49 RN43.2
CLK_PCIE_N2: RN21.1 UCPU1.BD3
CLK_PCIE_N2_R: JNGFF2.53 RN21.2
CLK_PCIE_N4: RR18.1 UCPU1.BA1
CLK_PCIE_N4_R: RR18.2 UR1.6
CLK_PCIE_N5: RN18.1 UCPU1.BE1
CLK_PCIE_N5_R: JNGFF1.53 RN18.2
CLK_PCIE_P0: UCPU1.AY3 UT2.V19
CLK_PCIE_P1: RN45.1 UCPU1.BC2
CLK_PCIE_P1_R: JNGFF3.47 RN45.2
CLK_PCIE_P2: RN22.1 UCPU1.BC3
CLK_PCIE_P2_R: JNGFF2.55 RN22.2
CLK_PCIE_P4: RR17.1 UCPU1.BA2
CLK_PCIE_P4_R: RR17.2 UR1.5
CLK_PCIE_P5: RN17.1 UCPU1.BE2
CLK_PCIE_P5_R: JNGFF1.55 RN17.2
CLK_SMB: JBATT1.4 PR195.1
CLK_TP_SIO_I2C_DAT: RE467.2 UE1.E10
CLKREQ_CNV: RC529.2 RN32.2 UCPU1.CH29
CLKREQ_CNV_R: JNGFF3.14 RN32.1
CLKREQ_PCIE#0: RC65.2 RT71.1 UCPU1.CF32
CLKREQ_PCIE#0_R: RT10.1 RT71.2 UT2.AC5
CLKREQ_PCIE#1: QN5.3 RC62.2 RN100.2 UCPU1.CE32
CLKREQ_PCIE#1_R: JNGFF3.53 QN5.6 RN99.2 RN100.1
CLKREQ_PCIE#2: JNGFF2.52 RC63.2 UCPU1.CF30
CLKREQ_PCIE#3: RC58.2 UCPU1.CE31
CLKREQ_PCIE#4: RC67.2 UCPU1.CE30 UR1.2
CLKREQ_PCIE#5: QN4.3 RC530.2 RN96.2 UCPU1.CF31
CLKREQ_PCIE#5_R: JNGFF1.52 QN4.6 RN95.1 RN96.1
CNV_BRI_PRX_DTX: RC526.2 RN46.2 UCPU1.CK20
CNV_BRI_PRX_R_DTX: JNGFF3.22 RN46.1
CNV_BRI_PTX_DRX: RC525.2 UCPU1.CJ20
CNV_BRI_PTX_R_DRX: JNGFF3.36 RC525.1 RC597.1
CNV_COEX1: RN52.2 UCPU1.CH17
CNV_COEX2: RN53.2 UCPU1.CJ17
CNV_COEX3: RN54.2 UCPU1.CP20
CNV_DET#: RE485.2 UE1.L11
CNV_PRX_DTX_N0: JNGFF3.15 UCPU1.CR30
CNV_PRX_DTX_N1: JNGFF3.9 UCPU1.CM30
CNV_PRX_DTX_P0: JNGFF3.17 UCPU1.CP30
CNV_PRX_DTX_P1: JNGFF3.11 UCPU1.CN30
CNV_PTX_DRX_N0: JNGFF3.65 UCPU1.CN32
CNV_PTX_DRX_N1: JNGFF3.59 UCPU1.CP33
CNV_PTX_DRX_P0: JNGFF3.67 UCPU1.CM32
CNV_PTX_DRX_P1: JNGFF3.61 UCPU1.CN33
CNV_RF_RESET: QN10.1 RE485.1 RN119.2 RW19.1
CNV_RF_RESET#: RC528.2 RN31.2 RN118.1 UCPU1.CJ32
CNV_RF_RESET#_R: JNGFF3.10 RN31.1
CNV_RGI_PRX_DTX: RC527.2 RN47.2 UCPU1.CH19
CNV_RGI_PRX_R_DTX: JNGFF3.34 RN47.1
CNV_RGI_PTX_DRX: RC524.2 UCPU1.CG19
CNV_RGI_PTX_R_DRX: JNGFF3.32 RC490.1 RC491.1 RC524.1
CNVI_EN#: QN6.2 RN110.1 RN119.1 UCPU1.CH30
CNVI_RCOMP: RC439.2 UCPU1.CP32 UCPU1.CR32
CODEC_MUTE#: CA32.2 DA27.2 RA118.2 RA120.2 RA121.1 UA1.2
CONTACTLESS_DET#: DB9.2 RC620.1 UCPU1.CN35
CONTACTLESS_DET#_R: DB9.1 JUSH1.23
CORE_VID0: PR1428.2 UCPU1.CB36
CORE_VID1: PR1429.2 UCPU1.CB35
CPU_C10_GATE#: PR1430.1 R273.1 UCPU1.CN27
CPU_DP1_AUXN: CT26.2 UCPU1.AC7
CPU_DP1_AUXN_C: CT26.1 UT2.W11
CPU_DP1_AUXP: CT25.2 UCPU1.AC6
CPU_DP1_AUXP_C: CT25.1 UT2.Y11
CPU_DP1_CTRL_CLK: RC1.2 RT91.1 UCPU1.CC8
CPU_DP1_CTRL_DATA: RC3.2 RT92.1 UCPU1.CC9
CPU_DP1_HPD: RC4.1 UCPU1.CN6 UT2.AA2
CPU_DP1_N0: CT14.2 UCPU1.AL5
CPU_DP1_N0_C: CT14.1 UT2.AC7
CPU_DP1_N1: CT15.2 UCPU1.AJ5
CPU_DP1_N1_C: CT15.1 UT2.AC9
CPU_DP1_N2: CT24.2 UCPU1.AF6
CPU_DP1_N2_C: CT24.1 UT2.AC11
CPU_DP1_N3: CT18.2 UCPU1.AE5
CPU_DP1_N3_C: CT18.1 UT2.AC13
CPU_DP1_P0: CT13.2 UCPU1.AL6
CPU_DP1_P0_C: CT13.1 UT2.AB7
CPU_DP1_P1: CT23.2 UCPU1.AJ6
CPU_DP1_P1_C: CT23.1 UT2.AB9
CPU_DP1_P2: CT16.2 UCPU1.AF5
CPU_DP1_P2_C: CT16.1 UT2.AB11
CPU_DP1_P3: CT17.2 UCPU1.AE6
CPU_DP1_P3_C: CT17.1 UT2.AB13
CPU_DP2_AUXN: CT36.2 UCPU1.AD4
CPU_DP2_AUXN_C: CT36.1 UT2.W12
CPU_DP2_AUXP: CT35.2 UCPU1.AD3
CPU_DP2_AUXP_C: CT35.1 UT2.Y12
CPU_DP2_CTRL_CLK: RC5.2 RT93.2 UCPU1.CH4
CPU_DP2_CTRL_DATA: RC7.2 RT94.2 UCPU1.CH3
CPU_DP2_HPD: RC6.1 UCPU1.CM6 UT2.Y6
CPU_DP2_N0: CT28.2 UCPU1.AC4
CPU_DP2_N0_C: CT28.1 UT2.AC15
CPU_DP2_N1: CT30.2 UCPU1.AC1
CPU_DP2_N1_C: CT30.1 UT2.AC17
CPU_DP2_N2: CT32.2 UCPU1.AE4
CPU_DP2_N2_C: CT32.1 UT2.AC19
CPU_DP2_N3: CT34.2 UCPU1.AE1
CPU_DP2_N3_C: CT34.1 UT2.AC21
CPU_DP2_P0: CT27.2 UCPU1.AC3
CPU_DP2_P0_C: CT27.1 UT2.AB15
CPU_DP2_P1: CT29.2 UCPU1.AC2
CPU_DP2_P1_C: CT29.1 UT2.AB17
CPU_DP2_P2: CT31.2 UCPU1.AE3
CPU_DP2_P2_C: CT31.1 UT2.AB19
CPU_DP2_P3: CT33.2 UCPU1.AE2
CPU_DP2_P3_C: CT33.1 UT2.AB21
CPU_ID: CE116.1 RE533.2 UE1.F2
CPU_POPIRCOMP: RC106.1 UCPU1.BP27
CPU_XDP_PRDY#: JXDP1.5 UCPU1.W1
CPU_XDP_PREQ#: JXDP1.3 RC230.2 UCPU1.W2
CPU_XDP_TCK: RC228.1 RC244.2 UCPU1.T6
CPU_XDP_TDI: RC229.1 RC240.2 UCPU1.U6
CPU_XDP_TDO: RC227.1 RC242.2 UCPU1.Y5
CPU_XDP_TMS: RC231.1 RC239.2 UCPU1.T5
CPU_XDP_TRST#: RC217.2 RC232.1 UCPU1.AB6
CPVEE: CA10.1 UA1.25
CR_EN: RR13.2 RR14.2 UR2.3
CS_CORE1: PR917.1 PU900.5 PU1000.12
CS_CORE2: PR918.1 PU900.4 PU1001.12
CS_GT: PR921.1 PU900.1 PU1100.12
CS_SA: PR924.1 PU900.48 PU1101.10
CSSUMA: PR917.2 PR918.2 PU900.18
CSSUMB: PR921.2 PU900.19
CSSUMC: PR924.2 PU900.20
DAT_SMB: JBATT1.5 PR196.1
DAT_TP_SIO_I2C_CLK: RE468.2 UE1.C12
DBC_EN: RV17.1 UCPU1.CE28
DBC_EN_R: JCAM1.1 RV17.2 RV88.1
DCIN1_EN: PR166.1 UE1.L12
DCIN2_EN: PR126.1 UE1.K4
DDR_A0_ZQ0: RD20.1 UD4.B3
DDR_A0_ZQ1: RD19.1 UD4.B4
DDR_A1_ZQ0: RD1.1 UD2.B3
DDR_A1_ZQ1: RD2.1 UD2.B4
DDR_A_CA1_0: RD21.1 UCPU1.AB35 UD4.R2
DDR_A_CA1_1: RD23.1 UCPU1.W36 UD4.P2
DDR_A_CA1_2: RD25.1 UCPU1.AA37 UD4.N2
DDR_A_CA1_3: RD27.1 UCPU1.AB34 UD4.N3
DDR_A_CA1_4: RD29.1 UCPU1.AA36 UD4.M3
DDR_A_CA1_5: RD31.1 UCPU1.V34 UD4.F3
DDR_A_CA1_6: RD33.1 UCPU1.AA34 UD4.E3
DDR_A_CA1_7: RD35.1 UCPU1.W34 UD4.E2
DDR_A_CA1_8: RD37.1 UCPU1.V35 UD4.D2
DDR_A_CA1_9: RD39.1 UCPU1.W35 UD4.C2
DDR_A_CA2_0: RD41.1 UCPU1.AC32 UD2.R2
DDR_A_CA2_1: RD43.1 UCPU1.AB32 UD2.P2
DDR_A_CA2_2: RD45.1 UCPU1.AC31 UD2.N2
DDR_A_CA2_3: RD47.1 UCPU1.Y32 UD2.N3
DDR_A_CA2_4: RD49.1 UCPU1.W32 UD2.M3
DDR_A_CA2_5: RD51.1 UCPU1.AC34 UD2.F3
DDR_A_CA2_6: RD53.1 UCPU1.AB31 UD2.E3
DDR_A_CA2_7: RD55.1 UCPU1.Y31 UD2.E2
DDR_A_CA2_8: RD57.1 UCPU1.AC36 UD2.D2
DDR_A_CA2_9: RD59.1 UCPU1.AC37 UD2.C2
DDR_A_CKE0: RD65.1 UCPU1.U36 UD4.K3
DDR_A_CKE1: RD67.1 UCPU1.U37 UD4.K4
DDR_A_CKE2: RD69.1 UCPU1.U34 UD2.K3
DDR_A_CKE3: RD71.1 UCPU1.U35 UD2.K4
DDR_A_CLK0: RD75.1 UCPU1.V31 UD4.J3
DDR_A_CLK1: RD79.1 UCPU1.T31 UD2.J3
DDR_A_CLK#0: RD77.1 UCPU1.V32 UD4.J2
DDR_A_CLK#1: RD81.1 UCPU1.T32 UD2.J2
DDR_A_CS#0: RD61.1 UCPU1.AE32 UD2.L3 UD4.L3
DDR_A_CS#1: RD63.1 UCPU1.AF32 UD2.L4 UD4.L4
DDR_A_D0: UCPU1.A26 UD4.M10
DDR_A_D1: UCPU1.D26 UD4.M11
DDR_A_D2: UCPU1.D28 UD4.P9
DDR_A_D3: UCPU1.C28 UD4.N9
DDR_A_D4: UCPU1.B26 UD4.N11
DDR_A_D5: UCPU1.C26 UD4.N10
DDR_A_D6: UCPU1.B28 UD4.M8
DDR_A_D7: UCPU1.A28 UD4.M9
DDR_A_D8: UCPU1.B30 UD2.E11
DDR_A_D9: UCPU1.D30 UD2.E10
DDR_A_D10: UCPU1.B33 UD2.D9
DDR_A_D11: UCPU1.D32 UD2.F8
DDR_A_D12: UCPU1.A30 UD2.F10
DDR_A_D13: UCPU1.C30 UD2.F11
DDR_A_D14: UCPU1.B32 UD2.E9
DDR_A_D15: UCPU1.C32 UD2.F9
DDR_A_D16: UCPU1.J22 UD2.B9
DDR_A_D17: UCPU1.H25 UD2.C11
DDR_A_D18: UCPU1.G22 UD2.C8
DDR_A_D19: UCPU1.H22 UD2.C9
DDR_A_D20: UCPU1.F25 UD2.B11
DDR_A_D21: UCPU1.J25 UD2.C10
DDR_A_D22: UCPU1.G25 UD2.B10
DDR_A_D23: UCPU1.F22 UD2.B8
DDR_A_D24: UCPU1.D22 UD4.T9
DDR_A_D25: UCPU1.C22 UD4.T8
DDR_A_D26: UCPU1.C24 UD4.T11
DDR_A_D27: UCPU1.D24 UD4.R10
DDR_A_D28: UCPU1.A22 UD4.R9
DDR_A_D29: UCPU1.B22 UD4.R8
DDR_A_D30: UCPU1.A24 UD4.R11
DDR_A_D31: UCPU1.B24 UD4.T10
DDR_A_D32: UCPU1.H37 UD4.F10
DDR_A_D33: UCPU1.H34 UD4.F8
DDR_A_D34: UCPU1.K34 UD4.D9
DDR_A_D35: UCPU1.K35 UD4.E11
DDR_A_D36: UCPU1.H36 UD4.F11
DDR_A_D37: UCPU1.H35 UD4.F9
DDR_A_D38: UCPU1.K36 UD4.E10
DDR_A_D39: UCPU1.K37 UD4.E9
DDR_A_D40: UCPU1.N36 UD4.C10
DDR_A_D41: UCPU1.N34 UD4.C11
DDR_A_D42: UCPU1.R37 UD4.B8
DDR_A_D43: UCPU1.R34 UD4.C8
DDR_A_D44: UCPU1.N37 UD4.B11
DDR_A_D45: UCPU1.N35 UD4.B10
DDR_A_D46: UCPU1.R36 UD4.C9
DDR_A_D47: UCPU1.R35 UD4.B9
DDR_A_D48: UCPU1.G31 UD2.M10
DDR_A_D49: UCPU1.G32 UD2.M11
DDR_A_D50: UCPU1.H29 UD2.N9
DDR_A_D51: UCPU1.H28 UD2.P9
DDR_A_D52: UCPU1.G28 UD2.M8
DDR_A_D53: UCPU1.G29 UD2.M9
DDR_A_D54: UCPU1.H31 UD2.N10
DDR_A_D55: UCPU1.H32 UD2.N11
DDR_A_D56: UCPU1.L31 UD2.T11
DDR_A_D57: UCPU1.L32 UD2.T10
DDR_A_D58: UCPU1.N29 UD2.T8
DDR_A_D59: UCPU1.N28 UD2.R8
DDR_A_D60: UCPU1.L28 UD2.R11
DDR_A_D61: UCPU1.L29 UD2.R10
DDR_A_D62: UCPU1.N31 UD2.R9
DDR_A_D63: UCPU1.N32 UD2.T9
DDR_A_DQS0: UCPU1.D27 UD4.L10
DDR_A_DQS1: UCPU1.C31 UD2.G10
DDR_A_DQS2: UCPU1.G24 UD2.D10
DDR_A_DQS3: UCPU1.D23 UD4.P10
DDR_A_DQS4: UCPU1.J34 UD4.G10
DDR_A_DQS5: UCPU1.P35 UD4.D10
DDR_A_DQS6: UCPU1.H30 UD2.L10
DDR_A_DQS7: UCPU1.N30 UD2.P10
DDR_A_DQS#0: UCPU1.C27 UD4.L11
DDR_A_DQS#1: UCPU1.D31 UD2.G11
DDR_A_DQS#2: UCPU1.H24 UD2.D11
DDR_A_DQS#3: UCPU1.C23 UD4.P11
DDR_A_DQS#4: UCPU1.J35 UD4.G11
DDR_A_DQS#5: UCPU1.P34 UD4.D11
DDR_A_DQS#6: UCPU1.G30 UD2.L11
DDR_A_DQS#7: UCPU1.L30 UD2.P11
DDR_A_ODT0: RD73.1 UCPU1.AE31 UD2.J8 UD4.J8
DDR_B0_ZQ0: RD13.1 UD3.B3
DDR_B0_ZQ1: RD14.1 UD3.B4
DDR_B1_ZQ0: RD8.1 UD1.B3
DDR_B1_ZQ1: RD7.1 UD1.B4
DDR_B_CA1_0: RD22.1 UCPU1.AF35 UD3.R2
DDR_B_CA1_1: RD24.1 UCPU1.AB29 UD3.P2
DDR_B_CA1_2: RD26.1 UCPU1.AE37 UD3.N2
DDR_B_CA1_3: RD28.1 UCPU1.AE36 UD3.N3
DDR_B_CA1_4: RD30.1 UCPU1.AC29 UD3.M3
DDR_B_CA1_5: RD32.1 UCPU1.W29 UD3.F3
DDR_B_CA1_6: RD34.1 UCPU1.AB28 UD3.E3
DDR_B_CA1_7: RD36.1 UCPU1.AC28 UD3.E2
DDR_B_CA1_8: RD38.1 UCPU1.W28 UD3.D2
DDR_B_CA1_9: RD40.1 UCPU1.Y28 UD3.C2
DDR_B_CA2_0: RD42.1 UCPU1.AK35 UD1.R2
DDR_B_CA2_1: RD44.1 UCPU1.AK34 UD1.P2
DDR_B_CA2_2: RD46.1 UCPU1.AJ35 UD1.N2
DDR_B_CA2_3: RD48.1 UCPU1.AJ34 UD1.N3
DDR_B_CA2_4: RD50.1 UCPU1.AJ37 UD1.M3
DDR_B_CA2_5: RD52.1 UCPU1.AF34 UD1.F3
DDR_B_CA2_6: RD54.1 UCPU1.AJ36 UD1.E3
DDR_B_CA2_7: RD56.1 UCPU1.AG34 UD1.E2
DDR_B_CA2_8: RD58.1 UCPU1.AG35 UD1.D2
DDR_B_CA2_9: RD60.1 UCPU1.AG36 UD1.C2
DDR_B_CKE0: RD66.1 UCPU1.T28 UD3.K3
DDR_B_CKE1: RD68.1 UCPU1.T29 UD3.K4
DDR_B_CKE2: RD70.1 UCPU1.V28 UD1.K3
DDR_B_CKE3: RD72.1 UCPU1.V29 UD1.K4
DDR_B_CLK0: RD76.1 UCPU1.AF29 UD3.J3
DDR_B_CLK1: RD80.1 UCPU1.AE29 UD1.J3
DDR_B_CLK#0: RD78.1 UCPU1.AF28 UD3.J2
DDR_B_CLK#1: RD82.1 UCPU1.AE28 UD1.J2
DDR_B_CS#0: RD62.1 UCPU1.AL37 UD1.L3 UD3.L3
DDR_B_CS#1: RD64.1 UCPU1.AL35 UD1.L4 UD3.L4
DDR_B_D0: UCPU1.AN35 UD1.T9
DDR_B_D1: UCPU1.AN34 UD1.R8
DDR_B_D2: UCPU1.AR35 UD1.T10
DDR_B_D3: UCPU1.AR34 UD1.R11
DDR_B_D4: UCPU1.AN37 UD1.R9
DDR_B_D5: UCPU1.AN36 UD1.T8
DDR_B_D6: UCPU1.AR36 UD1.R10
DDR_B_D7: UCPU1.AR37 UD1.T11
DDR_B_D8: UCPU1.AU35 UD1.N11
DDR_B_D9: UCPU1.AU34 UD1.P9
DDR_B_D10: UCPU1.AW35 UD1.M11
DDR_B_D11: UCPU1.AW34 UD1.M8
DDR_B_D12: UCPU1.AU37 UD1.N10
DDR_B_D13: UCPU1.AU36 UD1.N9
DDR_B_D14: UCPU1.AW36 UD1.M9
DDR_B_D15: UCPU1.AW37 UD1.M10
DDR_B_D16: UCPU1.AJ29 UD3.B9
DDR_B_D17: UCPU1.AJ30 UD3.C8
DDR_B_D18: UCPU1.AM32 UD3.B10
DDR_B_D19: UCPU1.AM31 UD3.C10
DDR_B_D20: UCPU1.AM30 UD3.B11
DDR_B_D21: UCPU1.AM29 UD3.C11
DDR_B_D22: UCPU1.AJ31 UD3.C9
DDR_B_D23: UCPU1.AJ32 UD3.B8
DDR_B_D24: UCPU1.AR31 UD3.E9
DDR_B_D25: UCPU1.AR32 UD3.E10
DDR_B_D26: UCPU1.AV30 UD3.F9
DDR_B_D27: UCPU1.AV29 UD3.F8
DDR_B_D28: UCPU1.AR30 UD3.D9
DDR_B_D29: UCPU1.AR29 UD3.E11
DDR_B_D30: UCPU1.AV32 UD3.F11
DDR_B_D31: UCPU1.AV31 UD3.F10
DDR_B_D32: UCPU1.BA35 UD1.D9
DDR_B_D33: UCPU1.BA34 UD1.F8
DDR_B_D34: UCPU1.BC35 UD1.F11
DDR_B_D35: UCPU1.BC34 UD1.E10
DDR_B_D36: UCPU1.BA37 UD1.E9
DDR_B_D37: UCPU1.BA36 UD1.F9
DDR_B_D38: UCPU1.BC36 UD1.F10
DDR_B_D39: UCPU1.BC37 UD1.E11
DDR_B_D40: UCPU1.BE35 UD1.B11
DDR_B_D41: UCPU1.BE34 UD1.C10
DDR_B_D42: UCPU1.BG35 UD1.B9
DDR_B_D43: UCPU1.BG34 UD1.B8
DDR_B_D44: UCPU1.BE37 UD1.B10
DDR_B_D45: UCPU1.BE36 UD1.C11
DDR_B_D46: UCPU1.BG36 UD1.C8
DDR_B_D47: UCPU1.BG37 UD1.C9
DDR_B_D48: UCPU1.BA32 UD3.M9
DDR_B_D49: UCPU1.BA31 UD3.N9
DDR_B_D50: UCPU1.BD31 UD3.M10
DDR_B_D51: UCPU1.BD32 UD3.M11
DDR_B_D52: UCPU1.BA30 UD3.P9
DDR_B_D53: UCPU1.BA29 UD3.M8
DDR_B_D54: UCPU1.BD29 UD3.N10
DDR_B_D55: UCPU1.BD30 UD3.N11
DDR_B_D56: UCPU1.BG31 UD3.T11
DDR_B_D57: UCPU1.BG32 UD3.R10
DDR_B_D58: UCPU1.BK32 UD3.T9
DDR_B_D59: UCPU1.BK31 UD3.R9
DDR_B_D60: UCPU1.BG29 UD3.R11
DDR_B_D61: UCPU1.BG30 UD3.T10
DDR_B_D62: UCPU1.BK30 UD3.T8
DDR_B_D63: UCPU1.BK29 UD3.R8
DDR_B_DQS0: UCPU1.AP34 UD1.P10
DDR_B_DQS1: UCPU1.AV35 UD1.L10
DDR_B_DQS2: UCPU1.AL30 UD3.D10
DDR_B_DQS3: UCPU1.AU30 UD3.G10
DDR_B_DQS4: UCPU1.BB34 UD1.G10
DDR_B_DQS5: UCPU1.BF35 UD1.D10
DDR_B_DQS6: UCPU1.BC30 UD3.L10
DDR_B_DQS7: UCPU1.BH30 UD3.P10
DDR_B_DQS#0: UCPU1.AP35 UD1.P11
DDR_B_DQS#1: UCPU1.AV34 UD1.L11
DDR_B_DQS#2: UCPU1.AL31 UD3.D11
DDR_B_DQS#3: UCPU1.AU31 UD3.G11
DDR_B_DQS#4: UCPU1.BB35 UD1.G11
DDR_B_DQS#5: UCPU1.BF34 UD1.D11
DDR_B_DQS#6: UCPU1.BC31 UD3.L11
DDR_B_DQS#7: UCPU1.BH31 UD3.P11
DDR_B_ODT0: RD74.1 UCPU1.AL36 UD1.J8 UD3.J8
DDR_CHA_EN: RC499.2 RC501.2 UCPU1.CK19
DDR_CHB_EN: RC500.2 RC502.2 UCPU1.CG17
DDR_PG: PU600.18 RE457.2
DDR_VTT_CNTL: RC383.1 UC9.2 UCPU1.C35
DDR_XDP_SMBCLK: JXDP1.53 QC1.1 RC388.2 RC489.1
DDR_XDP_SMBDAT: JXDP1.51 QC1.4 RC387.2 RC488.1
DEBUG_TX: JDEG1.9 RE93.2 RE97.2
DISPOFF#: DC8.1 JEDP1.31 RV16.1 RV83.2
DMIC_CLK: CA35.1 DV6.1 JEDP1.6 RA23.1 RV66.2
DMIC_CLK0: RC565.2 UCPU1.CP24
DMIC_CLK_UA1: RA23.2 UA1.5
DMIC_DATA0: RC566.2 UCPU1.CN24
DMIC_DATA12: CA34.1 DV7.1 JEDP1.5 RA21.1 RV67.2
DMIC_DATA_UA1: RA21.2 UA1.4
DPSNK1_DDC_CLK: RT82.1 RT93.1 UT2.Y8
DPSNK_RBIAS: RT23.1 UT2.Y18
DPSRC_RBIAS: RT9.1 UT2.N6
EC_TOUCHPAD_INTR#: Q3.3 RE522.1 UE1.G2
EC_TP_DISABLE#: Q13.6 RE516.1 RP13.1 UE1.N12
EC_TP_I2C_CLK: RE468.1 RP5.1
EC_TP_I2C_DAT: RE467.1 RP4.1
EDP_AUXN: CV17.1 RV96.1 UCPU1.AH4
EDP_AUXN_R: CV17.2 JEDP1.33
EDP_AUXP: CV18.1 RV97.1 UCPU1.AH3
EDP_AUXP_R: CV18.2 JEDP1.34
EDP_BIA_PWM: DV3.3 UCPU1.CH11
EDP_HPD: RC2.1 RV70.1 UCPU1.CM7
EDP_HPD_EC: RV71.1 UE1.J10
EDP_HPD_R: JEDP1.11 RV70.2 RV71.2
EDP_RCOMP: RC8.2 UCPU1.AM6
EDP_TEST_SCL: JEDP1.21 TV1.1(TP-1)
EDP_TEST_SDA: JEDP1.22 TV2.1(TP-1)
EDP_TXN0: CV5.1 UCPU1.AG4
EDP_TXN0_R: CV5.2 JEDP1.37
EDP_TXN1: CV7.1 UCPU1.AG2
EDP_TXN1_R: CV7.2 JEDP1.40
EDP_TXP0: CV6.1 UCPU1.AG3
EDP_TXP0_R: CV6.2 JEDP1.36
EDP_TXP1: CV8.1 UCPU1.AG1
EDP_TXP1_R: CV8.2 JEDP1.39
EDRAM_OPIO_RCOMP: RC108.1 UCPU1.L5
EMMC_RCOMP: RC10.1 UCPU1.CK15
EN_1.0VA: CC253.1 PU800.11 RC574.2
EN_1.8V_PRIM: CC254.1 PU500.11 RC575.2
EN_INVPWR: QV11.5 RE153.1 UE1.B2
EN_INVPWR_R: CV16.2 QV10.3 RV80.1 RV81.2
EN_PD_HV1: PR157.1 PR1204.2 PR1432.1 PRB36.1 PTB2.1(TP-1) RT103.2
EN_PD_HV2: PR120.1 PR199.2 PR1431.1 PRB37.1 RT120.2
EN_PRIM_CORE: CC255.1 PU1401.5 RC576.2
EN_VCCIO: C88.1 PU1400.5 R249.2
ENABLE_DS#: RE163.2 RE166.1 UE1.L2
ENVDD: RV3.1 RV92.2 UV1.3
ENVDD_PCH: CC259.1 DV1.2 UCPU1.CG11
EOPIO_RCOMP: RC109.1 UCPU1.N5
ESPI_ALERT#: RC24.2 UCPU1.BV28 UE1.H7
ESPI_CLK: RC19.1 UCPU1.BV32
ESPI_CLK_5105: CC2.1 JESPI1.10 RC19.2 RE180.1 UE1.G7
ESPI_CS#: JESPI1.7 UCPU1.CA28 UE1.H6
ESPI_IO0: JESPI1.3 RC366.2 UE1.K5
ESPI_IO0_R: RC366.1 UCPU1.CA29
ESPI_IO1: JESPI1.4 RC367.2 UE1.L4
ESPI_IO1_R: RC367.1 UCPU1.BY29
ESPI_IO2: JESPI1.5 RC368.2 UE1.G6
ESPI_IO2_R: RC368.1 UCPU1.BY27
ESPI_IO3: JESPI1.6 RC369.2 UE1.L5
ESPI_IO3_R: RC369.1 UCPU1.BV27
ESPI_RESET#: RC614.1 RE99.2 UCPU1.CA27 UE1.K6
F4_LED: JKB1.32 RK11.2
F4_LED#: QK4.3 UK1.42
F4_LED#_R: CK13.1 QK4.1 QK5.2 RK12.2
F4_LED_R: QK5.1 RK11.1
FAULT_EVENT: PD1504.1 PD1505.1 PQ1506.2 PR1519.2 RE536.2
FB_1.0V: PC806.2 PR803.2 PR806.1 PU800.14
FB_1.2V_DDR: PC609.2 PR605.2 PR606.1 PU600.16
FP_USB+: JUSH1.5 R279.1
FP_USB-: JUSH1.4 R278.1
FPR_DET#: D3.4 D3.7 JFP1.16 RE121.1 UE1.D9
FPR_LP_MODE#: Q14.3 RE489.1 UE1.K12
FPR_LP_MODE#_R: JFP1.6 Q14.4 R218.2
FPR_PWR_EN#: R258.1 RE526.1 UE1.M11
FPR_RESET#: JFP1.5 JUSH1.2 R220.1
FPR_SCAN_INT#: D3.5 D3.6 JFP1.2 JUSH1.21 Q15.4 R221.2
FPR_SCAN_INT#_EC: Q15.3 RE530.1 UE1.L8
FPR_SSO_EN#: Q15.6 RE490.1 UE1.H9
FPR_UEFI_MGMT#: Q14.6 RE488.1 UE1.K9
GPIO043: RE536.1 UE1.J12
GPIO_5_AUDIO_0: JLTE1.3 JLTE2.3 JNGFF1.20 T148.1(TP-1)
GPIO_6_AUDIO_1: JNGFF1.22 QN12.1 RN115.2
GPIO_7_AUDIO_2: JLTE1.2 JLTE2.4 JNGFF1.24 T147.1(TP-1)
GPP_A7: RC632.2 UCPU1.CC32
GPP_B15: RC626.2 UCPU1.CC27
GPP_B22: RC46.1 UCPU1.CA30
GPP_B23: RC29.1 UCPU1.CC34
GPP_C2: RC26.1 RC606.1 UCPU1.CJ15
GPP_C5: RC27.1 RC397.1 UCPU1.CG15
GPP_D12: RC608.1 RC609.1 UCPU1.CP22
GPP_H17: RC464.2 UCPU1.CP26
GPP_H21: RC443.1 RC444.1 UCPU1.CF25
GPP_H23: RC445.1 RC446.1 UCPU1.CM26
GPS_DISABLE#: QN8.6 RE118.1 UE1.H5
GPS_DISABLE#_R: JNGFF1.26 QN8.1
GT_B+: PC1100.1 PC1101.1 PC1102.1 PC1103.1 PC1104.1 PC1117.1 PC1118.1 PC1119.1 PL1103.2 PL1104.2 PU1100.1 PU1100.8
H_CATERR#: RC219.2 UCPU1.AA4
H_CPU_SVIDALRT#: RC155.1 UCPU1.AA3
H_CPUPWRGD: CC199.1 RC85.2 UCPU1.AR2
H_PROCHOT#: PR217.1 PR600.2 PR920.1 RC220.1 RC221.2 RE161.2
H_PROCHOT#_R: RC220.2 UCPU1.Y4
H_THERMTRIP#: QE5.3 RC222.1
H_THERMTRIP#_R: RC218.2 RC222.2 UCPU1.BJ1
HDA_BIT_CLK: CC13.1 RC112.2 RC613.2 UCPU1.BN37
HDA_BIT_CLK_R: CA28.1 RC112.1 UA1.14
HDA_RST#: CC17.1 RC559.2 RC615.2 UCPU1.BL35
HDA_RST#_R: RA117.1 RC559.1
HDA_SDIN0: CA154.1 RA16.2 UCPU1.BN35
HDA_SDIN0_R: RA16.1 UA1.16
HDA_SDOUT: CC15.1 RC113.2 RC511.1 UCPU1.BN36
HDA_SDOUT_R: RC113.1 UA1.17
HDA_SYNC: RC111.2 UCPU1.BN34
HDA_SYNC_R: RC111.1 UA1.15
HDMI_CEC: JHDMI1.13 RM98.2
HDMI_CLKN: CM20.2 RM31.1 RM99.1
HDMI_CLKP: CM18.2 RM33.1 RM100.1
HDMI_CTRL_CLK: JHDMI1.15 QM1.3 RM95.2
HDMI_CTRL_DATA: JHDMI1.16 QM1.6 RM94.2
HDMI_HPD: JHDMI1.19 QM2.1 RM97.1
HDMI_OB: QM3.1 RM99.2 RM100.2 RM101.2 RM102.2 RM103.2 RM104.2 RM105.2 RM106.2
HDMI_R_CLKN: DM4.1 JHDMI1.12 RM31.2 RM32.1
HDMI_R_CLKP: DM5.1 JHDMI1.10 RM32.2 RM33.2
HDMI_R_TX_N0: DM3.1 JHDMI1.9 RM34.2 RM35.1
HDMI_R_TX_N1: DM2.1 JHDMI1.6 RM37.2 RM38.1
HDMI_R_TX_N2: DM1.1 JHDMI1.3 RM40.2 RM41.1
HDMI_R_TX_P0: DM8.1 JHDMI1.7 RM35.2 RM36.2
HDMI_R_TX_P1: DM7.1 JHDMI1.4 RM38.2 RM39.2
HDMI_R_TX_P2: DM6.1 JHDMI1.1 RM41.2 RM42.2
HDMI_TX_N0: CM17.2 RM34.1 RM101.1
HDMI_TX_N1: CM15.2 RM37.1 RM103.1
HDMI_TX_N2: CM7.2 RM40.1 RM105.1
HDMI_TX_P0: CM16.2 RM36.1 RM102.1
HDMI_TX_P1: CM14.2 RM39.1 RM104.1
HDMI_TX_P2: CM6.2 RM42.1 RM106.1
HOST_DEBUG_TX: JDEG1.8 RE92.2 RE96.2 UE1.G11
HOST_SD_WP#: QR1.2 RC38.1 UCPU1.CH35
HPOL_CONN: CA47.1 DA5.2 JHP1.1 LA3.2
HPOR_CONN: CA46.1 DA4.2 JHP1.2 LA4.2
HPOUT-L: CA9.1 CA42.2 RA30.1 UA1.27
HPOUT-L_L: CA45.1 LA3.1 RA30.2
HPOUT-R: CA8.1 CA43.2 RA31.1 UA1.26
HPOUT-R_L: CA44.1 LA4.1 RA31.2
HRESET_PD1: RT160.1 UT1.D6
HRESET_PD2: RT148.1 UT5.D6
I2C1_SCK_TP: RP3.1 UCPU1.CJ12
I2C1_SDA_TP: RP14.1 UCPU1.CK12
I_ADP: PR234.1 UE1.B11
I_BATT: PR233.1 RE123.2
I_BATT_R: CE18.1 RE123.1 UE1.J4
I_SYS: PR229.1 PR232.1 PR934.1 RE125.2
I_SYS_R: CE19.1 RE125.1 RE148.1 UE1.J5
IA1_B+: PC1000.1 PC1001.1 PC1002.1 PC1003.1 PC1004.1 PC1008.1 PC1013.1 PL1001.2 PL1002.2 PR900.1 PR1567.2 PU1000.1 PU1000.8
IA2_B+: PC1010.1 PC1011.1 PC1015.1 PC1016.1 PC1017.1 PC1018.1 PC1019.1 PC1421.1 PC1422.1 PC1423.1 PC1424.1 PL1003.2 PL1005.2 PR1568.2 PU1001.1 PU1001.8
ILMT_1.0V: PR807.2 PR808.1 PU800.13
IMON_GT: PC910.2 PR941.2 PU900.22
IMON_IA: PC909.2 PR939.2 PU900.21
IMON_SA: PC911.2 PR942.2 PU900.23
IMVP_SMBCLK: PR916.1 RE111.1 UE1.F7
IMVP_SMBDAT: PR919.1 RE110.1 UE1.B6
IMVP_VR_ADDR: PR930.2 PR931.2 PU900.25
IMVP_VR_IREF: PR936.2 PU900.24
IMVP_VR_ON: R241.1 RE499.1 U10.1 UE1.N7
IMVP_VR_ON_EN: PU900.37 R243.2
IMVP_VR_ON_P: R241.2 R242.1 R243.1 U7.2 U10.4
IMVP_VR_PE: PR935.2 PR937.2 PU900.36
IMVP_VR_PG: PU900.30 RC433.2 UC10.1
IMVP_VR_PSYS: PC905.2 PR932.2 PR934.2 PU900.46
IMVP_VR_SLP_S0#: PR910.2 PR911.2 PU900.35
IMVP_VR_SMBCLK: PR909.2 PR916.2 PU900.33
IMVP_VR_SMBDAT: PR908.2 PR919.2 PU900.32
IMVP_VR_SVID_ALERT#: PR926.2 PU900.29
IMVP_VR_SVID_ALERT#_R: PR914.2 PR925.2 PR926.1
IMVP_VR_SVID_CLK: PR923.2 PU900.27
IMVP_VR_SVID_CLK_R: PR913.2 PR922.2 PR923.1
IMVP_VR_SVID_DATA: PR928.2 PU900.28
IMVP_VR_SVID_DATA_R: PR915.2 PR927.2 PR928.1
IMVP_VR_VDD18: PC901.1 PR901.1 PU900.26
IMVP_VR_VDD33: PC902.1 PR902.2 PU900.44
IMVP_VR_VINSEN: PC900.1 PR900.2 PR905.1 PU900.47
IMVP_VR_VRHOT#: PR912.2 PR920.2 PU900.31
INPUT3VSEL: RC451.1 RC452.1 UCPU1.BT27
INTRUDER#: RC78.1 UCPU1.BR35
ISH_ACC1_INT#: JEDP1.29 RC546.1 UCPU1.BW35
ISH_ACC2_INT#: RC548.1 UCPU1.BW34 UV5.12
ISH_ALS_INT#: JCAM1.11 RC545.1 UCPU1.CA36
ISH_I2C0_SCL: RC556.1 RV53.1 RV62.1 UCPU1.CH20
ISH_I2C0_SCL_EDP: DV4.1 JEDP1.25 RV62.2
ISH_I2C0_SCL_R: RV53.2 UV5.1
ISH_I2C0_SDA: RC555.1 RV52.1 RV63.1 UCPU1.CK22
ISH_I2C0_SDA_EDP: DV5.1 JEDP1.26 RV63.2
ISH_I2C0_SDA_R: RV52.2 UV5.4
ISH_I2C1_SCL: RS11.2 UCPU1.CJ22
ISH_I2C1_SDA: RS12.2 UCPU1.CH22
ISH_LID_CL#_NB: DC6.1 DE7.2 RC633.1 U33.2 UCPU1.CA34
ISH_LID_CL#_TAB: DE8.2 RC634.1 UCPU1.BW37
ISH_NB_MODE#: QN12.6 RC549.1 RE480.2 UCPU1.CA35
ISH_P_SENSOR_INT#: JCAM1.5 RC547.1 UCPU1.BW36
ISH_TABLE_MODE#: RC550.1 RC551.1 UCPU1.CA37 UE1.J8
JACK_PLUG: DA26.1 JHP1.6 RA29.2
JACK_PLUG#: CA36.1 RA22.1 RA29.1 UA1.48
JD2: RA124.2 UA1.47
JHP1_GND: JHP1.7 RA125.2
JTAG_CLK: JDEG1.4 RE210.2 UE1.C8
JTAG_RST#: CE26.1 CLEC1.1 RE162.2 RE164.1 UE1.G13
JTAG_TDI: JDEG1.2 RE212.2 UE1.E9
JTAG_TDO: JDEG1.5 RE209.2 UE1.F6
JTAG_TMS: JDEG1.3 RE211.2 UE1.C5
KB_ADDR: RK8.2 UK1.28
KB_BL_DET: JBL1.4 RK4.2 UK1.39
KB_DET#: JKB1.1 RC41.2 UCPU1.CK25
KB_LED_PWM: QK1.2 UK1.40
KB_LED_PWM#: JBL1.3 QK1.1
KB_TEST: RK9.2 TK1.1(TP-1) UK1.29
KSI0: JKB1.9 UK1.18
KSI1: JKB1.7 UK1.20
KSI2: JKB1.5 UK1.23
KSI3: JKB1.8 UK1.19
KSI4: JKB1.4 UK1.25
KSI5: JKB1.6 UK1.22
KSI6: JKB1.3 UK1.26
KSI7: JKB1.2 UK1.27
KSO00: JKB1.18 UK1.11
KSO01: JKB1.16 UK1.13
KSO02: JKB1.17 UK1.12
KSO03: JKB1.15 UK1.14
KSO04: JKB1.11 UK1.16
KSO05: JKB1.10 UK1.17
KSO06: JKB1.13 UK1.15
KSO11: JKB1.12 UK1.5
KSO12: JKB1.14 UK1.10
KSO13: JKB1.24 UK1.7
KSO14: JKB1.26 UK1.6
KSO15: JKB1.25 UK1.8
KSO16: JKB1.19 UK1.9
KSO17: JKB1.22 UK1.3
KSO18: JKB1.23 UK1.2
KSO19: JKB1.21 UK1.1
KSO20: JKB1.20 UK1.47
LAN_WAKE#: RC74.2 UCPU1.BU32 UE1.L3
LCD_CBL_DET#: JEDP1.32 RC617.1 UCPU1.CF12
LCD_SELF_TEST: JCAM1.2 RV86.2 RV87.1
LCD_TST: RV86.1 UE1.M2
LCD_VCC_TEST_EN: DV1.3 UE1.E1
LCDVDD_MONITOR: QV7.2 RV47.1
LDO2_CAP: CA18.1 UA1.21
LDO3_CAP: CA19.1 UA1.19
LDO_1.0V: PC811.1 PU800.16 PU800.17
LDO_IN: CT201.1 DT47.1 DT48.1 DT49.1 RT296.1 UT16.1
LED_MASK#: R274.2 U33.1 UE1.A12
LID_CL#_NB: DE7.1 RE193.1 ULID1.B2
LID_CL#_TAB: DE8.1 RE484.1 ULID1.A2
LID_CL_SIO#: CE37.1 RE192.2 RE193.2 UE1.N11
LID_CL_SIO_TAB#: CE115.1 RE484.2 RE525.2 UE1.E12
LIMT_1.2V_DDR: PR604.2 PR607.1 PU600.17
LINE2-L: CA42.1 UA1.36
LINE2-R: CA43.1 UA1.35
LP_PRIM_CORE: PR1414.2 PR1415.2 PU1401.6
LP_VCCIO: PR1400.2 PR1401.2 PR1430.2 PU1400.6
LX_1.0V: PC803.2 PL801.1 PR800.1 PU800.6 PU800.19 PU800.20
LX_1.2V_DDR: PC605.2 PL601.1 PR602.1 PU600.11
LX_1.8VPRIM: PC500.2 PL500.1 PR506.1 PR510.1 PU500.6
LX_CORE1: PC1006.2 PL1000.1 PR1003.1 PU1000.2 PU1000.3 PU1000.4
LX_CORE2: PC1021.2 PL1004.1 PR1012.1 PU1001.2 PU1001.3 PU1001.4
LX_GT: PC1106.2 PL1100.1 PR1103.1 PU1100.2 PU1100.3 PU1100.4
LX_PRIM_CORE: PC1410.1 PL1403.1 PR1417.1 PU1401.8
LX_SA: PC1115.2 PL1102.1 PR1106.1 PU1101.2 PU1101.3
LX_VCCIO: PC1420.1 PL1401.1 PR1407.1 PU1400.8
M2280_DEVSLP: JNGFF2.38 RN23.1 UCPU1.CM8
M2280_PCIE_SATA#: RC585.1 RN26.1 UCPU1.CP10
M_BIST: R271.1 UE1.N8
M_BIST_R: C92.1 D481.2 QZ21.2 R271.2 R272.2 R283.2
ME_EN: RC511.2 RC512.2 SW3.2
ME_FWP: RC512.1 SW3.3 UE1.G12
MEC_XTAL1: CE31.1 UE1.A1 YE1.1
MEC_XTAL2: RE179.1 UE1.A3
MEC_XTAL2_R: CE32.1 RE179.2 YE1.2
MEDIACARD_IRQ#: RC17.2 RR8.1 UCPU1.CG20
MEM_CONFIG0: RH51.2 RH52.1 UCPU1.CR20
MEM_CONFIG1: RH53.2 RH54.1 UCPU1.CM20
MEM_CONFIG2: RH55.2 RH56.1 UCPU1.CN19
MEM_CONFIG3: RH57.2 RH58.1 UCPU1.CM19
MEM_CONFIG4: RH59.2 RH60.1 UCPU1.CN18
MEM_INTERLEAVED: RC583.1 RC584.1 UCPU1.CE9
MEM_SMBCLK: QC1.6 RC18.1 RC388.1 UCPU1.CK14
MEM_SMBDATA: QC1.3 RC20.1 RC387.1 UCPU1.CH15
MIC2-VREFO-L: RA33.1 UA1.28
MIC2-VREFO-R: RA34.1 UA1.29
MIPI_CLK: JLTE1.4 JLTE2.2 JNGFF1.58 T149.1(TP-1)
MIPI_DATA: JLTE1.5 JLTE2.1 JNGFF1.56 T150.1(TP-1)
MODE_PRIM_CORE: PR1413.1 PU1401.7
MODE_VCCIO: PR1408.1 PU1400.7
MONO_IN: CA1.2 UA1.34
MSCLK: JDEG1.6 RE91.2 RE97.1 UE1.H10
MSDATA: JDEG1.7 RE94.2 RE95.1 UE1.G9
NB_MODE#: RE480.1 UE1.J6
NB_MUTE#: DA27.1 RA117.2 RA120.1 UE1.A4
NFC_ACTIVITY_STATUS#: JUSH1.25 Q13.3 RP12.1
NFC_STATUS#: DP2.1 JTP1.8 Q13.4 RP9.2 RP12.2 RP16.2
NGFF_CONFIG_0: JNGFF1.21 RE502.1 UE1.N9
NGFF_CONFIG_1: JNGFF1.69 RE504.1 UE1.M10 UN1.9
NGFF_CONFIG_2: JNGFF1.75 RE501.1 UE1.N10
NGFF_CONFIG_3: JNGFF1.1 RE503.1 UE1.F4
NRB_BIT: RC45.1 RC607.1 UCPU1.CE29
OT_1.2V_DDR: PR600.1 PU600.19
OVP_FAULT: PD1503.2 PD1504.2 PQ1500.2 PU1500.1
P_SENSOR_PWR_SAVE#: JCAM1.4 RC596.2 UCPU1.CP12
PA_USB2_RBIAS: RT42.1 UT2.H19
PANEL_BKEN_EC: DV2.3 UE1.J9
PANEL_BKLEN: CC258.1 DV2.2 UCPU1.CK11 UCPU1.CM35
PANEL_PWRGD: RV42.2 UE1.M8
PANEL_PWRGD_R: CV39.1 QV5.1 QV7.1 RV40.2 RV42.1 RV44.1
PB_USB2_RBIAS: RT43.1 UT2.F19
PBAT_CHARGER_SMBCLK: PD104.2 PR195.2 PR214.1 RE109.1 UE1.N2
PBAT_CHARGER_SMBDAT: PD104.3 PR196.2 PR213.1 RE108.1 UE1.M3
PBAT_PRES#: QE26.1 RE518.2 UE1.F9
PCH_3.3V_TS_EN: R223.1 UCPU1.CC30
PCH_BATLOW#: RC80.1 UCPU1.BV36
PCH_CL_CLK1: JNGFF3.42 UCPU1.CH7
PCH_CL_DATA1: JNGFF3.40 UCPU1.CH8
PCH_CL_RST1#: JNGFF3.38 UCPU1.CH9
PCH_DMIC_CLK0: CC247.1 RC565.1 RV66.1
PCH_DMIC_DATA0: CC246.1 RC566.1 RV67.1
PCH_DPWROK: CC12.1 RC90.1 RC92.1 RE112.1 UCPU1.BP30
PCH_DPWROK_EC: RE112.2 UE1.F8
PCH_JTAG_TCK: RC238.1 RC258.2 UCPU1.W6
PCH_JTAG_TDI: RC234.1 RC254.2 UCPU1.U5
PCH_JTAG_TDO: RC233.1 RC255.2 UCPU1.W5
PCH_JTAG_TMS: RC235.1 RC252.2 UCPU1.P5
PCH_JTAG_TRST#: RC236.1 UCPU1.Y6
PCH_JTAGX: RC237.1 RC257.2 UCPU1.P6
PCH_PCIE_WAKE#: RC73.2 RE189.2 RT187.2 RT289.1 UCPU1.BU30 UE1.L1
PCH_PLTRST#: RC77.1 UC2.1 UC2.2 UCPU1.BJ35
PCH_PLTRST#_5105: RE186.2 UE4.4
PCH_PLTRST#_AND: JNGFF2.50 JNGFF3.52 LED_RST.1 RC76.1 RC523.2 RE98.2 RN113.1 RT190.2 RT285.1 UC2.4 UE4.2 UN5.1 UR1.1 UZ6.17
PCH_POPIRCOMP: RC107.1 UCPU1.BW25
PCH_PRIM_EN: R208.1 RC574.1 RC575.1 RC576.1 RC599.2 RC630.2 U12.5
PCH_PWROK: RC381.1 UC10.4 UCPU1.BP31
PCH_RSMRST#: RE513.2 UE1.M5
PCH_RSMRST#_AND: R272.1 RC90.2 RC250.1 RC568.1 RE513.1 UCPU1.BR36
PCH_RTCRST#: CC11.1 CLCMOS1.1 JAPS1.9 RB35.2 RC71.1 UCPU1.BR34
PCH_RTCX1: RC403.1 UCPU1.BN31
PCH_RTCX1_R: CC8.1 RC66.1 RC403.2 YC2.1
PCH_RTCX2: RC404.1 UCPU1.BN32
PCH_RTCX2_R: CC10.1 RC66.2 RC404.2 YC2.2
PCH_SPI_CLK: RC466.2 RC481.2 UCPU1.CH37
PCH_SPI_CLK_R: JSPI1.4 RC466.1 RC474.2 RZ29.1
PCH_SPI_CLK_TPM: RZ29.2 RZ32.2 UZ6.19
PCH_SPI_CS0#: RC471.2 UCPU1.CG36
PCH_SPI_CS0#_R: JSPI1.5 RC471.1 U27.1 UC18.1
PCH_SPI_CS1#: RC472.2 UCPU1.CG35
PCH_SPI_CS1#_R: JSPI1.1 RC472.1
PCH_SPI_CS2#: RZ30.1 UCPU1.CH34
PCH_SPI_CS2#_TPM: RZ30.2 UZ6.20
PCH_SPI_IO2: RC469.2 RC483.1 RC486.1 UCPU1.CF34
PCH_SPI_IO2_R: JSPI1.6 RC243.2 RC469.1 RC476.2
PCH_SPI_IO3: RC470.2 RC484.1 RC487.1 UCPU1.CG34
PCH_SPI_IO3_R: JSPI1.7 RC470.1 RC477.2
PCH_SPI_SI: RC468.2 RC482.1 RC485.1 UCPU1.CF36
PCH_SPI_SI_R: JSPI1.2 RC241.1 RC468.1 RC473.2 RZ28.1
PCH_SPI_SI_TPM: RZ28.2 UZ6.21
PCH_SPI_SO: RC467.2 UCPU1.CF37
PCH_SPI_SO_R: JSPI1.3 RC467.1 RC475.2 RZ27.1
PCH_SPI_SO_TPM: RZ27.2 UZ6.24
PCH_TBT_PERST#: RC395.2 RC503.2 RT183.2 RT284.1 UCPU1.CR14
PCIE_PRX_C_DTX_N1: CR17.2 UR1.8
PCIE_PRX_C_DTX_N9: CT4.2 UT2.V22
PCIE_PRX_C_DTX_N10: CT21.2 UT2.P22
PCIE_PRX_C_DTX_N11: CT8.2 UT2.K22
PCIE_PRX_C_DTX_N12: CT12.2 UT2.F22
PCIE_PRX_C_DTX_N13: JNGFF2.5 RN57.2
PCIE_PRX_C_DTX_N14: JNGFF2.17 RN59.2
PCIE_PRX_C_DTX_N15: JNGFF2.29 RN61.2
PCIE_PRX_C_DTX_N16: JNGFF2.43 RN64.2
PCIE_PRX_C_DTX_P1: CR6.2 UR1.7
PCIE_PRX_C_DTX_P9: CT2.2 UT2.V23
PCIE_PRX_C_DTX_P10: CT19.2 UT2.P23
PCIE_PRX_C_DTX_P11: CT6.2 UT2.K23
PCIE_PRX_C_DTX_P12: CT10.2 UT2.F23
PCIE_PRX_C_DTX_P13: JNGFF2.7 RN58.2
PCIE_PRX_C_DTX_P14: JNGFF2.19 RN60.2
PCIE_PRX_C_DTX_P15: JNGFF2.31 RN62.2
PCIE_PRX_C_DTX_P16: JNGFF2.41 RN63.2
PCIE_PRX_DTX_N1: CR17.1 UCPU1.CB5
PCIE_PRX_DTX_N6: JNGFF3.43 UCPU1.BU6
PCIE_PRX_DTX_N7: UCPU1.BT7 UN1.12
PCIE_PRX_DTX_N8: RN101.1 UCPU1.BU9
PCIE_PRX_DTX_N9: CT4.1 UCPU1.BP5
PCIE_PRX_DTX_N10: CT21.1 UCPU1.BN6
PCIE_PRX_DTX_N11: CT8.1 UCPU1.BN10
PCIE_PRX_DTX_N12: CT12.1 UCPU1.BL6
PCIE_PRX_DTX_N13: RN57.1 UCPU1.BK6
PCIE_PRX_DTX_N14: RN59.1 UCPU1.BJ6
PCIE_PRX_DTX_N15: RN61.1 UCPU1.BG5
PCIE_PRX_DTX_N16: RN64.1 UCPU1.BE5
PCIE_PRX_DTX_P1: CR6.1 UCPU1.CB6
PCIE_PRX_DTX_P6: JNGFF3.41 UCPU1.BU5
PCIE_PRX_DTX_P7: UCPU1.BT6 UN1.13
PCIE_PRX_DTX_P8: RN102.1 UCPU1.BU8
PCIE_PRX_DTX_P9: CT2.1 UCPU1.BP6
PCIE_PRX_DTX_P10: CT19.1 UCPU1.BN5
PCIE_PRX_DTX_P11: CT6.1 UCPU1.BN8
PCIE_PRX_DTX_P12: CT10.1 UCPU1.BL5
PCIE_PRX_DTX_P13: RN58.1 UCPU1.BK5
PCIE_PRX_DTX_P14: RN60.1 UCPU1.BJ5
PCIE_PRX_DTX_P15: RN62.1 UCPU1.BG6
PCIE_PRX_DTX_P16: RN63.1 UCPU1.BE6
PCIE_PRX_R_DTX_N8: JNGFF1.41 RN101.2
PCIE_PRX_R_DTX_P8: JNGFF1.43 RN102.2
PCIE_PTX_C_DRX_N1: CR22.2 UR1.4
PCIE_PTX_C_DRX_N6: CN40.2 JNGFF3.37
PCIE_PTX_C_DRX_N7: CN16.2 UN1.14
PCIE_PTX_C_DRX_N8: CN19.2 RN103.1
PCIE_PTX_C_DRX_N9: CT3.1 UT2.Y22
PCIE_PTX_C_DRX_N10: CT20.1 UT2.T22
PCIE_PTX_C_DRX_N11: CT7.1 UT2.M22
PCIE_PTX_C_DRX_N12: CT11.1 UT2.H22
PCIE_PTX_C_DRX_N13: CN49.2 JNGFF2.11
PCIE_PTX_C_DRX_N14: CN51.2 JNGFF2.23
PCIE_PTX_C_DRX_N15: CN53.2 JNGFF2.35
PCIE_PTX_C_DRX_N16: CN55.2 JNGFF2.47
PCIE_PTX_C_DRX_P1: CR21.2 UR1.3
PCIE_PTX_C_DRX_P6: CN39.2 JNGFF3.35
PCIE_PTX_C_DRX_P7: CN17.2 UN1.15
PCIE_PTX_C_DRX_P8: CN20.2 RN104.1
PCIE_PTX_C_DRX_P9: CT1.1 UT2.Y23
PCIE_PTX_C_DRX_P10: CT5.1 UT2.T23
PCIE_PTX_C_DRX_P11: CT22.1 UT2.M23
PCIE_PTX_C_DRX_P12: CT9.1 UT2.H23
PCIE_PTX_C_DRX_P13: CN50.2 JNGFF2.13
PCIE_PTX_C_DRX_P14: CN52.2 JNGFF2.25
PCIE_PTX_C_DRX_P15: CN54.2 JNGFF2.37
PCIE_PTX_C_DRX_P16: CN56.2 JNGFF2.49
PCIE_PTX_DRX_N1: CR22.1 UCPU1.CA4
PCIE_PTX_DRX_N6: CN40.1 UCPU1.BU4
PCIE_PTX_DRX_N7: CN16.1 UCPU1.BU2
PCIE_PTX_DRX_N8: CN19.1 UCPU1.BT4
PCIE_PTX_DRX_N9: CT3.2 UCPU1.BR2
PCIE_PTX_DRX_N10: CT20.2 UCPU1.BR4
PCIE_PTX_DRX_N11: CT7.2 UCPU1.BN4
PCIE_PTX_DRX_N12: CT11.2 UCPU1.BN2
PCIE_PTX_DRX_N13: CN49.1 UCPU1.BM4
PCIE_PTX_DRX_N14: CN51.1 UCPU1.BL2
PCIE_PTX_DRX_N15: CN53.1 UCPU1.BL4
PCIE_PTX_DRX_N16: CN55.1 UCPU1.BJ4
PCIE_PTX_DRX_P1: CR21.1 UCPU1.CA3
PCIE_PTX_DRX_P6: CN39.1 UCPU1.BU3
PCIE_PTX_DRX_P7: CN17.1 UCPU1.BU1
PCIE_PTX_DRX_P8: CN20.1 UCPU1.BT3
PCIE_PTX_DRX_P9: CT1.2 UCPU1.BR1
PCIE_PTX_DRX_P10: CT5.2 UCPU1.BR3
PCIE_PTX_DRX_P11: CT22.2 UCPU1.BN3
PCIE_PTX_DRX_P12: CT9.2 UCPU1.BN1
PCIE_PTX_DRX_P13: CN50.1 UCPU1.BM3
PCIE_PTX_DRX_P14: CN52.1 UCPU1.BL1
PCIE_PTX_DRX_P15: CN54.1 UCPU1.BL3
PCIE_PTX_DRX_P16: CN56.1 UCPU1.BJ3
PCIE_PTX_R_DRX_N8: JNGFF1.47 RN103.2
PCIE_PTX_R_DRX_P8: JNGFF1.49 RN104.2
PCIE_RCOMPN: RC50.1 UCPU1.CE6
PCIE_RCOMPP: RC50.2 UCPU1.CE5
PCIE_WAKE#: JNGFF3.55 RE188.2 RE189.1 RN24.2 RN112.1 RT27.1 RT186.2 RT290.1 UN4.3
PCIE_WAKE#_AR: RT185.1 RT186.1 RT187.1 RT188.1 RT292.2 UT2.W1
PCIE_WAKE#_AR_R: RT292.1 RT293.1 UT15.4
PCIE_WAKE#_R: RE124.1 RE188.1 UE1.N13
PD1_GPIO0: RT271.1 UT1.B2
PD1_GPIO1: RT103.1 UT1.C2
PD1_GPIO2: RT152.1 UT1.D10
PD1_GPIO4: RT104.1 UT1.C10
PD1_GPIO5: RT269.1 UT1.E10
PD1_GPIO6: RT268.1 UT1.G10
PD1_GPIO7: RT105.1 UT1.D7
PD1_GPIO8: RT107.1 UT1.H6
PD1_GPIO8_EXT: RT107.2 RT155.2 RT159.1
PD1_HOLD#: RT102.2 UT4.7
PD1_LPS1: PQ119.6 PR149.2 PR165.2 PR1508.2
PD1_LPS2: PQ115.5 PQ116.5 PR183.1
PD1_ROM_CLK: RT172.1 UT4.6
PD1_ROM_CLK_R: RT172.2 UT1.A3
PD1_ROM_CS#: RT99.2 RT171.1 UT4.1
PD1_ROM_CS#_R: RT171.2 UT1.B3
PD1_ROM_DI: RT169.1 UT4.5
PD1_ROM_DI_R: RT169.2 UT1.B4
PD1_ROM_DO: RT100.2 RT170.1 UT4.2
PD1_ROM_DO_R: RT170.2 UT1.A4
PD1_ROM_WP#: RT101.2 UT4.3
PD2_GPIO0: RT272.1 UT5.B2
PD2_GPIO1: RT120.1 UT5.C2
PD2_GPIO2: RT163.1 UT5.D10
PD2_GPIO4: RT121.1 UT5.C10
PD2_GPIO5: RT274.1 UT5.E10
PD2_GPIO6: RT275.1 UT5.G10
PD2_GPIO7: RT122.1 UT5.D7
PD2_GPIO8: RT124.1 UT5.H6
PD2_GPIO8_EXT: RT124.2 RT147.1 RT165.2
PD2_LPS1: PQ105.6 PR110.2 PR125.2 PR1510.2
PD2_LPS2: PQ100.5 PQ101.5 PR181.1
PD2_ROM_CLK: RT178.2 UT5.A3
PD2_ROM_CS#: RT177.2 UT5.B3
PD2_ROM_DI: RT179.2 UT5.B4
PD2_ROM_DO: RT180.2 UT5.A4
PECI_EC: RE151.2 UCPU1.AR1
PECI_EC_R: RE151.1 UE1.K13
PG_PRIM_CORE: PR1425.1 PU1401.13 RE167.2
PG_VCCIO: PR1402.1 PU1400.13 RE508.2
PM_SYS_RESET#: RC87.1 RC89.1 RC248.2
POWER_SW_IN#: CE35.1 QZ21.3 RE187.2 RE190.2 UE1.D5
PRIM_PWRGD: LED_PRI.1 RE182.1 UE1.L7
PRIM_PWRGD_R: RE165.1 RE167.1 RE182.2 RE473.2 RE507.1
PROCHOT#_R1: RE161.1 UE1.H13
PS_SMBCLK: Q12.1 RS6.2 RS11.1 U16.A1
PS_SMBDAT: Q12.4 RS7.2 RS12.1 U16.B1
PSENSOR_CS0: CS12.1 JLTE1.1 LS3.1 T146.1(TP-1)
PSENSOR_CS2: CS15.1 JLTE2.5 LS6.1
PWM1_IA: PR903.1 PU900.43
PWM2_IA: PR904.1 PU900.42
PWM5_GT: PR906.1 PU900.39
PWM6_SA: PR907.1 PU900.38
PWM_CORE1: PR903.2 PU1000.9
PWM_CORE2: PR904.2 PU1001.9
PWM_FAN1: JFAN1.2 R24.2 UE1.L10
PWM_GT: PR906.2 PU1100.9
PWM_SA: PR907.2 PU1101.7
PWR_DEBUG#_XDP: JXDP1.45 RC256.2 RC521.2
PWR_LED#: QN11.1 R20.1
PWR_LED#_R: JPTN1.2 R20.2
PWRBTN#: CE34.1 DE4.1 JAPS1.11 JPTN1.3 JUSH1.1 PU700.1 RE190.1 SW2.1 SW2.2
PWRGD_XDP: JXDP1.39 RC250.2 RC371.2
REFCLK_CNV: L3.2 RN55.2
REFCLK_CNV_L: CC260.1 L3.1 RC531.1 UCPU1.CM3
REFCLK_CNV_R: JNGFF3.64 RN55.1 RN79.1
REM_DIODE1_N: CE22.1 CE57.2 CE58.2 QE12.3 QE14.1 QE14.2 UE1.A8
REM_DIODE1_P: CE22.2 CE57.1 CE58.1 QE12.1 QE12.2 QE14.3 UE1.A7
REM_DIODE2_N: CE23.1 CE55.2 CE69.2 QE8.1 QE8.2 QE17.3 UE1.A10
REM_DIODE2_P: CE23.2 CE55.1 CE69.1 QE8.3 QE17.1 QE17.2 UE1.A9
REM_DIODE3_N: CE60.2 CE112.1 JEDP1.28 QE23.1 QE23.2 UE1.B9
REM_DIODE3_P: CE60.1 CE112.2 JEDP1.27 QE23.3 UE1.B8
RESET_IN#: RE138.2 UE1.C1
RESET_OUT: RE158.2 UE1.G4
RESET_OUT#_R: CC89.1 JXDP1.47 RC241.2 RC370.2 RC522.2
RING2: CA48.1 LA6.1 RA33.2 UA1.30
RING2_CONN: CA150.1 DA8.2 JHP1.4 LA6.2
RREF: RR10.2 UR1.9
RTCRST_ON: QB6.5 RB34.1 UE1.F11
RTCRST_ON_POWER: RB24.2 UE1.B13
RTCRST_ON_R: CB17.1 DB5.2 QB6.2 RB23.2
RTD3_CIO_PWR_EN: RT19.1 RT34.1 RT304.1 UCPU1.CN26 UT2.F1
RTD3_SELECT: RT291.1 UE1.F13 UT15.6
RTD3_USB_PWR_EN: RT35.1 UT2.D4
RUN_ON_EC: RE500.1 U11.2 UE1.E8
RUN_ON_P: QE1.2 R247.1 R250.2 R268.1 R282.1 U6.3 U6.5 U19.3 U32.2
RUN_ON_P#: QE1.1 QE10.2 QE11.2 RE177.2
RUN_ON_R: R238.1 R249.1 R250.1 U11.4
RUNPWROK: LED_RUN.1 RE478.1 UC10.2 UE1.G3
SA_B+: PC1108.1 PC1109.1 PC1110.1 PC1111.1 PC1112.1 PC1113.1 PL1101.2 PU1101.1 PU1101.6
SAR_ACT#: RS10.2 UE1.K7
SAR_DPR#: QN7.6 RE521.1 UE1.M4
SAR_DPR_R: JNGFF1.25 QN7.1 RN3.2
SBIOS_TX: RE96.1 UCPU1.CP14
SD_CD#: RR12.2 UR1.30
SD_CD#_R: JCR1.9 RR12.1
SD_CLK: RR4.1 UR1.17
SD_CLK_R: CR8.1 JCR1.5 RR4.2
SD_CMD: RR5.1 UR1.19
SD_CMD_R: JCR1.3 RR5.2
SD_D0: RR3.1 UR1.16
SD_D0_R: JCR1.7 RR3.2
SD_D1: RR2.1 UR1.15
SD_D1_R: JCR1.8 RR2.2
SD_D2: RR7.1 UR1.21
SD_D2_R: JCR1.1 RR7.2
SD_D3: RR6.1 UR1.20
SD_D3_R: JCR1.2 RR6.2
SD_LN0_M: JCR1.19 UR1.25
SD_LN0_P: JCR1.18 UR1.26
SD_LN1_M: JCR1.21 UR1.23
SD_LN1_P: JCR1.22 UR1.22
SD_RCOMP: RC116.1 UCPU1.CK33 UCPU1.CM34
SD_REG2: CR13.1 UR1.24
SENSOR_DET#: JEDP1.24 RE532.2
SENSOR_DET#_R: RE532.1 RE535.1 UE1.H8
SIO_EXT_WAKE#: RC40.1 RE482.1 UCPU1.CG12
SIO_EXT_WAKE#_EC: RE482.2 UE1.M12
SIO_PWRBTN#: RC247.1 UCPU1.BU28 UE1.K11
SIO_SLP_A#: CC250.2 JAPS1.6 RC571.2 UCPU1.BU37
SIO_SLP_S0#: JAPS1.15 PR911.1 PR1401.1 PR1415.1 RC582.2 RZ21.2 RZ23.1 RZ37.1 UCPU1.BJ37
SIO_SLP_S3#: CC248.2 JAPS1.2 QE4.2 R280.1 R281.1 RC569.2 U10.2 U11.1 UCPU1.BU36 UT2.D2
SIO_SLP_S4#: CC249.2 RC570.2 RC621.1 UC19.1 UCPU1.BU27
SIO_SLP_S4#_AND: DC7.1 JAPS1.5 JUSH1.3 R248.1 RC612.1 RC621.2 RC622.1 RC625.2 U12.3 UC19.4
SIO_SLP_S5#: JAPS1.4 RC577.2 UCPU1.BT29
SIO_SLP_SUS#: CC252.2 RC573.2 RC599.1 RE115.1 UCPU1.BU29
SIO_SLP_SUS#_R: RE113.1 RE115.2 UE1.N4
SIO_SLP_WLAN#: CC251.2 QN2.1 QN6.3 RC572.2 UCPU1.BT30
SKTOCC#: RC223.2 UCPU1.E1
SLEEVE: CA49.1 LA5.1 RA34.2 UA1.31
SLEEVE_CONN: CA151.1 DA9.2 JHP1.3 LA5.2
SLP_LAN#: T11.1(TP-1) UCPU1.BT31
SLP_WLAN#_GATE: QN2.2 RN70.2 UE1.K10
SM_PG_CTRL: PU600.2 RC383.2 RE241.2 UC9.4
SM_RCOMP0: RC11.1 UCPU1.BN28
SM_RCOMP1: RC12.1 UCPU1.BN27
SM_RCOMP2: RC13.1 UCPU1.BN29
SML0_SMBCLK: RC580.1 UCPU1.CH14
SML0_SMBDATA: RC581.1 UCPU1.CF15
SML0B_SMBCLK: RC595.1 UCPU1.CN23
SML0B_SMBDATA: RC594.1 UCPU1.CM24
SML1_SMBCLK: RC23.1 UCPU1.CN15 UE1.D8
SML1_SMBDATA: RC25.1 UCPU1.CM15 UE1.E11
SMOKE_OVP: PR1503.1 PR1514.2
SMOKE_UVP: PD1500.1 PD1501.1 PR1501.1 PR1505.2
SNK0_CONFIG1: RT83.1 RT94.1 UT2.N4
SNUB_1.0V: PC800.1 PR800.2
SNUB_1.8VPRIM: PC512.1 PR506.2
SNUB_CHG1: PC236.2 PR215.2
SNUB_CHG2: PC237.1 PR216.2
SNUB_CORE1: PC1007.1 PR1003.2
SNUB_CORE2: PC1022.1 PR1012.2
SNUB_GT: PC1107.1 PR1103.2
SNUB_PRIM_CORE: PC1411.1 PR1417.2
SNUB_SA: PC1116.1 PR1106.2
SNUB_VCCIO: PC1408.1 PR1407.2
SOLC: RV23.1 UE1.N6
SOLC_R: JCAM1.3 RV23.2 RV85.1
SP7_SDWP: QR1.1 UR1.29
SPI_CLK_VROM0: RC474.1 U27.6 UC18.6
SPI_IO2_VROM0: RC476.1 U27.3 UC18.3
SPI_IO3_VROM0: RC477.1 U27.7 UC18.7
SPI_SI_VROM0: RC473.1 U27.5 UC18.5
SPI_SO_VROM0: RC475.1 U27.2 UC18.2
SPK-L+: LA8.1 UA1.42
SPK-L-: LA7.1 UA1.43
SPK-R+: LA10.1 UA1.45
SPK-R-: LA9.1 UA1.44
SPK_DET#: RA109.1 UCPU1.CK34
SPK_DET#_R: JSPK1.5 RA109.2 RA110.2
SPK_OUT_L+: CA85.1 DA11.1 JSPK1.4 LA8.2
SPK_OUT_L-: CA84.1 DA10.1 JSPK1.3 LA7.2
SPK_OUT_R+: CA87.1 DA13.1 JSPK1.1 LA10.2
SPK_OUT_R-: CA86.1 DA12.1 JSPK1.2 LA9.2
SPKR: RA7.1 RC118.1 UCPU1.CF35
SRTCRST#: CC9.1 CLME1.2 RC68.1 UCPU1.BR37
SSD_EN: R268.2 U8.3 U32.4
SSD_PCIE_WAKE#: JNGFF2.54 RN24.1 RN25.1
SSD_SCP#: RE141.1 RN98.2 UE1.L6
SSD_SCP#_R: JNGFF2.8 RN98.1
SSD_SCP_PWR_EN: R267.1 U32.1 UE1.M1
SSD_SUSCLK: JNGFF2.68 RN27.1
SSO_EN#_R: JFP1.1 Q15.1 R219.2
SUS_ON_EC: RC625.1 RE534.2 UC19.2
SUS_ON_EC_R: RE534.1 UE1.D2
SUSCLK: RC57.1 RN13.2 RN27.2 RN48.2 UCPU1.BT32
SX9310_CS0: RS8.2 RS9.2 U16.A3
SX9310_CS0_R: LS3.2 RS8.1
SX9310_CS2: RS15.2 U16.B3
SX9310_CS2_R: LS6.2 RS15.1
SYNC: PR1002.1 PR1011.1 PR1102.1 PR1107.1 PU900.34
SYNC_CORE1: PR1002.2 PU1000.10
SYNC_CORE2: PR1011.2 PU1001.10
SYNC_GT: PR1102.2 PU1100.10
SYNC_SA: PR1107.2 PU1101.8
SYS_PRES#: JBATT1.7 PR705.1 PU700.5
SYS_PWROK: RC370.1 RE147.1 RE158.1 UCPU1.CR10
SYS_RESET#: JAPS1.13 RC88.2 RC89.2 UCPU1.CN10
SYSPWR_PRES: RE149.2 RE155.1 UE1.B1
TACH_FAN1: DE6.2 R23.2 UE1.E3
TACH_FAN1_D: DE6.1 JFAN1.3 R229.2
TBT_A_AUX_N: CT49.2 RT114.2 UT1.J2
TBT_A_AUX_N_C: CT49.1 UT2.W15
TBT_A_AUX_P: CT47.2 RT115.2 UT1.J1
TBT_A_AUX_P_C: CT47.1 UT2.Y15
TBT_A_CC1: CT181.1 DT27.2 JUSBC1.B5 UT1.K9 UT1.L9
TBT_A_CC2: CT180.1 DT14.1 JUSBC1.A5 UT1.K10 UT1.L10
TBT_A_DBG_CTL1: RT106.2 UT1.E4
TBT_A_DBG_CTL2: RT108.2 UT1.D5
TBT_A_DEBUG1: RT53.2 RT109.2 UT1.L2
TBT_A_DEBUG2: RT54.2 RT111.2 UT1.K2
TBT_A_DEBUG3: RT118.2 RT262.2 UT1.L3
TBT_A_DEBUG4: RT119.2 RT263.2 UT1.K3
TBT_A_HPD: RT36.1 RT104.2 UT2.M4
TBT_A_I2C_B_N: LT9.1 UT1.L7
TBT_A_I2C_B_N_R: DT22.1 JUSBC1.A7 LT9.2
TBT_A_I2C_B_P: LT9.4 UT1.K7
TBT_A_I2C_B_P_R: DT18.1 JUSBC1.A6 LT9.3
TBT_A_I2C_INT#: RT31.1 UT1.C1 UT2.J4
TBT_A_LSRX: RT38.1 RT117.1 RT119.1 UT2.A4
TBT_A_LSRX_R: RT117.2 UT1.K4
TBT_A_LSTX: RT37.1 RT116.1 RT118.1 UT2.A5
TBT_A_LSTX_R: RT116.2 UT1.L4
TBT_A_MRESET: RT112.1 UT1.E11
TBT_A_RESET_N: RT17.2 UT1.F11
TBT_A_SBU1: DT15.2 JUSBC1.B8 UT1.K8
TBT_A_SBU2: DT26.1 JUSBC1.A8 UT1.L8
TBT_A_TRX_DTX_N1: DT30.1 JUSBC1.A10 UT2.A21
TBT_A_TRX_DTX_N2: DT11.2 JUSBC1.B10 UT2.B15
TBT_A_TRX_DTX_P1: DT34.1 JUSBC1.A11 UT2.B21
TBT_A_TRX_DTX_P2: DT7.2 JUSBC1.B11 UT2.A15
TBT_A_TTX_C_DRX_N1: CT45.2 DT31.2 JUSBC1.B3
TBT_A_TTX_C_DRX_N2: CT41.2 DT10.1 JUSBC1.A3
TBT_A_TTX_C_DRX_P1: CT43.2 DT35.2 JUSBC1.B2
TBT_A_TTX_C_DRX_P2: CT39.2 DT6.1 JUSBC1.A2
TBT_A_TTX_DRX_N1: CT45.1 UT2.B19
TBT_A_TTX_DRX_N2: CT41.1 UT2.B17
TBT_A_TTX_DRX_P1: CT43.1 UT2.A19
TBT_A_TTX_DRX_P2: CT39.1 UT2.A17
TBT_A_USB2_T_N: LT11.1 UT1.L6
TBT_A_USB2_T_N_R: DT19.2 JUSBC1.B7 LT11.2
TBT_A_USB2_T_P: LT11.4 UT1.K6
TBT_A_USB2_T_P_R: DT23.2 JUSBC1.B6 LT11.3
TBT_A_VBUS_L: CT179.1 CT197.1 LT3.1 UT1.A10 UT1.B10 UT1.H11 UT1.J10 UT1.J11 UT1.K11
TBT_B_AUX_N: CT50.2 RT138.2 UT5.J2
TBT_B_AUX_N_C: CT50.1 UT2.W16
TBT_B_AUX_P: CT48.2 RT140.2 UT5.J1
TBT_B_AUX_P_C: CT48.1 UT2.Y16
TBT_B_CC1: CT193.1 DT25.2 JUSBC2.B5 UT5.K9 UT5.L9
TBT_B_CC2: CT192.1 DT12.1 JUSBC2.A5 UT5.K10 UT5.L10
TBT_B_DBG_CTL1: RT123.2 UT5.E4
TBT_B_DBG_CTL2: RT125.2 UT5.D5
TBT_B_DEBUG1: RT126.2 RT265.2 UT5.L2
TBT_B_DEBUG2: RT128.2 RT266.2 UT5.K2
TBT_B_DEBUG3: RT59.2 RT143.2 UT5.L3
TBT_B_DEBUG4: RT60.2 RT144.2 UT5.K3
TBT_B_HPD: RT39.1 RT121.2 UT2.G2
TBT_B_I2C_B_N: LT10.1 UT5.L7
TBT_B_I2C_B_N_R: DT20.1 JUSBC2.A7 LT10.2
TBT_B_I2C_B_P: LT10.4 UT5.K7
TBT_B_I2C_B_P_R: DT16.1 JUSBC2.A6 LT10.3
TBT_B_I2C_INT#: RT189.1 UT2.E2 UT5.C1
TBT_B_LSRX: RT41.1 RT142.1 RT144.1 UT2.B5
TBT_B_LSRX_R: RT142.2 UT5.K4
TBT_B_LSTX: RT40.1 RT141.1 RT143.1 UT2.B4
TBT_B_LSTX_R: RT141.2 UT5.L4
TBT_B_RESET_N: RT15.2 UT5.F11
TBT_B_SBU1: DT13.2 JUSBC2.B8 UT5.K8
TBT_B_SBU2: DT24.1 JUSBC2.A8 UT5.L8
TBT_B_TRX_DTX_N1: DT28.1 JUSBC2.A10 UT2.B13
TBT_B_TRX_DTX_N2: DT9.2 JUSBC2.B10 UT2.A7
TBT_B_TRX_DTX_P1: DT32.1 JUSBC2.A11 UT2.A13
TBT_B_TRX_DTX_P2: DT42.2 JUSBC2.B11 UT2.B7
TBT_B_TTX_C_DRX_N1: CT46.2 DT29.2 JUSBC2.B3
TBT_B_TTX_C_DRX_N2: CT42.2 DT8.1 JUSBC2.A3
TBT_B_TTX_C_DRX_P1: CT44.2 DT33.2 JUSBC2.B2
TBT_B_TTX_C_DRX_P2: CT40.2 DT4.1 JUSBC2.A2
TBT_B_TTX_DRX_N1: CT46.1 UT2.B11
TBT_B_TTX_DRX_N2: CT42.1 UT2.B9
TBT_B_TTX_DRX_P1: CT44.1 UT2.A11
TBT_B_TTX_DRX_P2: CT40.1 UT2.A9
TBT_B_USB2_T_N: LT12.1 UT5.L6
TBT_B_USB2_T_N_R: DT21.2 JUSBC2.B7 LT12.2
TBT_B_USB2_T_P: LT12.4 UT5.K6
TBT_B_USB2_T_P_R: DT17.2 JUSBC2.B6 LT12.3
TBT_B_VBUS_L: CT191.1 CT200.1 LT4.1 UT5.A10 UT5.B10 UT5.H11 UT5.J10 UT5.J11 UT5.K11
TBT_BATLOW#: RC560.2 RT30.1 UCPU1.CJ25 UT2.F2
TBT_CIO_PLUG_EVENT#: RT29.1 RT305.1 UCPU1.CL36 UT2.W2
TBT_DP0_N0: CM7.1 CM52.1 UT2.R1
TBT_DP0_P0: CM6.1 CM52.2 UT2.R2
TBT_DP1_CLK: QM1.4 RT11.1 UT2.Y2
TBT_DP1_DATA: QM1.1 RT13.1 UT2.Y1
TBT_DP1_N1: CM15.1 CM51.1 UT2.N1
TBT_DP1_P1: CM14.1 CM51.2 UT2.N2
TBT_DP2_N2: CM17.1 CM50.1 UT2.L1
TBT_DP2_P2: CM16.1 CM50.2 UT2.L2
TBT_DP3_N3: CM20.1 CM49.1 UT2.J1
TBT_DP3_P3: CM18.1 CM49.2 UT2.J2
TBT_DP_HPD: QM2.3 RM96.2 RT8.2
TBT_FORCE_PWR: RT33.1 UCPU1.CG25 UT2.H4
TBT_I2C_CLK: RT26.1 UT1.D2 UT2.U2 UT5.D2
TBT_I2C_DATA: RT25.1 UT1.D1 UT2.U1 UT5.D1
TBT_JTAG_TCK: RT4.2 UT2.T4
TBT_JTAG_TDI: RT6.2 UT2.Y4
TBT_JTAG_TDO: RT3.2 UT2.W4
TBT_JTAG_TMS: RT5.2 UT2.V4
TBT_PCIE_RBIAS: RT7.1 UT2.N16
TBT_PERST#: RT183.1 RT190.1 RT287.2 UT2.L4
TBT_PERST#_R: RT287.1 RT288.1 UT14.4
TBT_RBIAS: RT28.1 UT2.H6
TBT_RESET_N_EC: RE154.1 RT69.2 UE1.D1
TBT_RESET_N_R: RT14.1 RT15.1 RT17.1 RT69.1 UT2.F4
TBT_ROM_CLK: UT2.AB4 UT3.6
TBT_ROM_CS#: RT45.2 UT2.AC3 UT3.1
TBT_ROM_DI: UT2.AB3 UT3.5
TBT_ROM_DO: RT46.2 UT2.AC4 UT3.2
TBT_ROM_HOLD#: RT44.2 UT3.7
TBT_ROM_WP#: RT47.2 UT2.V1 UT3.3
TBT_RSENSE: RT28.2 UT2.J6
TBT_RTD3_WAKE#: RC454.1 RC465.1 RT188.2 RT294.1 UCPU1.BV35
TBT_SNK0_DDC_CLK: RT80.1 RT91.2 UT2.Y5
TBT_SNK0_DDC_DATA: RT81.1 RT92.2 UT2.R4
TBT_SRC_CFG1: RT97.1 RT295.1 UT2.AA1
TBT_SRC_HPD: RT8.1 RT98.1 UT2.G1
TBT_SVR_IND: CT169.1 CT170.1 LT1.1 UT2.C1 UT2.C2 UT2.D1
TBT_TEST_EN: RT18.1 UT2.E1
TBT_TEST_PWRG: RT21.1 UT2.AB5
TBT_TMU_CLK_OUT: CT141.1 RT32.1 UT2.V2
THERMTRIP1#: RE122.1 UE1.B12
THERMTRIP2#: CE41.1 QE5.1 RE197.2 UE1.H3
TOUCH_SCREEN_PD#: DC5.1 RC516.1 RC517.1 UCPU1.CN3
TOUCH_SCREEN_PD#_R: DC5.2 DC6.2 DC8.2 JEDP1.19 RC517.2
TOUCHPAD_INTR#: Q3.6 RC518.2 UCPU1.CB34
TOUCHPAD_INTR#_R: JTP1.6 Q3.1 Q3.4 RP15.2
TP_DISABLE#: DP1.1 JTP1.7 Q13.1 RP8.2 RP13.2 RP16.1
TP_EN: R246.1 UE1.L9
TP_EN_R: R28.1 R246.2 U15.3
TP_I2C_DAT: DP4.1 JTP1.3 RP4.2 RP6.1 RP14.2
TP_I2C_SCL: DP3.1 JTP1.4 RP3.2 RP5.2 RP7.1
TPM_GPIO0: RZ37.2 UZ6.6
TPM_GPIO0_NU: RZ23.2 UZ6.29
TPM_PIRQ#: RZ19.2 UCPU1.CC29 UZ6.18
TS_I2C_SCL: RV21.1 UCPU1.CN11
TS_I2C_SCL_R: JEDP1.16 RV21.2 RV57.1
TS_I2C_SDA: RV20.1 UCPU1.CM11
TS_I2C_SDA_R: JEDP1.15 RV20.2 RV58.1
TS_INT#: RC463.2 RV19.1 UCPU1.CM12
TS_INT#_R: JEDP1.17 RV19.2 RV60.2
TS_RST#: RC564.2 RC626.1 RV15.2
TS_RST#_R: JEDP1.18 RV15.1
UART_MISO: RT151.2 UT1.F2 UT5.E2
UART_MOSI: RT153.2 UT1.E2 UT5.F2
UEFI_MGMT#_R: JFP1.4 Q14.1 R217.2
UI2_A_DE0: RI40.1 UI2.16
UI2_A_DE1: RI44.1 UI2.18
UI2_A_EQ0: RI42.1 UI2.17
UI2_A_EQ1: RI38.1 UI2.15
UI2_B_DE0: RI74.1 UI2.3
UI2_B_DE1: RI78.1 UI2.6
UI2_B_EQ0: RI76.1 UI2.2
UI2_B_EQ1: RI72.1 UI2.4
UI2_I2C_EN: RI30.2 UI2.24
UI2_PD#: RI68.2 UI2.5
UI2_REXT: RI29.2 UI2.7
UI2_TEST: RI101.2 UI2.14
UI4_ILIM_SEL1: RI53.2 UI4.4
UI5_ILIM_SEL1: RI64.2 UI5.4
UIM_CLK: CS1.1 CS6.1 DS1.1 DS1.9 JNGFF1.32 JSIM1.C3
UIM_DATA: CS3.1 CS5.1 DS1.4 DS1.7 JNGFF1.34 JSIM1.C7 RS1.2
UIM_DET: JNGFF1.66 RN10.1
UIM_DET_R: CS2.1 DS1.5 DS1.6 JSIM1.2 RN10.2
UIM_RESET: CS4.1 DS1.2 DS1.8 JNGFF1.30 JSIM1.C2
UPD1_SMBCLK: RE105.1 RT109.1 UE1.C3 UT1.B5
UPD1_SMBDAT: RE104.1 RT111.1 UE1.B4 UT1.A5
UPD1_SMBINT#: RE106.1 UE1.F10 UT1.B6
UPD2_SMBCLK: RE496.1 RT126.1 UE1.D7 UT5.B5
UPD2_SMBDAT: RE495.1 RT128.1 UE1.E7 UT5.A5
UPD2_SMBINT#: RE497.1 UE1.F5 UT5.B6
USB2_ID: RC48.1 UCPU1.CE8
USB3_MRX_DTX_N4: RN15.1 UN1.8
USB3_MRX_DTX_P4: RN16.1 UN1.7
USB3_MRX_L_DTX_N4: JNGFF1.29 RN15.2
USB3_MRX_L_DTX_P4: JNGFF1.31 RN16.2
USB3_MTX_DRX_N4: RN12.1 UN1.4
USB3_MTX_DRX_P4: RN14.1 UN1.3
USB3_MTX_L_DRX_N4: JNGFF1.35 RN12.2
USB3_MTX_L_DRX_P4: JNGFF1.37 RN14.2
USB3_PRX_C_RD_DTX_N3: CI12.1 UI2.23
USB3_PRX_C_RD_DTX_P3: CI11.1 UI2.22
USB3_PRX_DTX_N2: RI62.1 UCPU1.BY8
USB3_PRX_DTX_N3: CI12.2 UCPU1.BY7
USB3_PRX_DTX_N4: UCPU1.BW6 UN1.16
USB3_PRX_DTX_P2: RI61.1 UCPU1.BY9
USB3_PRX_DTX_P3: CI11.2 UCPU1.BY6
USB3_PRX_DTX_P4: UCPU1.BW5 UN1.17
USB3_PRX_L_DTX_N2: DI15.1 JUSB2.5 RI62.2
USB3_PRX_L_DTX_N3: DI9.1 DI9.9 JUSB1.5 RI50.2
USB3_PRX_L_DTX_P2: DI17.1 JUSB2.6 RI61.2
USB3_PRX_L_DTX_P3: DI9.2 DI9.8 JUSB1.6 RI51.2
USB3_PRX_RD_DTX_N3: RI50.1 UI2.8
USB3_PRX_RD_DTX_P3: RI51.1 UI2.9
USB3_PTX_C_DRX_N2: CI27.2 RI60.1
USB3_PTX_C_DRX_N3: CI36.2 RI48.1
USB3_PTX_C_DRX_N4: CN15.2 UN1.18
USB3_PTX_C_DRX_P2: CI26.2 RI59.1
USB3_PTX_C_DRX_P3: CI35.2 RI49.1
USB3_PTX_C_DRX_P4: CN14.2 UN1.19
USB3_PTX_C_RD_DRX_N3: CI10.2 UI2.20
USB3_PTX_C_RD_DRX_P3: CI9.2 UI2.19
USB3_PTX_DRX_N2: CI27.1 UCPU1.CA2
USB3_PTX_DRX_N3: CI10.1 UCPU1.BY4
USB3_PTX_DRX_N4: CN15.1 UCPU1.BW2
USB3_PTX_DRX_P2: CI26.1 UCPU1.CA1
USB3_PTX_DRX_P3: CI9.1 UCPU1.BY3
USB3_PTX_DRX_P4: CN14.1 UCPU1.BW1
USB3_PTX_L_DRX_N2: DI16.1 JUSB2.8 RI60.2
USB3_PTX_L_DRX_N3: DI9.5 DI9.6 JUSB1.8 RI48.2
USB3_PTX_L_DRX_P2: DI18.1 JUSB2.9 RI59.2
USB3_PTX_L_DRX_P3: DI9.4 DI9.7 JUSB1.9 RI49.2
USB3_PTX_RD_DRX_N3: CI36.1 UI2.11
USB3_PTX_RD_DRX_P3: CI35.1 UI2.12
USB20_N1: UCPU1.CE3 UT1.K5
USB20_N2: UCPU1.CE1 UT5.K5
USB20_N3: UCPU1.CG3 UI5.2
USB20_N4: UCPU1.CD3 UI4.2
USB20_N6: LV6.4 UCPU1.CC1 UV6.1 UV6.8
USB20_N6_R: DV11.1 JEDP1.7 LV6.3
USB20_N7: LN4.1 UCPU1.CG8
USB20_N7_R: JNGFF1.9 LN4.2
USB20_N8: LB1.1 UCPU1.CB8
USB20_N8_R: JUSH1.8 LB1.2
USB20_N9: R276.1 UCPU1.CH5
USB20_N9_L: L2.4 R276.2 R278.2
USB20_N9_R: D3.2 D3.8 JFP1.11 L2.3
USB20_N10: LN6.1 UCPU1.CC3
USB20_N10_R: JNGFF3.5 LN6.2
USB20_P1: UCPU1.CE4 UT1.L5
USB20_P2: UCPU1.CE2 UT5.L5
USB20_P3: UCPU1.CG4 UI5.3
USB20_P4: UCPU1.CD4 UI4.3
USB20_P6: LV6.1 UCPU1.CC2 UV6.2 UV6.7
USB20_P6_R: DV10.1 JEDP1.8 LV6.2
USB20_P7: LN4.4 UCPU1.CG9
USB20_P7_R: JNGFF1.7 LN4.3
USB20_P8: LB1.4 UCPU1.CB9
USB20_P8_R: JUSH1.9 LB1.3
USB20_P9: R277.1 UCPU1.CH6
USB20_P9_L: L2.1 R277.2 R279.2
USB20_P9_R: D3.1 D3.9 JFP1.13 L2.2
USB20_P10: LN6.4 UCPU1.CC4
USB20_P10_R: JNGFF3.3 LN6.3
USB_OC0#: RC53.1 RC458.1 UCPU1.CK6 UI5.13
USB_OC1#: RC54.1 RC459.1 UCPU1.CK5 UI4.13
USB_OC2#: RC55.1 RC460.1 UCPU1.CK8
USB_OC3#: RC623.1 RC624.1 UCPU1.CK9
USB_POWERSHARE_ENL#: RE506.1 UE1.J3 UI5.6
USB_POWERSHARE_ENR#: RE505.1 UE1.K3 UI4.6
USB_POWERSHARE_VBUS_EN_L: RI124.2 UE1.J2 UI5.5
USB_POWERSHARE_VBUS_EN_R: RI68.1 RI123.2 UE1.G5 UI4.5
USBCOMP: RC47.1 UCPU1.CC5
USH_DET#: JUSH1.26 RE529.1 UE1.C13
USH_EXPANDER_SMBCLK: JUSH1.11 Q12.6 RE487.1 UE1.B3
USH_EXPANDER_SMBDAT: JUSH1.12 Q12.3 RE486.1 UE1.E5
USH_PWR_STATE#: JUSH1.22 RE527.1 UE1.H2
UVP_FAULT: PD1502.2 PD1505.2 PQ1507.2 PU1501.1
VCI_IN1#: RE135.1 UE1.B5
VCI_IN2#: RE136.1 UE1.D4
VCI_IN3#: RE515.1 UE1.E4
VDIFF_GT: PC907.1 PR938.1 PU900.10
VDIFF_IA: PC904.1 PR929.1 PU900.6
VDIFF_SA: PC912.1 PR943.1 PU900.14
VFB_GT: PC907.2 PR938.2 PR940.1 PU900.11
VFB_IA: PC904.2 PR929.2 PR933.1 PU900.7
VFB_SA: PC912.2 PR943.2 PR945.1 PU900.15
VID0_PRIM_CORE: PR1421.2 PR1427.1 PR1428.1 PU1401.4
VID0_VCCIO: PR1406.2 PR1411.1 PU1400.4
VID1_PRIM_CORE: PR1420.2 PR1426.1 PR1429.1 PU1401.3
VID1_VCCIO: PR1405.2 PR1410.1 PU1400.3
VIDSCLK_R: RC159.1 UCPU1.AA1
VIDSOUT_R: RC157.1 UCPU1.AA2
VOUT_PRIM_CORE: PR1418.1 PR1419.1 PU1401.12
VOUT_VCCIO: PR1409.1 PR1424.1 PU1400.12
VR_SVID_ALERT#: PR925.1 RC154.2 RC155.2
VR_SVID_CLK: PR922.1 RC158.2 RC159.2
VR_SVID_DATA: PR927.1 RC156.2 RC157.2
VRACPU_VTEMP: PC913.1 PR944.1 PR1001.1 PR1010.1 PR1101.1 PR1105.1 PU900.45
VRALERT#: RC81.1 UCPU1.CC36
VSET_5105: CE113.1 RE474.1 UE1.C9
VTEMP_CORE1: PR1001.2 PU1000.11
VTEMP_CORE2: PR1010.2 PU1001.11
VTEMP_GT: PR1101.2 PU1100.11
VTEMP_SA: PR1105.2 PU1101.9
VTTREF_0.6V: PC614.1 PU600.3
WLAN_COEX1: JNGFF3.48 RN51.2
WLAN_COEX2: JNGFF3.46 RN50.2
WLAN_COEX3: JNGFF3.44 RN49.2
WLAN_SUSCLK: JNGFF3.50 RN48.1
WLAN_WIGIG60GHZ_DIS#: QN9.3 RE119.1 UE1.L13
WLAN_WIGIG60GHZ_DIS#_R: JNGFF3.56 QN9.4 RN78.2
WWAN_BB_RST#: RN73.1 UCPU1.CG23
WWAN_BB_RST#_R: CN59.1 JNGFF1.67 RN73.2 RN105.2
WWAN_COEX1: JNGFF1.64 RN51.1 RN52.1
WWAN_COEX2: JNGFF1.62 RN50.1 RN53.1
WWAN_COEX3: JNGFF1.60 RN49.1 RN54.1
WWAN_FULL_PWR_EN: RN9.2 UCPU1.CM23
WWAN_GPIO_CTRL: RN90.1 UE1.K1
WWAN_GPIO_CTRL#: QN3.1 RN89.2 UN4.6
WWAN_GPIO_CTRL_R: QN3.2 RN90.2 RN91.1
WWAN_GPIO_PERST#: RN85.2 RN86.1 UCPU1.CH23
WWAN_GPIO_PERST#_R: RN86.2 RN97.1 UN5.6
WWAN_GPIO_WAKE#: RN80.1 RN82.1 UCPU1.CK23
WWAN_GPIO_WAKE#_R: RN80.2 UN4.1
WWAN_PERST#: JNGFF1.50 RN87.2 RN88.1 RN113.2
WWAN_PERST#_R: RN87.1 UN5.4
WWAN_PEWAKE#: JNGFF1.54 RN74.1 RN81.2 RN82.2 RN112.2
WWAN_PEWAKE#_R: RN81.1 UN4.4
WWAN_PWR_OFF#_R: CN18.1 JNGFF1.6 RN7.2 RN9.1
WWAN_RADIO_DIS#: QN8.3 RE129.1 UE1.F12
WWAN_RADIO_DIS#_R: JNGFF1.8 QN8.4
WWAN_SUSCLK: CN21.1 JNGFF1.68 RN13.1
WWAN_WAKE#: QN7.3 RE120.1 UE1.M13
WWAN_WAKE#_R: JNGFF1.23 QN7.4 RN92.2
XCLK_BIASREF: RC402.1 UCPU1.CJ1
XDP_BPM#0: RC245.1 UCPU1.U1
XDP_BPM#1: RC246.1 UCPU1.U2
XDP_BPM#2_R: T50.1(TP-1) UCPU1.U3
XDP_BPM#3_R: T51.1(TP-1) UCPU1.U4
XDP_DBRESET#: CC87.1 JXDP1.48 RC248.1
XDP_ITP_PMODE: RC125.2 RC249.2 UCPU1.W4
XDP_OBS0: JXDP1.21 RC245.2
XDP_OBS1: JXDP1.23 RC246.2
XDP_PIN1: JXDP1.1 RC253.2
XDP_PRSENT#: JXDP1.60 RC225.2 RC243.1
XDP_PWRBTN#: CC88.1 JXDP1.41 RC247.2 RC519.1
XDP_RST#: JXDP1.46 RC226.2 RC249.1 RC523.1
XDP_TCK0: JXDP1.57 RC228.2 RC237.2
XDP_TCK1: JXDP1.55 RC238.2
XDP_TDI: JXDP1.56 RC229.2 RC234.2
XDP_TDO: JXDP1.52 RC227.2 RC233.2
XDP_TMS: JXDP1.58 RC231.2 RC235.2
XDP_TRST#: JXDP1.54 RC232.2 RC236.2
XTAL24_IN: RC375.1 UCPU1.CK3
XTAL24_IN_R: CC6.1 RC59.1 RC375.2 YC1.3
XTAL24_OUT: RC376.1 UCPU1.CK2
XTAL24_OUT_R: CC7.1 RC59.2 RC376.2 YC1.1
XTAL_25_IN: RT72.1 UT2.D22
XTAL_25_IN_R: CT38.1 RT72.2 YT1.1
XTAL_25_OUT: RT24.2 UT2.D23
XTAL_25_OUT_R: CT37.1 RT24.1 YT1.3
N203838: PC604.1 PR602.2
N204012: PC605.1 PR603.2
N16430096: PR224.2 PU200.25
N16636697: PC1420.2 PR1404.2
N16837016: PC505.1 PR501.1 PR510.2
N16935323: PC137.1 PD102.1 PQ129.1 PR180.1 PR181.2 PR192.1 PU101.3
N16935337: PQ130.2 PR1204.1
N16935355: PC136.1 PD102.2 PR180.2 PR182.2 PR186.1
N16935372: PC138.1 PR178.2 PR193.1 PU101.4
N16935378: PR182.1 PU101.1
N16935575: PR187.2 PU102.1
N16935577: PC142.1 PD103.2 PR179.2 PR187.1 PR188.1
N16935624: PC140.1 PD103.1 PQ130.1 PR179.1 PR183.2 PR190.1 PU102.3
N16935644: PC141.1 PR184.2 PR194.1 PU102.4
N16935923: PQ129.2 PR199.1
N17013446: PQ205.2 PR223.2 PR227.1
N17091541: PC1426.1 PQ124.2 PR174.2
N17091543: PQ122.2 PQ124.1 PR160.2 PR163.1
N17093022: PQ120.2 PR154.1 PR158.2
