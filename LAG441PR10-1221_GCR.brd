# Allegro board LAG441PR10-1221_GCR.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
Y_7M25000016_4P
  rect 0.991x0.889 smd: 1(0,0) 2(2.15,0) 3(2.15,1.55) 4(0,1.55)
Y_9H03280012_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_X3G024000DC1H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)

## Nets
1.0VA_PG: PU800.9 RE507.2
1.2V_DDR_EN: CC257.1 DC7.2 PU600.1 RC612.2
1.8V_PRIM_PG: PR503.1 PU500.5 RE165.2
3.3V_CAM_EN#: QV1.2 RC611.1 RC616.1 UCPU1.CC37
3.3V_TS_EN: R222.1 UE1.J7
3.3V_TS_EN_R: R145.1 R222.2 R223.2 UC17.3
3.3V_WWAN_EN: R266.1 U4.3 UE1.C6
3V_5V_ALWON: CE50.1 PR306.1 PR404.1 PR412.1 RE469.2
3V_BST: PR300.1 PU300.1
3V_CS: PR308.1 PU300.3
3V_EN: PR306.2 PU300.8
3V_FB: PC310.1 PR302.2 PR304.1 PU300.7
3V_LX: PC305.1 PL301.1 PR309.1 PU300.20
3V_MODE: PR307.1 PU300.4
3V_TRK: PC309.1 PU300.5
3V_VCC: PC313.1 PR310.2 PU300.19
3V_VIN: PC300.1 PC301.1 PC302.1 PC303.1 PC304.1 PL300.2 PL302.2 PU300.10 PU300.21
3VALW_PG: PR310.1 PU300.9
5VALW_BST: PR401.1 PU400.8
5VALW_EN: PR404.2 PR413.1 PU400.11
5VALW_ENLDO: PR400.2 PU400.12
5VALW_LP: PC405.2 PU400.6
5VALW_LX: PC400.1 PL401.1 PR402.1 PU400.7
5VALW_PG: PR403.1 PU400.3 RE511.1
5VALW_VCC: PC411.1 PR403.2 PU400.9
5VALW_VIN: PC401.1 PC402.1 PC403.1 PC404.1 PL400.2 PL404.2 PU400.1
5VALWB_BST: PR409.1 PU401.8
5VALWB_EN: PR412.2 PR414.1 PU401.11
5VALWB_ENLDO: PR408.2 PU401.12
5VALWB_LP: PC418.2 PU401.6
5VALWB_LX: PC413.1 PL403.1 PR410.1 PU401.7
5VALWB_PG: PR411.1 PU401.3 RE512.1
5VALWB_VCC: PC424.1 PR411.2 PU401.9
5VALWB_VIN: PC414.1 PC415.1 PC416.1 PC417.1 PL402.2 PL405.2 PU401.1
+0.6VS: CD100.1 CD101.1 CD102.1 CD103.1 CD104.1 CD105.1 CD106.1 CD107.1 CD108.1 CD109.1 CD112.1 CD113.1 PJP601.2 RD21.2 RD22.2 RD23.2 RD24.2 RD25.2 RD26.2 RD27.2 RD28.2 RD29.2 RD30.2 RD31.2 RD32.2 RD33.2 RD34.2 RD35.2 RD36.2 RD37.2 RD38.2 RD39.2 RD40.2 RD41.2 RD42.2 RD43.2 RD44.2 RD45.2 RD46.2 RD47.2 RD48.2 RD49.2 RD50.2 RD51.2 RD52.2 RD53.2 RD54.2 RD55.2 RD56.2 RD57.2 RD58.2 RD59.2 RD60.2 RD61.2 RD62.2 RD63.2 RD64.2 RD65.2 RD66.2 RD67.2 RD68.2 RD69.2 RD70.2 RD71.2 RD72.2 RD73.2 RD74.2 RD75.2 RD76.2 RD77.2 RD78.2 RD79.2 RD80.2 RD81.2 RD82.2
+0.6VSP: PC615.1 PJP601.1 PU600.5 PU600.6
+1.0V_AMPHYPLL: CC80.1 CC102.1 CC263.1 CC265.1 LC1.2 RC173.2 UCPU1.BV2
+1.0V_CLK: CC83.1 CC100.1 CC261.1 CC262.1 LC2.1 RC175.1 UCPU1.CP5
+1.0V_PRIM_CORE: CC66.1 PJP1401.2 UCPU1.BU15 UCPU1.BU22 UCPU1.BV15 UCPU1.BV16 UCPU1.BV18 UCPU1.BV19 UCPU1.BV20 UCPU1.BV22 UCPU1.BW20 UCPU1.BW22 UCPU1.CA12 UCPU1.CA16 UCPU1.CA18 UCPU1.CA19 UCPU1.CA20 UCPU1.CB12 UCPU1.CB14 UCPU1.CB15
+1.0V_PRIM_COREP: PC1416.1 PC1417.1 PC1418.1 PJP1401.1 PL1403.2 PR1418.2
+1.0V_VCCPLL: CC240.1 CC241.1 CC242.1 LC3.2 RC627.2 UCPU1.BR11 UCPU1.BT11
+1.0V_VCCST: CC202.1 CZ1.1 LC3.1 PC903.1 PR912.1 PR913.1 PR914.1 PR915.1 R207.2 RC79.1 RC154.1 RC156.1 RC158.1 RC218.1 RC219.1 RC627.1 RE144.2 RE199.1 UCPU1.BP2 UCPU1.BP11
+1.0V_VCCST_R: R207.1 UZ3.6
+1.0V_VCCSTG: CC201.1 CZ5.1 R206.2 RC153.2 RC221.1 RC239.1 RC240.1 RC242.1 RC252.1 RC254.1 RC255.1 RC257.1 RC436.1 RC534.1 UCPU1.BG2
+1.0V_VCCSTG_CPU: RC153.1 UCPU1.BG3
+1.0V_VCCSTG_FUSE: RC534.2 UCPU1.BG1
+1.0V_VCCSTG_R: R206.1 UZ4.6
+1.0VA: CC67.1 CC68.1 CC70.1 CZ2.1 CZ3.1 LC1.1 LC2.2 PJP800.2 RC173.1 RC175.2 RC251.1 UCPU1.BP14 UCPU1.BP20 UCPU1.BP22 UCPU1.BR12 UCPU1.BR14 UCPU1.BR15 UCPU1.BR20 UCPU1.BT12 UCPU1.BT18 UCPU1.BT19 UCPU1.BT22 UCPU1.BU12 UCPU1.BU14 UCPU1.BU18 UCPU1.BU19 UCPU1.BV12 UCPU1.BV14 UCPU1.BW12 UCPU1.BW14 UCPU1.BW16 UCPU1.BW18 UCPU1.BW19 UCPU1.BY12 UCPU1.BY14 UCPU1.BY16 UCPU1.BY20 UCPU1.CA14 UCPU1.CC12 UZ3.1 UZ3.2 UZ3.7 UZ4.1 UZ4.2 UZ4.7
+1.0VA_XDP: CC85.1 CC86.1 JXDP1.43 JXDP1.44 RC125.1 RC226.1 RC230.1 RC251.2
+1.0VAP: PC806.1 PC807.1 PC808.1 PC809.1 PC810.1 PJP800.1 PL801.2 PR803.1
+1.0VS_VCCIO: CC39.1 CC40.1 CC41.1 CC42.1 CC51.1 CC52.1 CC53.1 CC54.1 CC55.1 CC56.1 CC234.1 CC235.1 CC236.1 CC237.1 PJP1400.2 QE4.1 RC8.1 RC163.1 RC521.1 UCPU1.AK24 UCPU1.AK26 UCPU1.AL24 UCPU1.AL25 UCPU1.AL26 UCPU1.AL27 UCPU1.AM25 UCPU1.AM27 UCPU1.BH24 UCPU1.BH25 UCPU1.BH26 UCPU1.BH27 UCPU1.BJ24 UCPU1.BJ26 UCPU1.BP16 UCPU1.BP18
+1.0VS_VCCIOP: PC1403.1 PC1404.1 PC1405.1 PJP1400.1 PL1401.2 PR1409.2
+1.2V_DDR: CC31.1 CC32.1 CC33.1 CC34.1 CC35.1 CC36.1 CC37.1 CC38.1 CC45.1 CC46.1 CC47.1 CC48.1 CC49.1 CC50.1 CC92.1 CD1.1 CD2.1 CD3.1 CD4.1 CD5.1 CD6.1 CD8.1 CD9.1 CD10.1 CD11.1 CD12.1 CD13.1 CD14.1 CD15.1 CD16.1 CD17.1 CD18.1 CD23.1 CD24.1 CD25.1 CD26.1 CD27.1 CD28.1 CD29.1 CD30.1 CD31.1 CD32.1 CD33.1 CD37.1 CD38.1 CD39.1 CD51.1 CD52.1 CD53.1 CD56.1 CD57.1 CD58.1 CD59.1 CD60.1 CD61.1 CD62.1 CD63.1 CD64.1 CD65.1 CD66.1 CD68.1 CD73.1 CD74.1 CD75.1 CD76.1 CD77.1 CD78.1 CD79.1 CD80.1 CD81.1 CD82.1 CD85.1 CZ7.1 PJP600.2 RD6.1 RD12.1 RD18.1 UC9.5 UCPU1.AD36 UCPU1.AH32 UCPU1.AH36 UCPU1.AM36 UCPU1.AN32 UCPU1.AW32 UCPU1.AY36 UCPU1.BE32 UCPU1.BH36 UCPU1.R32 UCPU1.Y36 UD1.A8 UD1.A9 UD1.A11 UD1.C12 UD1.D4 UD1.D5 UD1.D6 UD1.E8 UD1.E12 UD1.F2 UD1.G2 UD1.G5 UD1.G12 UD1.H3 UD1.H5 UD1.H6 UD1.H8 UD1.H9 UD1.H11 UD1.H12 UD1.J5 UD1.J6 UD1.J9 UD1.J10 UD1.K5 UD1.K6 UD1.K8 UD1.K11 UD1.K12 UD1.L2 UD1.L5 UD1.L12 UD1.M2 UD1.N8 UD1.N12 UD1.P4 UD1.P5 UD1.P6 UD1.R12 UD1.U8 UD1.U9 UD1.U11 UD2.A8 UD2.A9 UD2.A11 UD2.C12 UD2.D4 UD2.D5 UD2.D6 UD2.E8 UD2.E12 UD2.F2 UD2.G2 UD2.G5 UD2.G12 UD2.H3 UD2.H5 UD2.H6 UD2.H8 UD2.H9 UD2.H11 UD2.H12 UD2.J5 UD2.J6 UD2.J9 UD2.J10 UD2.K5 UD2.K6 UD2.K8 UD2.K11 UD2.K12 UD2.L2 UD2.L5 UD2.L12 UD2.M2 UD2.N8 UD2.N12 UD2.P4 UD2.P5 UD2.P6 UD2.R12 UD2.U8 UD2.U9 UD2.U11 UD3.A8 UD3.A9 UD3.A11 UD3.C12 UD3.D4 UD3.D5 UD3.D6 UD3.E8 UD3.E12 UD3.F2 UD3.G2 UD3.G5 UD3.G12 UD3.H3 UD3.H5 UD3.H6 UD3.H8 UD3.H9 UD3.H11 UD3.H12 UD3.J5 UD3.J6 UD3.J9 UD3.J10 UD3.K5 UD3.K6 UD3.K8 UD3.K11 UD3.K12 UD3.L2 UD3.L5 UD3.L12 UD3.M2 UD3.N8 UD3.N12 UD3.P4 UD3.P5 UD3.P6 UD3.R12 UD3.U8 UD3.U9 UD3.U11 UD4.A8 UD4.A9 UD4.A11 UD4.C12 UD4.D4 UD4.D5 UD4.D6 UD4.E8 UD4.E12 UD4.F2 UD4.G2 UD4.G5 UD4.G12 UD4.H3 UD4.H5 UD4.H6 UD4.H8 UD4.H9 UD4.H11 UD4.H12 UD4.J5 UD4.J6 UD4.J9 UD4.J10 UD4.K5 UD4.K6 UD4.K8 UD4.K11 UD4.K12 UD4.L2 UD4.L5 UD4.L12 UD4.M2 UD4.N8 UD4.N12 UD4.P4 UD4.P5 UD4.P6 UD4.R12 UD4.U8 UD4.U9 UD4.U11 UZ5.1 UZ5.2 UZ5.7
+1.2V_DDRP: PC608.1 PC609.1 PC610.1 PC611.1 PC612.1 PC613.1 PC616.1 PC619.1 PJP600.1 PL601.2 PR605.1 PU600.7 PU600.8
+1.8V_MEM: C70.1 CD7.1 CD34.1 CD35.1 CD36.1 CD40.1 CD41.1 CD48.1 CD49.1 CD50.1 CD54.1 CD55.1 CD83.1 CD84.1 R58.2 UD1.A3 UD1.A4 UD1.A5 UD1.A6 UD1.A10 UD1.U3 UD1.U4 UD1.U5 UD1.U6 UD1.U10 UD2.A3 UD2.A4 UD2.A5 UD2.A6 UD2.A10 UD2.U3 UD2.U4 UD2.U5 UD2.U6 UD2.U10 UD3.A3 UD3.A4 UD3.A5 UD3.A6 UD3.A10 UD3.U3 UD3.U4 UD3.U5 UD3.U6 UD3.U10 UD4.A3 UD4.A4 UD4.A5 UD4.A6 UD4.A10 UD4.U3 UD4.U4 UD4.U5 UD4.U6 UD4.U10
+1.8V_MEM_R: R58.1 U12.13 U12.14
+1.8V_PRIM: C72.1 CC69.1 CC98.1 PJP500.2 RC24.1 RC464.1 RC491.2 RC526.1 RC527.1 RC541.1 RC597.2 RH51.1 RH53.1 RH55.1 RH57.1 RH59.1 RV68.1 U12.1 U12.2 UCPU1.CC15 UCPU1.CC18 UCPU1.CC19 UCPU1.CD15 UCPU1.CD16 UCPU1.CD18 UCPU1.CD19 UCPU1.CP17 UCPU1.CP23
+1.8V_PRIMP: PC505.2 PC506.1 PC507.1 PC508.1 PC509.1 PJP500.1 PL500.2 PR502.1
+1.8V_PRIMR: C61.1 C86.1 CE14.1 R205.2 RE184.1 U19.1 U19.2
+1.8V_PRIMR_RIGHT: R205.1 R209.1 U17.5
+1.8VA_EC: CE15.1 RE163.1 RE184.2 RE186.1 UE1.N5
+1.8VA_LDO_PD_A: CT94.1 RT52.2 UT1.K1
+1.8VA_LDO_PD_B: CT97.1 RT58.2 UT5.K1
+1.8VD_LDO_PD_A: CT95.1 UT1.A2
+1.8VD_LDO_PD_B: CT98.1 UT5.A2
+1.8VS: C62.1 CA141.1 CS9.1 CS10.1 Q12.2 Q12.5 QN7.2 QN7.5 QN12.2 QN12.5 R47.2 RC499.1 RC500.1 RN3.1 RN92.1 RN105.1 RN115.1 RS3.1 RS5.1 RS6.1 RS7.1 UA7.1 UA7.2
+1.8VS_AUDIO: CA153.1 RA11.1 RA13.2 RA15.1 RA112.2
+1.8VS_AUDIO_R: RA112.1 UA7.7 UA7.8
+1.8VS_R: R47.1 U19.7 U19.8
+1.8VS_U16: RS3.2 U16.A2
+3.3V_BAT_LDO: DB3.2 PD105.2 PD105.3 PD1501.2 PR197.2 PR1500.1 PR1502.1 QE26.2 RE519.1
+3.3V_BAT_LDO_R: JBATT1.6 PR197.1
+3.3V_EC_PLL: CE7.1 CE8.1 RE114.2 UE1.F1
+3.3V_LDO_PD_A: CT142.1 CT174.1 RT51.2 RT99.1 RT100.1 RT101.1 RT102.1 RT106.1 RT108.1 RT114.1 RT155.1 RT260.1 UT1.G1 UT4.8
+3.3V_LDO_PD_B: CT186.1 RT57.2 RT123.1 RT125.1 RT138.1 RT165.1 UT5.G1
+3.3V_TBT_FLASH: CT51.1 RT44.1 RT45.1 RT46.1 RT47.1 RT260.2 RT261.2 UT3.8
+3.3V_VOUT_PD_A: CT173.1 UT1.H2
+3.3V_VOUT_PD_B: CT185.1 UT5.H2
+3.3V_VPS_TPM: CZ19.1 CZ20.1 CZ21.1 RZ38.2 RZ39.2 RZ1413.2 UZ6.14 UZ6.22
+3V_1.8V_HDA: RC119.1 RC541.2 RC542.2 UCPU1.BT20
+3V_5105: CE2.1 CE3.1 CE4.1 CE6.1 CE9.1 CE10.1 RE114.1 RE183.2 UE1.B7 UE1.G8 UE1.H1 UE1.K2 UE1.M9
+3V_FPR: C15.1 C18.1 JFP1.3 Q14.2 Q14.5 Q15.2 Q15.5 R217.1 R218.1 R219.1 R220.2 R221.1 R256.2 R284.2
+3V_FPR_R: QV12.1 R284.1
+3V_LDO: CT204.2 DB4.2 PCB46.1 PR116.1 PR119.1 PR122.1 PR153.1 PR155.1 PR160.1 PUB2.5 QT2.3 QT4.3 RT149.1 RT161.1 RT298.2 RT300.2
+3V_LDOP: CT202.1 PC130.1 PC131.1 PR178.1 PR184.1 PU101.6 PU102.6 QT2.1 UT16.5
+3V_PCH: C74.1 CC243.1 CC244.1 D203.2 JAPS1.1 R59.2 R101.1 RC17.1 RC18.2 RC20.2 RC23.2 RC25.2 RC26.2 RC27.2 RC29.2 RC40.2 RC41.1 RC46.2 RC53.2 RC54.2 RC55.2 RC81.2 RC118.2 RC225.1 RC395.1 RC443.2 RC445.2 RC482.2 RC483.2 RC484.2 RC522.1 RC542.1 RC551.2 RC560.1 RC580.2 RC581.2 RC582.1 RC583.2 RC594.2 RC595.2 RC604.2 RC608.2 RC616.2 RC617.2 RC623.2 RC628.2 RC633.2 RC634.2 RE473.1 RN106.1 RN116.1 RT304.2 RT305.2 RV69.1 RZ19.1 RZ39.1 UCPU1.BP23 UCPU1.BV23 UCPU1.BW23 UCPU1.CB16 UCPU1.CB22 UCPU1.CB23 UCPU1.CC22 UCPU1.CC23 UCPU1.CD22 UCPU1.CD23 UCPU1.CP29
+3V_PCH_DSW: CC101.1 CN57.1 RC73.1 RC74.1 RC80.2 RC82.2 RC394.1 RC424.1 RC451.2 RC465.2 RC604.1 UCPU1.BR24 UCPU1.BT23 UN4.5
+3V_PCH_DSW_R: QC3.1 RC424.2
+3V_PCH_R: R59.1 U12.8 U12.9
+3V_SPI: CC4.1 D203.1 JSPI1.8 JSPI1.9 RC628.1 U27.8 UC18.8
+3V_SSD: C56.1 CN22.1 CN23.1 CN24.1 CN25.1 CN26.1 CN46.1 CN47.1 CN48.1 JNGFF2.2 JNGFF2.4 JNGFF2.12 JNGFF2.14 JNGFF2.16 JNGFF2.18 JNGFF2.70 JNGFF2.72 JNGFF2.74 R46.2 RN23.2 RN25.2
+3V_TBT: CT61.1 CT62.1 CT63.1 CT64.1 CT65.1 CT149.1 CT150.1 CT167.1 CT168.1 LT2.2 RT50.1 RT88.2 UT2.A2 UT2.A3 UT2.B3 UT2.H9
+3V_TBT_S0: CT131.1 CT132.1 CT133.1 CT143.1 CT144.1 LT2.1 RT11.2 RT13.2 UT2.R13
+3V_WLAN: C41.1 CN27.1 CN28.1 CN29.1 CN30.1 CN31.1 CN32.1 CN33.1 CN34.1 CN35.1 CN36.1 JNGFF3.2 JNGFF3.4 JNGFF3.72 JNGFF3.74 QN5.2 QN5.5 QN9.2 QN9.5 R33.2 RN77.1 RN78.1 RN99.1
+3V_WWAN: C29.1 CN1.1 CN2.1 CN3.1 CN4.1 CN5.1 CN6.1 CN7.1 CN8.1 CN9.1 CN10.1 CN41.1 CS11.1 JNGFF1.2 JNGFF1.4 JNGFF1.70 JNGFF1.72 JNGFF1.74 QN4.2 QN4.5 QN8.2 QN8.5 R31.2 RN4.2 RN7.1 RN67.1 RN74.2 RN95.2
+3VA_TBT: CT60.1 CT145.1 CT146.1 RT10.2 RT14.2 RT19.2 RT25.2 RT26.2 RT27.2 RT29.2 RT30.2 RT31.2 RT49.2 RT88.1 RT185.2 RT189.2 RT295.2 UT2.F8
+3VA_TBT_LC: CT59.1 CT147.1 CT148.1 RT3.1 RT4.1 RT5.1 RT6.1 RT261.1 UT2.R6
+3VALW: C28.1 C39.1 C49.1 C57.1 C75.1 C85.1 C94.1 C95.1 CB22.1 CE5.1 CE11.1 CE12.1 CI13.1 CI14.1 CV1.1 CV2.1 CV27.1 CV55.1 CZ22.1 CZ23.1 JAPS1.3 JAPS1.7 PC606.1 PC813.1 PJP300.2 PR102.1 PR107.1 PR128.1 PR133.1 PR136.1 PR137.1 PR138.1 PR139.1 PR169.1 PR174.1 PR604.1 PR807.1 PR902.1 PR908.1 PR909.1 PR910.1 PR937.1 PR1000.1 PR1009.1 PR1100.1 PR1104.1 PR1400.1 PR1402.2 PR1403.2 PR1405.1 PR1406.1 PR1414.1 PR1420.1 PR1421.1 PR1423.2 PR1425.2 PU600.13 PU800.15 QC3.3 QK2.3 QK5.3 QT4.1 QV12.3 R274.1 R283.1 RA123.2 RB36.1 RC394.2 RC538.1 RC540.1 RE90.1 RE91.1 RE92.1 RE93.1 RE94.1 RE104.2 RE105.2 RE106.2 RE108.2 RE109.2 RE110.2 RE111.2 RE113.2 RE116.2 RE118.2 RE119.2 RE120.2 RE121.2 RE122.2 RE124.2 RE126.2 RE129.2 RE131.2 RE138.1 RE141.2 RE142.2 RE162.1 RE177.1 RE183.1 RE192.1 RE197.1 RE200.1 RE209.1 RE210.1 RE211.1 RE212.1 RE486.2 RE487.2 RE488.2 RE489.2 RE490.2 RE495.2 RE496.2 RE497.2 RE501.2 RE502.2 RE503.2 RE504.2 RE505.2 RE506.2 RE509.1 RE516.2 RE518.1 RE521.2 RE522.2 RE525.1 RE526.2 RE529.2 RE530.2 RE533.1 RE535.2 RI38.2 RI40.2 RI42.2 RI44.2 RI72.2 RI74.2 RI76.2 RI78.2 RI101.1 RK4.1 RK5.1 RK6.1 RK12.1 RN70.1 RN84.2 RN89.1 RN108.1 RN111.1 RT49.1 RT145.1 RT146.1 RTCD3.2 RV45.1 RW19.2 RZ34.1 RZ1413.1 U4.1 U4.2 U4.6 U4.7 U5.5 U6.1 U6.2 U7.5 U8.1 U8.2 U10.5 U11.5 U12.6 U12.7 U17.1 U32.5 U33.5 UC19.5 UE4.5 UI2.1 UI2.13 ULID1.B1 UT14.5 UT15.5 UV1.6
+3VALW_1117: CK8.1 CK9.1 CK10.1 RK5.2 UK1.4 UK1.24 UK1.37
+3VALW_PD_A: CT171.1 CT195.1 RT145.2 RT149.2 UT1.B1 UT1.H1
+3VALW_PD_B: CT183.1 CT198.1 RT146.2 RT161.2 UT5.B1 UT5.H1
+3VALW_QV6: QV6.3 RV45.2
+3VALW_TPM: CZ15.1 CZ16.1 RZ34.2 UZ6.1
+3VALW_USH: JUSH1.14 JUSH1.15 JUSH1.16 RB36.2
+3VALWP: PC306.1 PC307.1 PC308.1 PC310.2 PC311.1 PC312.1 PJP300.1 PL301.2 PR302.1
+3VS: C31.1 C32.2 C48.1 CA146.1 CB21.1 CC239.1 CR18.1 CV26.1 CV42.1 CV43.1 JESPI1.1 JESPI1.2 QC1.2 QC1.5 QK3.2 QK4.2 QM1.2 QM1.5 QM2.2 QV1.3 R23.1 R24.1 R43.2 R139.1 R140.1 R256.1 R275.1 RA126.1 RB38.1 RC1.1 RC3.1 RC5.1 RC7.1 RC38.2 RC45.2 RC58.1 RC62.1 RC63.1 RC65.1 RC67.1 RC87.2 RC88.1 RC433.1 RC463.1 RC488.2 RC489.2 RC516.2 RC518.1 RC519.2 RC530.1 RC545.2 RC546.2 RC547.2 RC548.2 RC555.2 RC556.2 RC564.1 RC585.2 RC596.1 RC618.2 RC619.1 RC620.2 RE1.2 RE172.1 RE241.1 RM96.1 RM98.1 RM107.1 RN83.2 RR1.1 RR13.1 RT50.2 RV50.1 RV54.1 RV94.1 RV95.1 RZ18.1 RZ21.1 RZ38.1 U15.1 U15.2 UA8.6 UA8.7 UC2.5 UC10.5 UC17.1 UC17.2 UR2.6 UV5.9 UV5.10
+3VS_ALS: JCAM1.7 JCAM1.8 RV94.2
+3VS_AUDIO: CA147.1 RA9.1 RA14.1 RA110.1 RA115.2
+3VS_AUDIO_R: RA115.1 UA8.8 UA8.9
+3VS_CAM: CV31.1 CV32.1 CV33.1 CV34.1 CV52.1 CV53.1 JCAM1.9 JCAM1.10 RV76.2 UV6.12
+3VS_CAM_Q: QV1.1 RV76.1
+3VS_CR: CR1.1 CR2.1 CR3.1 CR4.1 CR20.1 RR1.2 RR9.1 RR11.2 RR16.2 UR1.11 UR1.27
+3VS_CR_R: RR16.1 RR20.2 UR2.1
+3VS_R: R43.1 U6.13 U6.14
+3VS_SENSOR: JEDP1.23 RV95.2
+3VS_SSD_R: R46.1 U8.7 U8.8
+3VS_TP: C26.1 CP1.1 CP2.1 JTP1.1 Q3.2 Q3.5 Q13.2 Q13.5 R27.2 R275.2 RP6.2 RP7.2 RP8.1 RP9.1 RP15.1
+3VS_TP_R: R27.1 U15.7 U15.8
+3VS_TPM: CZ17.1 CZ18.1 RZ18.2 UZ6.8
+3VS_TS: C78.1 CV44.1 CV45.1 JEDP1.14 R26.2 RV57.2 RV58.2 RV60.1
+3VS_TS_R: R26.1 UC17.7 UC17.8
+3VS_UN5: CN58.1 RN83.1 RN84.1 RN85.1 UN5.5
+3VS_USH: JUSH1.19 RB38.2
+3VS_WLAN_R: R33.1 U4.8 U4.9
+3VS_WWAN_R: R31.1 U4.13 U4.14
+3VS_WWAN_RF: RN67.2 UN3.4
+3VS_WWAN_UN1: CN11.1 CN12.1 CN13.1 RN4.1 UN1.1 UN1.6 UN1.10
+5V_USB_L: CI28.1 CI29.1 CI30.1 JUSB2.1 UI5.12
+5V_USB_R: CI21.1 CI22.1 CI23.1 JUSB1.1 UI4.12
+5VALW: C14.1 C96.1 C97.1 CI31.1 CI32.1 CM48.1 CT175.1 CT176.1 CT177.1 CT178.1 CT187.1 CT188.1 CT189.1 CT190.1 CT196.1 CT199.1 DV12.1 JLED1.1 PJP400.2 RI64.1 RI144.1 U12.4 UC17.4 UI5.1 UM3.1 UT1.A11 UT1.B11 UT1.C11 UT1.D11 UT1.H10 UT5.A11 UT5.B11 UT5.C11 UT5.D11 UT5.H10 UZ3.3 UZ4.3 UZ5.3
+5VALWB: C53.1 CA149.1 CB20.1 CI24.1 CI25.1 JPTN1.1 PJP401.2 R102.1 RB37.1 RI53.1 RI143.1 U4.4 U6.4 U6.6 U6.7 U8.4 U15.4 U19.4 UA7.4 UA8.1 UA8.2 UA8.4 UI4.1
+5VALWB_USH: JUSH1.17 JUSH1.18 RB37.2
+5VALWBP: PC419.1 PC420.1 PC421.1 PC422.1 PC423.1 PJP401.1 PL403.2 PU401.5
+5VALWP: PC406.1 PC407.1 PC408.1 PC409.1 PC410.1 PC426.1 PJP400.1 PL401.2 PU400.5
+5VS: C21.1 C22.1 C52.1 CB19.1 CK1.1 D9.1 FK1.1 JFAN1.4 R44.2 R229.1 RB39.1 RE213.1
+5VS_AUDIO: CA20.1 CA21.1 CA148.1 DA1.1 LA1.2 LA2.1 RA116.2
+5VS_AUDIO_R: RA116.1 UA8.13 UA8.14
+5VS_KBL: CK2.1 CK3.1 FK1.2 JBL1.2
+5VS_R: R44.1 U6.8 U6.9
+5VS_USH: JUSH1.20 RB39.2
+8.4V_BATT+: PC231.1 PC232.1 PQ202.1 PQ202.2 PQ202.3 PR211.4
+AVDD1: CA5.1 CA14.1 CA16.1 LA1.1 UA1.40
+DVDD: CA11.1 CA12.1 CA31.1 RA9.2 RA11.2 RA22.2 RA118.1 RA124.1 RV35.1 UA1.3
+DVDDIO: CA26.1 CA27.1 RA14.2 RA15.2 UA1.18
+PVDD: CA22.1 CA23.1 CA29.1 CA30.1 LA2.2 UA1.41 UA1.46
+VBATT: PC132.1 PC133.1 PC234.1 PL102.1 PL103.1 PL104.1 PQ202.5 PR236.2
+VBUS1_20V: CT172.1 DT43.1 DT44.2 DT44.3 DT47.2 LT3.2 PC117.1 PC118.1 PC119.1 PC120.1 PC121.1 PC122.1 PC123.1 PL101.2 PQ115.1 PQ115.2 PQ115.3 PQ117.3 PR145.1 PR146.1 PR147.1
+VBUS2_20V: CT184.1 DT45.1 DT46.2 DT46.3 DT48.2 LT4.2 PC104.1 PC105.1 PC106.1 PC107.1 PC108.1 PC109.1 PC110.1 PL100.2 PQ100.1 PQ100.2 PQ100.3 PQ102.3 PR100.1 PR103.1 PR104.1
+VCC0V9_CIO: CT134.1 CT135.1 CT136.1 CT161.1 CT162.1 UT2.R8 UT2.R9 UT2.R11 UT2.R12
+VCC0V9_DP: CT52.1 CT53.1 CT54.1 CT55.1 CT56.1 CT57.1 CT58.1 CT151.1 CT152.1 UT2.L6 UT2.L8 UT2.L11 UT2.L12 UT2.M6 UT2.M8 UT2.T11 UT2.T12 UT2.V11 UT2.V12 UT2.V13
+VCC0V9_PCIE: CT67.1 CT68.1 CT69.1 CT70.1 CT153.1 CT154.1 UT2.L18 UT2.L19 UT2.M13 UT2.M15 UT2.M16 UT2.M18 UT2.N18 UT2.N19
+VCC0V9_USB: CT66.1 CT71.1 CT157.1 CT158.1 UT2.R15 UT2.R16
+VCC_CORE: PC1200.1 PC1201.1 PC1202.1 PC1203.1 PC1204.1 PC1205.1 PC1206.1 PC1214.1 PC1215.1 PC1216.1 PC1217.1 PC1218.1 PC1219.1 PC1220.1 PC1221.1 PC1222.1 PC1223.1 PC1224.1 PC1232.1 PC1233.1 PC1234.1 PC1235.1 PC1236.1 PC1237.1 PC1238.1 PC1239.1 PC1240.1 PC1241.1 PC1242.1 PC1243.1 PC1244.1 PC1245.1 PC1246.1 PC1247.1 PC1248.1 PC1249.1 PC1250.1 PC1251.1 PC1252.1 PC1253.1 PC1254.1 PC1255.1 PC1256.1 PC1257.1 PC1258.1 PC1259.1 PC1260.1 PC1261.1 PC1262.1 PC1263.1 PC1264.1 PC1265.1 PC1266.1 PC1267.1 PC1268.1 PC1269.1 PC1270.1 PC1271.1 PC1272.1 PC1273.1 PC1274.1 PC1275.1 PC1276.1 PC1277.1 PC1278.1 PC1279.1 PC1280.1 PC1281.1 PC1282.1 PC1283.1 PC1284.1 PC1285.1 PC1286.1 PC1287.1 PC1288.1 PC1289.1 PC1290.1 PC1291.1 PC1292.1 PC1293.1 PC1294.1 PC1295.1 PC1296.1 PC1297.1 PC1298.1 PC1299.1 PC1300.1 PC1301.1 PC1302.1 PC1303.1 PC1304.1 PL1000.2 PL1004.2 PR1503.2 RC150.1 UCPU1.AA9 UCPU1.AB2 UCPU1.AB8 UCPU1.AB9 UCPU1.AB10 UCPU1.AC8 UCPU1.AD9 UCPU1.AE8 UCPU1.AE9 UCPU1.AE10 UCPU1.AF2 UCPU1.AF8 UCPU1.AF10 UCPU1.AG8 UCPU1.AG9 UCPU1.AH9 UCPU1.AJ8 UCPU1.AJ10 UCPU1.AK2 UCPU1.AK9 UCPU1.AL8 UCPU1.AL9 UCPU1.AL10 UCPU1.AM8 UCPU1.AN9 UCPU1.AN10 UCPU1.AN24 UCPU1.AN26 UCPU1.AN27 UCPU1.AP2 UCPU1.AP9 UCPU1.AP24 UCPU1.AP26 UCPU1.AR5 UCPU1.AR6 UCPU1.AR7 UCPU1.AR8 UCPU1.AR10 UCPU1.AR25 UCPU1.AR27 UCPU1.AT9 UCPU1.AT24 UCPU1.AT26 UCPU1.AU5 UCPU1.AU6 UCPU1.AU7 UCPU1.AU8 UCPU1.AU9 UCPU1.AU24 UCPU1.AU25 UCPU1.AU26 UCPU1.AU27 UCPU1.AV2 UCPU1.AV5 UCPU1.AV7 UCPU1.AV10 UCPU1.AV27 UCPU1.AW5 UCPU1.AW6 UCPU1.AW7 UCPU1.AW8 UCPU1.AW9 UCPU1.AW10 UCPU1.AW24 UCPU1.AW25 UCPU1.AW26 UCPU1.AW27 UCPU1.AY24 UCPU1.AY26 UCPU1.BA5 UCPU1.BA7 UCPU1.BA8 UCPU1.BA25 UCPU1.BA27 UCPU1.BB2 UCPU1.BB26 UCPU1.BC5 UCPU1.BC6 UCPU1.BC7 UCPU1.BC9 UCPU1.BC10 UCPU1.BC26 UCPU1.BC27 UCPU1.BD5 UCPU1.BD8 UCPU1.BD10 UCPU1.BD25 UCPU1.BD27 UCPU1.BE9 UCPU1.BE24 UCPU1.BE25 UCPU1.BE26 UCPU1.BE27 UCPU1.BF2 UCPU1.BF9 UCPU1.BF24 UCPU1.BF26 UCPU1.BG27 UCPU1.V2 UCPU1.Y8 UCPU1.Y10
+VCC_CORE_G0: T29.1(TP-1) UCPU1.BB9
+VCC_CORE_G1: T30.1(TP-1) UCPU1.BC24
+VCC_CORE_G2: T134.1(TP-1) UCPU1.AY9
+VCC_CORE_G3: T135.1(TP-1) UCPU1.BB24
+VCCDPHY_1P24: CC245.1 UCPU1.CP25
+VCCGT: PC1305.1 PC1306.1 PC1307.1 PC1308.1 PC1309.1 PC1310.1 PC1311.1 PC1312.1 PC1313.1 PC1314.1 PC1315.1 PC1316.1 PC1323.1 PC1324.1 PC1325.1 PC1326.1 PC1327.1 PC1328.1 PC1329.1 PC1330.1 PC1331.1 PC1332.1 PC1333.1 PC1334.1 PC1335.1 PC1336.1 PC1337.1 PC1338.1 PC1339.1 PC1340.1 PC1341.1 PC1342.1 PC1343.1 PC1344.1 PC1345.1 PC1346.1 PC1347.1 PC1348.1 PC1349.1 PC1350.1 PC1351.1 PC1352.1 PC1353.1 PC1354.1 PC1355.1 PC1356.1 PC1357.1 PC1358.1 PC1359.1 PC1360.1 PC1361.1 PC1362.1 PC1363.1 PC1364.1 PL1100.2 RC160.1 UCPU1.A5 UCPU1.A6 UCPU1.A8 UCPU1.A11 UCPU1.A12 UCPU1.A14 UCPU1.A15 UCPU1.A17 UCPU1.A18 UCPU1.A20 UCPU1.B3 UCPU1.B4 UCPU1.B6 UCPU1.B8 UCPU1.B11 UCPU1.B14 UCPU1.B17 UCPU1.B20 UCPU1.C2 UCPU1.C3 UCPU1.C6 UCPU1.C7 UCPU1.C8 UCPU1.C11 UCPU1.C12 UCPU1.C14 UCPU1.C15 UCPU1.C17 UCPU1.C18 UCPU1.C20 UCPU1.D4 UCPU1.D7 UCPU1.D11 UCPU1.D12 UCPU1.D14 UCPU1.D15 UCPU1.D17 UCPU1.D18 UCPU1.D20 UCPU1.E4 UCPU1.F5 UCPU1.F6 UCPU1.F7 UCPU1.F8 UCPU1.F11 UCPU1.F14 UCPU1.F17 UCPU1.F20 UCPU1.G11 UCPU1.G12 UCPU1.G14 UCPU1.G15 UCPU1.G17 UCPU1.G18 UCPU1.G20 UCPU1.H5 UCPU1.H6 UCPU1.H7 UCPU1.H8 UCPU1.H11 UCPU1.H12 UCPU1.H14 UCPU1.H15 UCPU1.H17 UCPU1.H18 UCPU1.H20 UCPU1.J7 UCPU1.J8 UCPU1.J11 UCPU1.J14 UCPU1.J17 UCPU1.J20 UCPU1.K2 UCPU1.K11 UCPU1.L7 UCPU1.L8 UCPU1.L10 UCPU1.M9 UCPU1.N7 UCPU1.N8 UCPU1.N9 UCPU1.N10 UCPU1.P2 UCPU1.P8 UCPU1.R9 UCPU1.T8 UCPU1.T9 UCPU1.T10 UCPU1.U8 UCPU1.U10 UCPU1.V9 UCPU1.W8 UCPU1.W9
+VCCLDOSRAM_1P24: UCPU1.BY23 UCPU1.BY24 UCPU1.CA23 UCPU1.CA24
+VCCPDSW_1P05: CC65.1 UCPU1.BT24
+VCCPLL_OC: CC203.1 CC232.1 CC233.1 CZ6.1 R103.2 UCPU1.BL27 UCPU1.BM26
+VCCPLL_OC_R: R103.1 UZ5.6
+VCCRTCEXT: CC76.1 UCPU1.BP24
+VCCSA: PC1365.1 PC1366.1 PC1367.1 PC1368.1 PC1369.1 PC1370.1 PC1371.1 PC1372.1 PC1373.1 PC1374.1 PC1375.1 PC1376.1 PC1377.1 PC1378.1 PC1379.1 PC1380.1 PC1381.1 PC1382.1 PC1383.1 PL1102.2 RC166.1 UCPU1.BG8 UCPU1.BG10 UCPU1.BH9 UCPU1.BJ8 UCPU1.BJ9 UCPU1.BJ10 UCPU1.BK8 UCPU1.BK25 UCPU1.BK27 UCPU1.BL8 UCPU1.BL9 UCPU1.BL10 UCPU1.BL24 UCPU1.BL26 UCPU1.BM24 UCPU1.BN25
+VSS_PLL: CE7.2 CE8.2 UE1.G1
AGND: CA5.2 CA7.2 CA8.2 CA9.2 CA10.2 CA13.2 CA14.2 CA15.1 CA16.2 CA18.2 CA24.2 CA25.2 CA44.2 CA45.2 CA48.2 CA49.2 DA25.1 JHP1.5 RA1.2 RA5.2 RA6.2 RA12.1 RA125.1 UA1.22 UA1.37
DV12S: CR14.1 CR15.1 CR16.1 UR1.10 UR1.14
DV33_18: CR5.1 UR1.18
GND: C14.2 C15.2 C18.2 C21.2 C22.2 C26.2 C27.2 C28.2 C29.2 C30.2 C31.2 C32.1 C37.2 C38.2 C39.2 C41.2 C48.2 C49.2 C50.2 C51.2 C52.2 C53.2 C56.2 C57.2 C59.2 C60.2 C61.2 C62.2 C70.2 C71.2 C72.2 C73.2 C74.2 C75.2 C78.2 C85.2 C86.2 C88.2 C92.2 C93.2 C94.2 C95.2 C96.2 C97.2 CA4.2 CA6.2 CA11.2 CA12.2 CA19.2 CA20.2 CA21.2 CA22.2 CA23.2 CA26.2 CA27.2 CA28.2 CA29.2 CA30.2 CA31.2 CA32.1 CA34.2 CA35.2 CA36.2 CA46.2 CA47.2 CA84.2 CA85.2 CA86.2 CA87.2 CA141.2 CA144.2 CA145.2 CA146.2 CA147.2 CA148.2 CA149.2 CA150.2 CA151.2 CA153.2 CA154.2 CA155.2 CB15.2 CB16.2 CB17.2 CB18.2 CB19.2 CB20.2 CB21.2 CB22.2 CC2.2 CC4.2 CC6.2 CC7.2 CC8.2 CC9.2 CC10.2 CC11.2 CC12.2 CC13.2 CC15.2 CC17.2 CC31.2 CC32.2 CC33.2 CC34.2 CC35.2 CC36.2 CC37.2 CC38.2 CC39.2 CC40.2 CC41.2 CC42.2 CC45.2 CC46.2 CC47.2 CC48.2 CC49.2 CC50.2 CC51.2 CC52.2 CC53.2 CC54.2 CC55.2 CC56.2 CC65.2 CC66.2 CC67.2 CC68.2 CC69.2 CC70.2 CC72.2 CC73.2 CC76.2 CC80.2 CC83.2 CC85.2 CC86.2 CC87.2 CC88.2 CC89.2 CC92.2 CC98.2 CC100.2 CC101.2 CC102.2 CC199.2 CC200.2 CC201.2 CC202.2 CC203.2 CC232.2 CC233.2 CC234.2 CC235.2 CC236.2 CC237.2 CC238.2 CC239.2 CC240.2 CC241.2 CC242.2 CC243.2 CC244.2 CC245.2 CC246.2 CC247.2 CC248.1 CC249.1 CC250.1 CC251.1 CC252.1 CC253.2 CC254.2 CC255.2 CC257.2 CC258.2 CC259.2 CC260.2 CC261.2 CC262.2 CC263.2 CC265.2 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD21.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD29.2 CD30.2 CD31.2 CD32.2 CD33.2 CD34.2 CD35.2 CD36.2 CD37.2 CD38.2 CD39.2 CD40.2 CD41.2 CD47.2 CD48.2 CD49.2 CD50.2 CD51.2 CD52.2 CD53.2 CD54.2 CD55.2 CD56.2 CD57.2 CD58.2 CD59.2 CD60.2 CD61.2 CD62.2 CD63.2 CD64.2 CD65.2 CD66.2 CD68.2 CD70.2 CD71.2 CD72.2 CD73.2 CD74.2 CD75.2 CD76.2 CD77.2 CD78.2 CD79.2 CD80.2 CD81.2 CD82.2 CD83.2 CD84.2 CD85.2 CD100.2 CD101.2 CD102.2 CD103.2 CD104.2 CD105.2 CD106.2 CD107.2 CD108.2 CD109.2 CD111.2 CD112.2 CD113.2 CE1.2 CE2.2 CE3.2 CE4.2 CE5.2 CE6.2 CE9.2 CE10.2 CE11.2 CE12.2 CE14.2 CE15.2 CE18.2 CE19.2 CE20.2 CE21.2 CE25.2 CE26.2 CE30.2 CE31.2 CE32.2 CE34.2 CE35.2 CE37.2 CE41.2 CE44.2 CE50.2 CE113.2 CE115.2 CE116.2 CI13.2 CI14.2 CI21.2 CI22.2 CI23.2 CI24.2 CI25.2 CI28.2 CI29.2 CI30.2 CI31.2 CI32.2 CK1.2 CK2.2 CK3.2 CK8.2 CK9.2 CK10.2 CK11.2 CK12.2 CK13.2 CLCMOS1.2 CLEC1.2 CLIP1.1 CLIP2.1 CLIP3.1 CLIP4.1 CLIP5.1 CLIP6.1 CLME1.1 CM46.2 CM47.2 CM48.2 CN1.2 CN2.2 CN3.2 CN4.2 CN5.2 CN6.2 CN7.2 CN8.2 CN9.2 CN10.2 CN11.2 CN12.2 CN13.2 CN18.2 CN21.2 CN22.2 CN23.2 CN24.2 CN25.2 CN26.2 CN27.2 CN28.2 CN29.2 CN30.2 CN31.2 CN32.2 CN33.2 CN34.2 CN35.2 CN36.2 CN41.2 CN42.2 CN43.2 CN44.2 CN45.2 CN46.2 CN47.2 CN48.2 CN57.2 CN58.2 CN59.2 CP1.2 CP2.2 CR1.2 CR2.2 CR3.2 CR4.2 CR5.2 CR8.2 CR9.2 CR10.2 CR11.2 CR12.2 CR13.2 CR14.2 CR15.2 CR16.2 CR18.2 CR20.2 CS2.2 CS3.2 CS4.2 CS5.2 CS6.2 CS7.2 CS8.2 CS9.2 CS10.2 CS11.2 CS12.2 CS13.2 CS14.2 CS15.2 CT37.2 CT38.2 CT51.2 CT52.2 CT53.2 CT54.2 CT55.2 CT56.2 CT57.2 CT58.2 CT59.2 CT60.2 CT61.2 CT62.2 CT63.2 CT64.2 CT65.2 CT66.2 CT67.2 CT68.2 CT69.2 CT70.2 CT71.2 CT72.2 CT73.2 CT74.2 CT75.2 CT76.2 CT77.2 CT78.2 CT79.2 CT80.2 CT81.2 CT94.2 CT95.2 CT96.2 CT97.2 CT98.2 CT99.2 CT100.2 CT101.2 CT102.2 CT103.2 CT104.1 CT105.1 CT106.1 CT107.1 CT108.1 CT109.1 CT110.1 CT111.1 CT129.2 CT130.2 CT131.2 CT132.2 CT133.2 CT134.2 CT135.2 CT136.2 CT137.2 CT138.2 CT139.2 CT140.2 CT141.2 CT142.2 CT143.2 CT144.2 CT145.2 CT146.2 CT147.2 CT148.2 CT149.2 CT150.2 CT151.2 CT152.2 CT153.2 CT154.2 CT155.2 CT156.2 CT157.2 CT158.2 CT159.2 CT160.2 CT161.2 CT162.2 CT163.2 CT164.2 CT165.2 CT166.2 CT167.2 CT168.2 CT169.2 CT170.2 CT171.2 CT172.2 CT173.2 CT174.2 CT175.2 CT176.2 CT177.2 CT178.2 CT179.2 CT180.2 CT181.2 CT182.2 CT183.2 CT184.2 CT185.2 CT186.2 CT187.2 CT188.2 CT189.2 CT190.2 CT191.2 CT192.2 CT193.2 CT194.2 CT195.2 CT196.2 CT197.2 CT198.2 CT199.2 CT200.2 CT201.2 CT202.2 CT205.2 CT206.2 CV1.2 CV2.2 CV3.2 CV4.2 CV13.2 CV19.2 CV20.2 CV21.2 CV22.2 CV23.2 CV24.2 CV25.2 CV26.2 CV27.2 CV31.2 CV32.2 CV33.2 CV34.2 CV37.2 CV38.2 CV39.2 CV40.2 CV41.2 CV42.2 CV43.2 CV44.2 CV45.2 CV50.2 CV51.2 CV52.2 CV53.2 CV55.2 CV56.2 CZ1.2 CZ2.2 CZ3.2 CZ5.2 CZ6.2 CZ7.2 CZ15.2 CZ16.2 CZ17.2 CZ18.2 CZ19.2 CZ20.2 CZ21.2 CZ22.2 CZ23.2 CZ28.2 D3.3 D9.2 DA1.2 DA4.1 DA5.1 DA8.1 DA9.1 DA10.2 DA11.2 DA12.2 DA13.2 DA25.2 DA26.2 DE4.2 DI7.2 DI8.2 DI9.3 DI13.2 DI14.2 DI15.2 DI16.2 DI17.2 DI18.2 DM1.2 DM2.2 DM3.2 DM4.2 DM5.2 DM6.2 DM7.2 DM8.2 DP1.2 DP2.2 DP3.2 DP4.2 DS1.3 DS2.1 DT4.2 DT6.2 DT7.1 DT8.2 DT9.1 DT10.2 DT11.1 DT12.2 DT13.1 DT14.2 DT15.1 DT16.2 DT17.1 DT18.2 DT19.1 DT20.2 DT21.1 DT22.2 DT23.1 DT24.2 DT25.1 DT26.2 DT27.1 DT28.2 DT29.1 DT30.2 DT31.1 DT32.2 DT33.1 DT34.2 DT35.1 DT42.1 DT43.2 DT44.1 DT45.2 DT46.1 DV4.2 DV5.2 DV6.2 DV7.2 DV10.2 DV11.2 DV12.2 H5.1(TP-1) H6.1(TP-1) H7.1(TP-1) H8.1(TP-1) H9.1(TP-1) H10.1(TP-1) H30.1(TP-1) H31.1(TP-1) H32.1(TP-1) H33.1(TP-1) H34.1(TP-1) H35.1(TP-1) H36.1(TP-1) H37.1(TP-1) H38.1(TP-1) H39.1(TP-1) JANT1.2 JANT1.3 JANT1.4 JANT2.2 JANT2.3 JANT2.4 JAPS1.8 JAPS1.10 JAPS1.12 JAPS1.14 JAPS1.19 JAPS1.20 JBATT1.8 JBATT1.9 JBATT1.10 JBATT1.11 JBATT1.12 JBATT1.13 JBATT1.14 JBL1.1 JBL1.5 JBL1.6 JCAM1.12 JCAM1.14 JCAM1.15 JCAM1.22 JCAM1.23 JCR1.6 JCR1.10 JCR1.11 JCR1.12 JCR1.13 JCR1.14 JCR1.17 JCR1.20 JCR1.23 JDEG1.10 JDEG1.11 JDEG1.12 JEDP1.9 JEDP1.10 JEDP1.20 JEDP1.30 JEDP1.35 JEDP1.38 JEDP1.41 JEDP1.42 JEDP1.43 JEDP1.44 JEDP1.45 JEDP1.46 JEDP1.47 JEDP1.48 JEDP1.49 JEDP1.50 JEDP1.51 JEDP1.52 JEDP1.53 JEDP1.54 JEDP1.55 JEDP1.56 JEDP1.57 JEDP1.58 JEDP1.59 JEDP1.60 JEDP1.61 JEDP1.62 JEDP1.63 JEDP1.64 JEDP1.65 JEDP1.66 JEDP1.67 JEDP1.68 JEDP1.69 JEDP1.70 JEDP1.71 JEDP1.72 JEDP1.73 JEDP1.74 JESPI1.9 JESPI1.11 JESPI1.12 JFAN1.1 JFAN1.5 JFAN1.6 JFP1.9 JFP1.15 JHDMI1.2 JHDMI1.5 JHDMI1.8 JHDMI1.11 JHDMI1.17 JHDMI1.20 JHDMI1.21 JHDMI1.22 JHDMI1.23 JKB1.29 JKB1.31 JKB1.33 JKB1.34 JLED1.4 JLED1.5 JLED1.6 JLTE1.6 JLTE1.7 JLTE1.8 JLTE1.9 JLTE1.10 JLTE1.11 JLTE2.6 JLTE2.7 JLTE2.8 JLTE2.9 JLTE2.10 JLTE2.11 JNGFF1.3 JNGFF1.5 JNGFF1.11 JNGFF1.27 JNGFF1.33 JNGFF1.39 JNGFF1.45 JNGFF1.51 JNGFF1.57 JNGFF1.71 JNGFF1.73 JNGFF1.76 JNGFF1.77 JNGFF2.1 JNGFF2.3 JNGFF2.9 JNGFF2.15 JNGFF2.21 JNGFF2.27 JNGFF2.33 JNGFF2.39 JNGFF2.45 JNGFF2.51 JNGFF2.57 JNGFF2.71 JNGFF2.73 JNGFF2.75 JNGFF2.76 JNGFF2.77 JNGFF3.1 JNGFF3.7 JNGFF3.13 JNGFF3.18 JNGFF3.19 JNGFF3.33 JNGFF3.39 JNGFF3.45 JNGFF3.51 JNGFF3.57 JNGFF3.63 JNGFF3.69 JNGFF3.75 JNGFF3.76 JNGFF3.77 JPTN1.4 JPTN1.5 JPTN1.6 JRTC1.2 JRTC1.3 JRTC1.4 JSIM1.3 JSIM1.4 JSIM1.5 JSIM1.6 JSIM1.7 JSIM1.8 JSIM1.9 JSIM1.C5 JSPI1.10 JSPI1.11 JSPI1.12 JSPK1.6 JSPK1.7 JSPK1.8 JTP1.5 JTP1.9 JTP1.10 JUSB1.4 JUSB1.7 JUSB1.10 JUSB1.11 JUSB1.12 JUSB1.13 JUSB2.4 JUSB2.7 JUSB2.10 JUSB2.11 JUSB2.12 JUSB2.13 JUSBC1.1 JUSBC1.2 JUSBC1.3 JUSBC1.4 JUSBC1.5 JUSBC1.6 JUSBC1.A1 JUSBC1.A12 JUSBC1.B1 JUSBC1.B12 JUSBC2.1 JUSBC2.2 JUSBC2.3 JUSBC2.4 JUSBC2.5 JUSBC2.6 JUSBC2.A1 JUSBC2.A12 JUSBC2.B1 JUSBC2.B12 JUSH1.6 JUSH1.7 JUSH1.10 JUSH1.24 JUSH1.27 JUSH1.28 JXDP1.2 JXDP1.7 JXDP1.8 JXDP1.13 JXDP1.14 JXDP1.19 JXDP1.20 JXDP1.25 JXDP1.26 JXDP1.31 JXDP1.32 JXDP1.37 JXDP1.38 JXDP1.49 JXDP1.50 JXDP1.59 JXDP1.61 JXDP1.62 JXDP1.63 LN12.2 LN13.2 LN14.2 LN15.2 PC100.2 PC101.2 PC102.2 PC103.2 PC104.2 PC105.2 PC106.2 PC107.2 PC108.2 PC109.2 PC112.2 PC113.2 PC114.2 PC115.2 PC116.2 PC117.2 PC118.2 PC119.2 PC120.2 PC121.2 PC122.2 PC130.2 PC131.2 PC132.2 PC133.2 PC134.2 PC135.2 PC136.2 PC137.2 PC138.2 PC139.2 PC140.2 PC141.2 PC142.2 PC143.2 PC200.1 PC201.2 PC202.2 PC203.2 PC204.2 PC205.2 PC206.2 PC207.2 PC208.2 PC209.2 PC211.2 PC212.2 PC213.2 PC214.2 PC215.2 PC216.2 PC217.2 PC218.2 PC219.2 PC221.2 PC222.2 PC223.2 PC224.2 PC226.1 PC227.2 PC228.2 PC229.1 PC231.2 PC232.2 PC233.2 PC234.2 PC235.2 PC236.1 PC237.2 PC238.1 PC240.2 PC241.2 PC243.2 PC244.2 PC245.2 PC300.2 PC301.2 PC302.2 PC303.2 PC304.2 PC306.2 PC307.2 PC308.2 PC309.2 PC311.2 PC312.2 PC313.2 PC314.2 PC401.2 PC402.2 PC403.2 PC404.2 PC405.1 PC406.2 PC407.2 PC408.2 PC409.2 PC410.2 PC411.2 PC412.2 PC414.2 PC415.2 PC416.2 PC417.2 PC418.1 PC419.2 PC420.2 PC421.2 PC422.2 PC423.2 PC424.2 PC425.2 PC426.2 PC501.2 PC502.2 PC503.2 PC504.2 PC506.2 PC507.2 PC508.2 PC509.2 PC510.2 PC512.2 PC600.2 PC601.2 PC602.2 PC603.2 PC604.2 PC606.2 PC607.2 PC608.2 PC610.2 PC611.2 PC612.2 PC613.2 PC614.2 PC615.2 PC616.2 PC619.2 PC620.2 PC700.1 PC800.2 PC801.2 PC802.2 PC804.2 PC805.2 PC807.2 PC808.2 PC809.2 PC810.2 PC811.2 PC813.2 PC900.2 PC901.2 PC902.2 PC903.2 PC905.1 PC906.2 PC908.2 PC909.1 PC910.1 PC911.1 PC913.2 PC914.2 PC1000.2 PC1001.2 PC1002.2 PC1003.2 PC1004.2 PC1005.2 PC1007.2 PC1008.2 PC1010.2 PC1011.2 PC1013.2 PC1015.2 PC1016.2 PC1017.2 PC1018.2 PC1019.2 PC1020.2 PC1022.2 PC1100.2 PC1101.2 PC1102.2 PC1103.2 PC1104.2 PC1105.2 PC1107.2 PC1108.2 PC1109.2 PC1110.2 PC1111.2 PC1112.2 PC1113.2 PC1114.2 PC1116.2 PC1117.2 PC1118.2 PC1119.2 PC1200.2 PC1201.2 PC1202.2 PC1203.2 PC1204.2 PC1205.2 PC1206.2 PC1214.2 PC1215.2 PC1216.2 PC1217.2 PC1218.2 PC1219.2 PC1220.2 PC1221.2 PC1222.2 PC1223.2 PC1224.2 PC1232.2 PC1233.2 PC1234.2 PC1235.2 PC1236.2 PC1237.2 PC1238.2 PC1239.2 PC1240.2 PC1241.2 PC1242.2 PC1243.2 PC1244.2 PC1245.2 PC1246.2 PC1247.2 PC1248.2 PC1249.2 PC1250.2 PC1251.2 PC1252.2 PC1253.2 PC1254.2 PC1255.2 PC1256.2 PC1257.2 PC1258.2 PC1259.2 PC1260.2 PC1261.2 PC1262.2 PC1263.2 PC1264.2 PC1265.2 PC1266.2 PC1267.2 PC1268.2 PC1269.2 PC1270.2 PC1271.2 PC1272.2 PC1273.2 PC1274.2 PC1275.2 PC1276.2 PC1277.2 PC1278.2 PC1279.2 PC1280.2 PC1281.2 PC1282.2 PC1283.2 PC1284.2 PC1285.2 PC1286.2 PC1287.2 PC1288.2 PC1289.2 PC1290.2 PC1291.2 PC1292.2 PC1293.2 PC1294.2 PC1295.2 PC1296.2 PC1297.2 PC1298.2 PC1299.2 PC1300.2 PC1301.2 PC1302.2 PC1303.2 PC1304.2 PC1305.2 PC1306.2 PC1307.2 PC1308.2 PC1309.2 PC1310.2 PC1311.2 PC1312.2 PC1313.2 PC1314.2 PC1315.2 PC1316.2 PC1323.2 PC1324.2 PC1325.2 PC1326.2 PC1327.2 PC1328.2 PC1329.2 PC1330.2 PC1331.2 PC1332.2 PC1333.2 PC1334.2 PC1335.2 PC1336.2 PC1337.2 PC1338.2 PC1339.2 PC1340.2 PC1341.2 PC1342.2 PC1343.2 PC1344.2 PC1345.2 PC1346.2 PC1347.2 PC1348.2 PC1349.2 PC1350.2 PC1351.2 PC1352.2 PC1353.2 PC1354.2 PC1355.2 PC1356.2 PC1357.2 PC1358.2 PC1359.2 PC1360.2 PC1361.2 PC1362.2 PC1363.2 PC1364.2 PC1365.2 PC1366.2 PC1367.2 PC1368.2 PC1369.2 PC1370.2 PC1371.2 PC1372.2 PC1373.2 PC1374.2 PC1375.2 PC1376.2 PC1377.2 PC1378.2 PC1379.2 PC1380.2 PC1381.2 PC1382.2 PC1383.2 PC1401.2 PC1402.2 PC1403.2 PC1404.2 PC1405.2 PC1406.2 PC1407.2 PC1408.2 PC1409.2 PC1411.2 PC1412.2 PC1413.2 PC1414.2 PC1415.2 PC1416.2 PC1417.2 PC1418.2 PC1419.2 PC1421.2 PC1422.2 PC1423.2 PC1424.2 PC1425.2 PC1426.2 PC1500.2 PC1501.2 PC1502.2 PC1503.2 PC1504.2 PC1505.2 PCB46.2 PD104.1 PD105.1 PD200.2 PQ104.1 PQ104.4 PQ105.1 PQ105.4 PQ106.1 PQ107.3 PQ108.3 PQ109.1 PQ109.4 PQ111.3 PQ113.1 PQ113.4 PQ114.1 PQ114.4 PQ119.1 PQ119.4 PQ120.3 PQ122.3 PQ123.1 PQ123.4 PQ126.3 PQ129.3 PQ130.3 PQ201.3 PQ201.4 PQ201.5 PQ203.3 PQ203.4 PQ203.5 PQ205.3 PQ700.3 PQ1500.3 PQ1501.3 PQ1502.3 PQ1507.3 PR103.2 PR121.1 PR123.2 PR124.2 PR132.2 PR145.2 PR158.1 PR161.2 PR163.2 PR172.2 PR185.2 PR189.2 PR190.2 PR191.2 PR192.2 PR193.2 PR194.2 PR204.2 PR212.1 PR224.1 PR225.2 PR226.2 PR227.2 PR232.2 PR304.2 PR307.2 PR308.2 PR400.1 PR408.1 PR413.2 PR414.2 PR504.2 PR606.2 PR607.2 PR705.2 PR706.2 PR806.2 PR808.2 PR905.2 PR930.1 PR932.1 PR935.1 PR936.1 PR939.1 PR941.1 PR942.1 PR944.2 PR1408.2 PR1410.2 PR1411.2 PR1412.1 PR1413.2 PR1419.2 PR1426.2 PR1427.2 PR1512.1 PR1513.1 PR1515.1 PR1516.2 PR1519.1 PRB40.2 PRB41.2 PU101.2 PU102.2 PU200.33 PU300.2 PU300.6 PU300.11 PU300.12 PU300.13 PU300.14 PU300.15 PU300.16 PU300.17 PU300.18 PU400.2 PU400.10 PU401.2 PU401.10 PU500.2 PU500.3 PU500.4 PU500.9 PU600.4 PU600.9 PU600.15 PU700.4 PU700.6 PU800.7 PU800.8 PU800.18 PU800.21 PU900.49 PU1000.5 PU1000.6 PU1000.7 PU1000.13 PU1001.5 PU1001.6 PU1001.7 PU1001.13 PU1100.5 PU1100.6 PU1100.7 PU1100.13 PU1101.4 PU1101.5 PU1101.11 PU1400.2 PU1400.11 PU1401.2 PU1401.11 PU1500.2 PU1501.2 PUB2.3 QB6.1 QB6.4 QC2.3 QE1.3 QE10.3 QE11.3 QE26.3 QK1.3 QM3.3 QN3.3 QN10.3 QR1.3 QT1.3 QT3.1 QT3.4 QV5.3 QV7.3 QV11.1 QV11.4 R28.2 R145.2 R210.2 R238.2 R240.2 R242.2 R266.2 R267.2 RA1.1 RA4.2 RA5.1 RA6.1 RA8.2 RA121.2 RB25.2 RB34.2 RC2.2 RC4.2 RC6.2 RC10.2 RC11.2 RC12.2 RC13.2 RC47.2 RC48.2 RC49.2 RC57.2 RC76.2 RC77.2 RC92.2 RC106.2 RC107.2 RC108.2 RC109.2 RC116.2 RC120.1 RC124.1 RC151.2 RC161.2 RC164.2 RC165.2 RC217.1 RC223.1 RC244.1 RC258.1 RC381.2 RC397.2 RC402.2 RC405.1 RC406.1 RC407.1 RC408.1 RC409.1 RC410.1 RC411.1 RC412.1 RC413.1 RC414.1 RC415.1 RC416.1 RC417.1 RC418.1 RC419.1 RC420.2 RC439.1 RC444.2 RC446.2 RC452.2 RC454.2 RC458.2 RC459.2 RC460.2 RC481.1 RC485.2 RC486.2 RC487.2 RC490.2 RC501.1 RC502.1 RC503.1 RC528.1 RC529.1 RC531.2 RC549.2 RC550.2 RC568.2 RC569.1 RC570.1 RC571.1 RC572.1 RC573.1 RC577.1 RC584.2 RC606.2 RC607.2 RC609.2 RC611.2 RC613.1 RC614.2 RC615.1 RC622.2 RC624.2 RD1.2 RD2.2 RD3.2 RD4.2 RD7.2 RD8.2 RD9.2 RD11.2 RD13.2 RD14.2 RD16.2 RD17.2 RD19.2 RD20.2 RE95.2 RE147.2 RE148.2 RE153.2 RE154.2 RE155.2 RE164.2 RE166.2 RE472.2 RE474.2 RE499.2 RE500.2 RE519.2 RE524.2 RE527.2 RH52.2 RH54.2 RH56.2 RH58.2 RH60.2 RI29.1 RI30.1 RI55.2 RI67.2 RI123.1 RI124.1 RK8.1 RK9.1 RM97.2 RN28.1 RN72.1 RN79.2 RN88.2 RN91.2 RN97.2 RN110.2 RR10.1 RR14.1 RR19.2 RS2.2 RT7.2 RT9.2 RT18.2 RT21.2 RT23.2 RT32.2 RT33.2 RT34.2 RT35.2 RT36.2 RT37.2 RT38.2 RT39.2 RT40.2 RT41.2 RT42.2 RT43.2 RT53.1 RT54.1 RT55.2 RT56.2 RT59.1 RT60.1 RT61.2 RT62.2 RT80.2 RT81.2 RT82.2 RT83.2 RT97.2 RT98.2 RT112.2 RT113.2 RT115.1 RT129.2 RT139.2 RT140.1 RT147.2 RT148.2 RT151.1 RT152.2 RT153.1 RT159.2 RT160.2 RT163.2 RT177.1 RT178.1 RT179.1 RT180.1 RT262.1 RT263.1 RT265.1 RT266.1 RT267.2 RT288.2 RT291.2 RT293.2 RT297.2 RV3.2 RV16.2 RV25.2 RV43.2 RV44.2 RV48.2 RV51.1 RV85.2 RV87.2 RV88.2 RV89.2 RV90.2 RV96.2 RV97.2 RZ1412.2 SW2.3 SW2.4 SW3.4 SW3.5 U4.11 U4.15 U5.3 U6.11 U6.15 U7.3 U8.5 U8.9 U10.3 U11.3 U12.11 U12.15 U15.5 U15.9 U16.A4 U17.2 U19.5 U19.9 U27.4 U32.3 U33.3 UA1.49 UA7.5 UA7.9 UA8.11 UA8.15 UC2.3 UC9.3 UC10.3 UC17.5 UC17.9 UC18.4 UC18.9 UC19.3 UCPU1.A3 UCPU1.A4 UCPU1.AB3 UCPU1.AB4 UCPU1.AB7 UCPU1.AB27 UCPU1.AB30 UCPU1.AB33 UCPU1.AB36 UCPU1.AC5 UCPU1.AC10 UCPU1.AC27 UCPU1.AC30 UCPU1.AD33 UCPU1.AD35 UCPU1.AE7 UCPU1.AE24 UCPU1.AE25 UCPU1.AE26 UCPU1.AE27 UCPU1.AE30 UCPU1.AF3 UCPU1.AF4 UCPU1.AF7 UCPU1.AF25 UCPU1.AF27 UCPU1.AF30 UCPU1.AF33 UCPU1.AF36 UCPU1.AG5 UCPU1.AG10 UCPU1.AG24 UCPU1.AG26 UCPU1.AH24 UCPU1.AH25 UCPU1.AH27 UCPU1.AH28 UCPU1.AH29 UCPU1.AH30 UCPU1.AH31 UCPU1.AH33 UCPU1.AH35 UCPU1.AJ7 UCPU1.AJ25 UCPU1.AJ28 UCPU1.AK3 UCPU1.AK4 UCPU1.AK33 UCPU1.AK36 UCPU1.AL7 UCPU1.AL28 UCPU1.AL29 UCPU1.AL32 UCPU1.AM5 UCPU1.AM10 UCPU1.AM28 UCPU1.AM33 UCPU1.AM35 UCPU1.AN7 UCPU1.AN8 UCPU1.AN25 UCPU1.AN28 UCPU1.AN29 UCPU1.AN30 UCPU1.AN31 UCPU1.AP3 UCPU1.AP4 UCPU1.AP33 UCPU1.AP36 UCPU1.AR4 UCPU1.AR28 UCPU1.AT4 UCPU1.AT33 UCPU1.AT35 UCPU1.AT36 UCPU1.AU4 UCPU1.AU10 UCPU1.AU28 UCPU1.AU29 UCPU1.AU32 UCPU1.AV3 UCPU1.AV4 UCPU1.AV6 UCPU1.AV8 UCPU1.AV25 UCPU1.AV28 UCPU1.AV33 UCPU1.AV36 UCPU1.AW1 UCPU1.AW3 UCPU1.AW4 UCPU1.AW28 UCPU1.AW29 UCPU1.AW30 UCPU1.AW31 UCPU1.AY4 UCPU1.AY33 UCPU1.AY35 UCPU1.B2 UCPU1.B5 UCPU1.B7 UCPU1.B9 UCPU1.B12 UCPU1.B15 UCPU1.B18 UCPU1.B21 UCPU1.B23 UCPU1.B25 UCPU1.B27 UCPU1.B29 UCPU1.B31 UCPU1.B34 UCPU1.B36 UCPU1.B37 UCPU1.BA3 UCPU1.BA4 UCPU1.BA6 UCPU1.BA10 UCPU1.BA28 UCPU1.BB3 UCPU1.BB4 UCPU1.BB33 UCPU1.BB36 UCPU1.BC4 UCPU1.BC8 UCPU1.BC25 UCPU1.BC29 UCPU1.BC32 UCPU1.BD4 UCPU1.BD6 UCPU1.BD7 UCPU1.BD28 UCPU1.BD33 UCPU1.BD35 UCPU1.BD36 UCPU1.BE3 UCPU1.BE4 UCPU1.BE8 UCPU1.BE10 UCPU1.BE28 UCPU1.BE29 UCPU1.BE30 UCPU1.BE31 UCPU1.BF3 UCPU1.BF4 UCPU1.BF33 UCPU1.BF36 UCPU1.BG4 UCPU1.BG25 UCPU1.BG28 UCPU1.BH28 UCPU1.BH29 UCPU1.BH32 UCPU1.BH33 UCPU1.BH35 UCPU1.BJ7 UCPU1.BK2 UCPU1.BK3 UCPU1.BK4 UCPU1.BK7 UCPU1.BK10 UCPU1.BK28 UCPU1.BK33 UCPU1.BL7 UCPU1.BL25 UCPU1.BL28 UCPU1.BL29 UCPU1.BL30 UCPU1.BL31 UCPU1.BL32 UCPU1.BM9 UCPU1.BM33 UCPU1.BM35 UCPU1.BM36 UCPU1.BN7 UCPU1.BN30 UCPU1.BP3 UCPU1.BP4 UCPU1.BP7 UCPU1.BP12 UCPU1.BP15 UCPU1.BP19 UCPU1.BP25 UCPU1.BP32 UCPU1.BP33 UCPU1.BP36 UCPU1.BR16 UCPU1.BR19 UCPU1.BR22 UCPU1.BR25 UCPU1.BT5 UCPU1.BT14 UCPU1.BT15 UCPU1.BT16 UCPU1.BT25 UCPU1.BT28 UCPU1.BT33 UCPU1.BT35 UCPU1.BT36 UCPU1.BU7 UCPU1.BU11 UCPU1.BU16 UCPU1.BU20 UCPU1.BU23 UCPU1.BU24 UCPU1.BU25 UCPU1.BV3 UCPU1.BV4 UCPU1.BV11 UCPU1.BV31 UCPU1.BV33 UCPU1.BW7 UCPU1.BW11 UCPU1.BW15 UCPU1.BW24 UCPU1.BY5 UCPU1.BY11 UCPU1.BY15 UCPU1.BY18 UCPU1.BY19 UCPU1.BY22 UCPU1.BY25 UCPU1.BY28 UCPU1.BY33 UCPU1.BY35 UCPU1.BY36 UCPU1.C4 UCPU1.C9 UCPU1.C21 UCPU1.C25 UCPU1.C29 UCPU1.C33 UCPU1.C36 UCPU1.C37 UCPU1.CA11 UCPU1.CA15 UCPU1.CA22 UCPU1.CA25 UCPU1.CB2 UCPU1.CB3 UCPU1.CB4 UCPU1.CB7 UCPU1.CB11 UCPU1.CB18 UCPU1.CB19 UCPU1.CB20 UCPU1.CB24 UCPU1.CB25 UCPU1.CB33 UCPU1.CC7 UCPU1.CC11 UCPU1.CC14 UCPU1.CC16 UCPU1.CC20 UCPU1.CC24 UCPU1.CC25 UCPU1.CC28 UCPU1.CC31 UCPU1.CD11 UCPU1.CD12 UCPU1.CD14 UCPU1.CD20 UCPU1.CD24 UCPU1.CD25 UCPU1.CE7 UCPU1.CE33 UCPU1.CE35 UCPU1.CE36 UCPU1.CF2 UCPU1.CF3 UCPU1.CF4 UCPU1.CF11 UCPU1.CF14 UCPU1.CF19 UCPU1.CF23 UCPU1.CF28 UCPU1.CG7 UCPU1.CG33 UCPU1.CH31 UCPU1.CJ2 UCPU1.CJ3 UCPU1.CJ4 UCPU1.CJ11 UCPU1.CJ14 UCPU1.CJ19 UCPU1.CJ23 UCPU1.CJ28 UCPU1.CJ33 UCPU1.CJ35 UCPU1.CJ36 UCPU1.CK1 UCPU1.CK4 UCPU1.CK7 UCPU1.CK37 UCPU1.CL2 UCPU1.CM1 UCPU1.CM4 UCPU1.CM5 UCPU1.CM9 UCPU1.CM13 UCPU1.CM17 UCPU1.CM21 UCPU1.CM25 UCPU1.CM29 UCPU1.CM31 UCPU1.CM33 UCPU1.CM37 UCPU1.CN2 UCPU1.CN5 UCPU1.CN9 UCPU1.CN13 UCPU1.CN17 UCPU1.CN21 UCPU1.CN25 UCPU1.CN29 UCPU1.CN37 UCPU1.CP2 UCPU1.CP9 UCPU1.CP11 UCPU1.CP13 UCPU1.CP15 UCPU1.CP19 UCPU1.CP21 UCPU1.CP27 UCPU1.CP35 UCPU1.CP37 UCPU1.CR2 UCPU1.CR6 UCPU1.D5 UCPU1.D6 UCPU1.D8 UCPU1.D9 UCPU1.D21 UCPU1.D25 UCPU1.E9 UCPU1.E23 UCPU1.E27 UCPU1.E29 UCPU1.E31 UCPU1.E33 UCPU1.E35 UCPU1.F2 UCPU1.F3 UCPU1.F4 UCPU1.F12 UCPU1.F15 UCPU1.F18 UCPU1.F21 UCPU1.F24 UCPU1.F33 UCPU1.G9 UCPU1.G21 UCPU1.G27 UCPU1.G33 UCPU1.G35 UCPU1.G36 UCPU1.H9 UCPU1.H21 UCPU1.H27 UCPU1.J5 UCPU1.J6 UCPU1.J12 UCPU1.J15 UCPU1.J18 UCPU1.J21 UCPU1.J24 UCPU1.J33 UCPU1.J36 UCPU1.K3 UCPU1.K4 UCPU1.K9 UCPU1.K21 UCPU1.K22 UCPU1.K24 UCPU1.K25 UCPU1.K27 UCPU1.K28 UCPU1.K29 UCPU1.K30 UCPU1.K31 UCPU1.K32 UCPU1.L6 UCPU1.L27 UCPU1.L33 UCPU1.L35 UCPU1.L36 UCPU1.N6 UCPU1.N25 UCPU1.N27 UCPU1.P3 UCPU1.P4 UCPU1.P7 UCPU1.P10 UCPU1.P33 UCPU1.P36 UCPU1.R27 UCPU1.R28 UCPU1.R29 UCPU1.R30 UCPU1.R31 UCPU1.T7 UCPU1.T27 UCPU1.T30 UCPU1.T33 UCPU1.T35 UCPU1.T36 UCPU1.U7 UCPU1.U24 UCPU1.U26 UCPU1.V3 UCPU1.V4 UCPU1.V26 UCPU1.V27 UCPU1.V30 UCPU1.V33 UCPU1.V36 UCPU1.W7 UCPU1.W10 UCPU1.W27 UCPU1.W30 UCPU1.Y7 UCPU1.Y26 UCPU1.Y27 UCPU1.Y30 UCPU1.Y33 UCPU1.Y35 UD1.B2 UD1.B5 UD1.B6 UD1.B12 UD1.C3 UD1.C5 UD1.C6 UD1.D3 UD1.D8 UD1.D12 UD1.E4 UD1.E5 UD1.E6 UD1.F4 UD1.F5 UD1.F6 UD1.F12 UD1.G3 UD1.G4 UD1.G6 UD1.G8 UD1.G9 UD1.H2 UD1.H10 UD1.J4 UD1.J12 UD1.K2 UD1.K10 UD1.L6 UD1.L8 UD1.L9 UD1.M4 UD1.M5 UD1.M6 UD1.M12 UD1.N4 UD1.N5 UD1.N6 UD1.P3 UD1.P8 UD1.P12 UD1.R4 UD1.R5 UD1.R6 UD1.T2 UD1.T3 UD1.T4 UD1.T5 UD1.T6 UD1.T12 UD2.B2 UD2.B5 UD2.B6 UD2.B12 UD2.C3 UD2.C5 UD2.C6 UD2.D3 UD2.D8 UD2.D12 UD2.E4 UD2.E5 UD2.E6 UD2.F4 UD2.F5 UD2.F6 UD2.F12 UD2.G3 UD2.G4 UD2.G6 UD2.G8 UD2.G9 UD2.H2 UD2.H10 UD2.J4 UD2.J12 UD2.K2 UD2.K10 UD2.L6 UD2.L8 UD2.L9 UD2.M4 UD2.M5 UD2.M6 UD2.M12 UD2.N4 UD2.N5 UD2.N6 UD2.P3 UD2.P8 UD2.P12 UD2.R4 UD2.R5 UD2.R6 UD2.T2 UD2.T3 UD2.T4 UD2.T5 UD2.T6 UD2.T12 UD3.B2 UD3.B5 UD3.B6 UD3.B12 UD3.C3 UD3.C5 UD3.C6 UD3.D3 UD3.D8 UD3.D12 UD3.E4 UD3.E5 UD3.E6 UD3.F4 UD3.F5 UD3.F6 UD3.F12 UD3.G3 UD3.G4 UD3.G6 UD3.G8 UD3.G9 UD3.H2 UD3.H10 UD3.J4 UD3.J12 UD3.K2 UD3.K10 UD3.L6 UD3.L8 UD3.L9 UD3.M4 UD3.M5 UD3.M6 UD3.M12 UD3.N4 UD3.N5 UD3.N6 UD3.P3 UD3.P8 UD3.P12 UD3.R4 UD3.R5 UD3.R6 UD3.T2 UD3.T3 UD3.T4 UD3.T5 UD3.T6 UD3.T12 UD4.B2 UD4.B5 UD4.B6 UD4.B12 UD4.C3 UD4.C5 UD4.C6 UD4.D3 UD4.D8 UD4.D12 UD4.E4 UD4.E5 UD4.E6 UD4.F4 UD4.F5 UD4.F6 UD4.F12 UD4.G3 UD4.G4 UD4.G6 UD4.G8 UD4.G9 UD4.H2 UD4.H10 UD4.J4 UD4.J12 UD4.K2 UD4.K10 UD4.L6 UD4.L8 UD4.L9 UD4.M4 UD4.M5 UD4.M6 UD4.M12 UD4.N4 UD4.N5 UD4.N6 UD4.P3 UD4.P8 UD4.P12 UD4.R4 UD4.R5 UD4.R6 UD4.T2 UD4.T3 UD4.T4 UD4.T5 UD4.T6 UD4.T12 UE1.A6 UE1.A13 UE1.C4 UE1.E6 UE1.H4 UE4.3 UI2.10 UI2.21 UI2.25 UI4.14 UI4.17 UI5.14 UI5.17 UK1.48 UK1.49 ULID1.A1 UM3.2 UN1.2 UN1.5 UN1.11 UN1.20 UN1.21 UN3.7 UN4.2 UN5.2 UN5.3 UR1.33 UR2.2 UT1.A1 UT1.A6 UT1.A7 UT1.A8 UT1.B7 UT1.B8 UT1.D8 UT1.E5 UT1.E6 UT1.E7 UT1.E8 UT1.F5 UT1.F6 UT1.F7 UT1.F8 UT1.G5 UT1.G6 UT1.G7 UT1.G8 UT1.H4 UT1.H5 UT1.H8 UT1.L1 UT2.A1 UT2.A6 UT2.A8 UT2.A10 UT2.A12 UT2.A14 UT2.A16 UT2.A18 UT2.A20 UT2.A22 UT2.AA22 UT2.AA23 UT2.AB1 UT2.AB2 UT2.AB6 UT2.AB8 UT2.AB10 UT2.AB12 UT2.AB14 UT2.AB16 UT2.AB18 UT2.AB20 UT2.AB22 UT2.AC1 UT2.AC2 UT2.AC6 UT2.AC8 UT2.AC10 UT2.AC12 UT2.AC14 UT2.AC16 UT2.AC18 UT2.AC20 UT2.AC22 UT2.B1 UT2.B2 UT2.B6 UT2.B8 UT2.B10 UT2.B12 UT2.B14 UT2.B16 UT2.B18 UT2.B20 UT2.B22 UT2.C22 UT2.C23 UT2.D5 UT2.D6 UT2.D8 UT2.D9 UT2.D11 UT2.D12 UT2.D13 UT2.D15 UT2.D16 UT2.D18 UT2.E4 UT2.E5 UT2.E6 UT2.E8 UT2.E9 UT2.E11 UT2.E15 UT2.E16 UT2.E22 UT2.E23 UT2.F5 UT2.F6 UT2.F9 UT2.F16 UT2.F20 UT2.G22 UT2.G23 UT2.H1 UT2.H2 UT2.H5 UT2.H8 UT2.H12 UT2.H13 UT2.H15 UT2.H16 UT2.H20 UT2.J5 UT2.J8 UT2.J12 UT2.J13 UT2.J15 UT2.J18 UT2.J19 UT2.J20 UT2.J22 UT2.J23 UT2.K1 UT2.K2 UT2.L5 UT2.L13 UT2.L15 UT2.L20 UT2.L22 UT2.L23 UT2.M1 UT2.M2 UT2.M5 UT2.M11 UT2.M12 UT2.M19 UT2.M20 UT2.N5 UT2.N8 UT2.N9 UT2.N11 UT2.N12 UT2.N13 UT2.N15 UT2.N20 UT2.N22 UT2.N23 UT2.P1 UT2.P2 UT2.R5 UT2.R18 UT2.R19 UT2.R20 UT2.R22 UT2.R23 UT2.T1 UT2.T2 UT2.T5 UT2.T6 UT2.T8 UT2.T9 UT2.T13 UT2.T15 UT2.T16 UT2.T18 UT2.T20 UT2.U22 UT2.U23 UT2.V5 UT2.V6 UT2.V8 UT2.V9 UT2.V15 UT2.V16 UT2.V20 UT2.W5 UT2.W6 UT2.W8 UT2.W9 UT2.W13 UT2.W18 UT2.W20 UT2.W22 UT2.W23 UT2.Y9 UT2.Y13 UT2.Y20 UT3.4 UT3.9 UT4.4 UT4.9 UT5.A1 UT5.A6 UT5.A7 UT5.A8 UT5.B7 UT5.B8 UT5.D8 UT5.E5 UT5.E6 UT5.E7 UT5.E8 UT5.F5 UT5.F6 UT5.F7 UT5.F8 UT5.G5 UT5.G6 UT5.G7 UT5.G8 UT5.H4 UT5.H5 UT5.H8 UT5.L1 UT14.3 UT15.2 UT16.2 UV1.2 UV5.5 UV5.6 UV5.7 UV5.8 UV6.10 UZ3.5 UZ4.5 UZ5.5 UZ6.2 UZ6.9 UZ6.16 UZ6.23 UZ6.32 UZ6.33 YC1.2 YC1.4 YT1.2 YT1.4
VBUS1_ECOK: PR134.1 PR154.2 PR1509.1 UE1.N3
VBUS2_ECOK: PR118.2 PR135.1 PR1507.1 UE1.M6
VBUSSENSE: RC49.1 UCPU1.CC6
VCC0V9_LVR_OUT: CT137.1 CT138.1 CT139.1 CT140.1 CT159.1 CT160.1 UT2.F18 UT2.H11 UT2.H18 UT2.J11
VCC0V9_SVR: CT72.1 CT73.1 CT74.1 CT75.1 CT76.1 CT77.1 CT78.1 CT79.1 CT80.1 CT81.1 CT155.1 CT156.1 LT1.2 UT2.E12 UT2.E13 UT2.F11 UT2.F12 UT2.F13 UT2.F15 UT2.J9 UT2.L9 UT2.M9
VCC3V3_ANA_PCIE: CT129.1 CT163.1 CT164.1 RT267.1 UT2.L16
VCC3V3_ANA_USB2: CT130.1 CT165.1 CT166.1 UT2.J16
VCC_1.2V_DDR: PC607.1 PU600.14
VCC_1.8VPRIM: PC510.1 PR503.2 PU500.8
VCC_CORE1: PC1005.1 PR1000.2 PU1000.14
VCC_CORE2: PC1020.1 PR1009.2 PU1001.14
VCC_GT: PC1105.1 PR1100.2 PU1100.14
VCC_PRIM_CORE: PC1419.1 PR1423.1 PU1401.10
VCC_SA: PC1114.1 PR1104.2 PU1101.12
VCC_SENSE: PU900.8 RC150.2 RC430.2
VCC_SENSE_R: RC430.1 UCPU1.AN6
VCC_VCCIO: PC1409.1 PR1403.1 PU1400.10
VCCDSW_EN: RC631.1 UE1.M7
VCCDSW_EN_GPIO: DC1.2 QC2.2 RC540.2 RC631.2
VCCDSW_EN_Q: DC1.1 DC2.2 RC630.1
VCCGT_SENSE: PU900.12 RC160.2 RC432.2
VCCGT_SENSE_R: RC432.1 UCPU1.E3
VCCIO_SENSE: PR1424.2 RC163.2 UCPU1.BP28
VCCPLL_EN: RZ2.2 UZ5.4
VCCSA_SENSE: PU900.16 RC166.2 RC426.2
VCCSA_SENSE_CPU: RC426.1 UCPU1.BG7
VCCST_EN: R247.2 R248.2 R280.2 UZ3.4
VCCST_PWRGD: CC200.1 RC79.2 RC86.1 RC371.1 U7.4
VCCST_PWRGD_CPU: RC86.2 UCPU1.BJ2
VCCSTG_EN: R240.1 RZ2.1 U5.4 UZ4.4
VDD: PC229.2 PR207.2 PR209.1 PR219.1 PU200.18
VDD18_CORE: PR901.2 PR931.1
VIN_PRIM_CORE: PC1412.1 PC1413.1 PC1414.1 PC1415.1 PL1402.2 PU1401.1
VIN_VCCIO: PC1401.1 PC1402.1 PC1406.1 PC1407.1 PL1400.2 PU1400.1
VSS_SENSE: PU900.9 RC151.1 RC429.2
VSS_SENSE_R: RC429.1 UCPU1.AN5
VSSGT_SENSE: PU900.13 RC161.1 RC431.2
VSSGT_SENSE_R: RC431.1 UCPU1.D2
VSSIO_SENSE: PR1412.2 RC165.1 UCPU1.BP29
VSSSA_SENSE: PU900.17 RC164.1 RC425.2
VSSSA_SENSE_CPU: RC425.1 UCPU1.BE7
2.7MM_CAM_DET#: JCAM1.13 RC618.1 UCPU1.BY31
3MM_CAM_DET#: JCAM1.16 RC619.2 UCPU1.CR12
32KHZ_OUT: CE21.1 UE1.F3
+BATT: JBATT1.1 JBATT1.2 JBATT1.3 PC134.1 PC135.1 PL102.2 PL103.2 PL104.2 PR185.1
+CHG_SRC_20V: PC201.1 PC202.1 PC203.1 PC204.1 PC205.1 PC206.1 PC207.1 PC208.1 PC209.1 PQ201.2 PR200.4
+CHG_VIN_20V: DT49.2 PC111.1 PC124.1 PD200.1 PD201.2 PL200.1 PQ101.1 PQ101.2 PQ101.3 PQ103.3 PQ116.1 PQ116.2 PQ116.3 PQ118.3 PR101.1 PR105.1 PR144.1 PR148.1 PR206.1
+CPVDD: CA24.1 CA25.1 RA13.1 UA1.20
+DMIC_DVDD: JCAM1.6 RV35.2 RV68.2 RV69.2
+EC_DEBUG_VCC: JDEG1.1 RE90.2
+INV_PWR_SRC: CV24.1 CV25.1 CV37.1 DV13.2 JEDP1.1 JEDP1.2 RV77.2 RV93.1
+INV_PWR_SRC_D: CV38.1 DV13.1 RV39.2 RV43.1
+INV_PWR_SRC_L: CV13.1 QV10.1 QV10.2 QV10.5 QV10.6 RV77.1
+INV_PWR_SRC_Q: QV11.6 RV93.2
+IR_B+: JCAM1.19 JCAM1.20 JCAM1.21 RV75.2
+LCDVDD: CV3.1 CV4.1 CV20.1 CV21.1 CV22.1 CV23.1 CV40.1 CV56.1 DV14.2 JEDP1.12 JEDP1.13 RV40.1 RV78.2
+LCDVDD_D: CV41.1 DV14.1 RV46.2 RV48.1
+LCDVDD_L: RV78.1 RV91.2 UV1.1
+LDO_BMC_PD_A: CT96.1 UT1.E1
+LDO_BMC_PD_B: CT99.1 UT5.E1
+LED1: LED1.2 R102.2
+LED_PRI: LED_PRI.2 R101.2
+LED_RST: LED_RST.2 R140.2
+LED_RUN: LED_RUN.2 R139.2
+PECI_VREF: CE20.1 RE144.1 UE1.J11
+RTC_CELL_VBAT: CE1.1 RE103.2 UE1.A2
+RTCBATT: JRTC1.1 RB21.1
+RTCVCC: CB15.1 CC72.1 CC73.1 QB5.1 RB22.1 RC68.2 RC71.2 RC78.2 UCPU1.BR23
+RTCVCC_R: CB16.1 DB3.1 DB4.1 PQ1506.3 PR1511.2 QB5.3 RA10.2 RB40.1 RE103.1 RE135.2 RE136.2 RE149.1 RE187.1 RE515.2 RTCD3.1
+SD_VDD1: CR9.1 CR10.1 JCR1.4 UR1.12
+SD_VDD2: CR11.1 CR12.1 JCR1.15 UR1.13
+SIM_PWR: CS7.1 CS8.1 DS2.2 DS2.3 JNGFF1.36 JSIM1.C1 RS1.1
+TBT_VBUS1: CT100.1 CT101.1 CT106.2 CT107.2 CT110.2 CT111.2 JUSBC1.A4 JUSBC1.A9 JUSBC1.B4 JUSBC1.B9 PC113.1 PC114.1 PC115.1 PC116.1 PL101.1 PT103.1(TP-1) PT104.1(TP-1) PT105.1(TP-1)
+TBT_VBUS2: CT102.1 CT103.1 CT104.2 CT105.2 CT108.2 CT109.2 JUSBC2.A4 JUSBC2.A9 JUSBC2.B4 JUSBC2.B9 PC100.1 PC101.1 PC102.1 PC103.1 PL100.1 PT100.1(TP-1) PT101.1(TP-1) PT102.1(TP-1)
+V_DDR_REF_CA: CD46.1 RD10.1 UCPU1.F36
+V_DDR_REFA_R: CD67.1 RD15.1 UCPU1.D35
+V_DDR_REFB_R: CD20.1 RD5.1 UCPU1.E36
+VDISPLAY_VCC: CM46.1 CM47.1 JHDMI1.18 RM94.1 RM95.1 UM3.3
+VR_CAP: CE25.1 UE1.C10 UE1.J1
+VREFCA: CD22.1 CD47.1 CD72.1 CD111.1 RD10.2 RD11.1 RD12.2 UD1.H4 UD2.H4 UD3.H4 UD4.H4
+VREFDQ_A: CD21.1 CD71.1 RD15.2 RD16.1 RD18.2 UD2.J11 UD4.J11
+VREFDQ_B: CD19.1 CD70.1 RD4.1 RD5.2 RD6.2 UD1.J11 UD3.J11
AC1_DISC#: PR140.1 PR167.1 PRB46.1 UT1.G11
AC1_OVP: PC143.1 PR131.1 PR188.2 PR191.1
AC2_DISC#: PR127.1 PR141.1 PRB47.1 UT5.G11
AC2_OVP: PC139.1 PR170.1 PR186.2 PR189.1
AC_DIS: PR223.1 RE116.1 UE1.H12
AC_DIS#: PC112.1 PQ106.6 PR107.2 PR108.2 PR109.1 PR129.2 PR130.2
AC_DISC#: PR108.1 UE1.E13
AC_DISC_OUT#: PR106.2 PR228.1
AC_PRESENT: RC82.1 UCPU1.BU35 UE1.K8
ACAV_IN: D481.1 PR1518.2 PRB40.1 PRB42.2 PRB45.2 UE1.C7
ACAV_IN1: PQ205.1 PR219.2 PR220.1 PR225.1 PR1517.2 PRB39.1 PRB45.1
ACC2_ADD_SEL: RV50.2 RV51.2 UV5.3
ALLSYS_PWRGD: RE1.1 RE457.1 RE477.1 RE478.2 RE508.1
ALW_PWRGD_3V_5V: DC2.1 QT1.2 RE509.2 RE511.2 RE512.2 RT302.1
ALWON: RE469.1 RE472.1 UE1.A5
ANT1_CS0: CS13.1 JANT1.1 LS4.1
ANT1_CS0_R: LS4.2 RS9.1
ANT1_CS1: CS14.1 LS5.1 RS14.2
ANT1_CS1_R: LS5.2 U16.B4
ANT2_SP4T: CN60.1 JANT2.1 RS14.1
ANT_RF1: LN13.1 LN15.1 UN3.1
ANT_RF2: CN44.1 CN45.1 UN3.2
ANT_RF3: LN12.1 LN14.1 UN3.9
ANT_RF4: CN42.1 CN43.1 UN3.8
ANTCTL0: JNGFF1.59 LN9.1
ANTCTL1: JNGFF1.61 LN10.1
ANTCTL2: JNGFF1.63 LN11.1
AUD_PWR_EN: RA122.1 UCPU1.CK36
AUD_PWR_EN_R: RA122.2 RA126.2 UA7.3 UA8.3 UA8.5
AUX_EN_WOWL: DN7.3 RE524.1 RN107.1 RN108.2 RN116.2 UE1.D3
AUX_EN_WOWL_R: DN7.1 RN71.2 RN72.2 RN107.2 RN109.2 U4.5
B+: CV16.1 PC214.1 PC215.1 PC216.1 PC217.1 PC218.1 PC219.1 PC221.1 PC222.1 PC223.1 PC224.1 PD202.2 PD1500.2 PL300.1 PL302.1 PL400.1 PL402.1 PL404.1 PL405.1 PL501.1 PL600.1 PL800.1 PL1001.1 PL1002.1 PL1003.1 PL1005.1 PL1101.1 PL1103.1 PL1104.1 PL1400.1 PL1402.1 PQ203.2 PR211.1 PR218.2 PR704.1 PR1501.2 PR1567.1 PR1568.1 QV4.3 QV10.4 RV75.1 RV81.1
B+_1.0V: PC801.1 PC802.1 PC804.1 PC805.1 PL800.2 PU800.2 PU800.3 PU800.4 PU800.5
B+_1.2V_DDR: PC600.1 PC601.1 PC602.1 PC603.1 PC620.1 PL600.2 PU600.10
B+_1.8VPRIM: PC501.1 PC502.1 PC503.1 PC504.1 PL501.2 PU500.1
BAT1_LED#: R151.1 UE1.D10
BAT1_LED#_Q: QZ20.2 QZ21.1
BAT1_LED#_R: JLED1.3 QZ20.3 R151.2
BAT2_LED#: R152.1 UE1.D11
BAT2_LED#_R: JLED1.2 R152.2
BC_CLK_ECE1117: UE1.D13 UK1.33
BC_DAT_ECE1117: RE126.1 UE1.D12 UK1.34
BC_INT#_ECE1117: UE1.E2 UK1.32
BCM5882_ALERT#: JUSH1.13 RE142.1 UE1.G10
BEEP: RA2.1 UE1.H11
BGPO0: RE531.1 UE1.D6
BIA_PWM: CV19.1 JEDP1.4 RV25.1 RV84.2
BIA_PWM_EC: DV3.2 UE1.N1
BL_PWR_MONITOR: QV5.2 RV41.1
BOARD_ID: CE44.1 RE200.2 UE1.J13
BREATH_LED#: LED1.1 QN11.3 UE1.C11
BST_1.0V: PR801.1 PU800.1
BST_1.0V_R: PC803.1 PR801.2
BST_1.2V_DDR: PR603.1 PU600.12
BST_1.8VPRIM: PR507.1 PU500.7
BST_CORE1: PC1006.1 PU1000.15
BST_CORE2: PC1021.1 PU1001.15
BST_GT: PC1106.1 PU1100.15
BST_PRIM_CORE: PR1416.1 PU1401.9
BST_SA: PC1115.1 PU1101.13
BST_VCCIO: PR1404.1 PU1400.9
BT_RADIO_DIS#: QN9.6 RE131.1 UE1.C2
BT_RADIO_DIS#_R: JNGFF3.54 QN9.1 RN77.2
CAPS_LED: JKB1.30 RK7.2
CAPS_LED#: QK3.3 UK1.41
CAPS_LED#_R: CK11.1 QK2.2 QK3.1 RK6.2
CAPS_LED_R: QK2.1 RK7.1
CBN: CA152.2 UA1.24
CBP: CA152.1 UA1.23
CD_WAKE#: RR8.2 RR9.2 UR1.32
CFG0: JXDP1.9 RC120.2 RC256.1 UCPU1.T4
CFG1: JXDP1.11 RC405.2 UCPU1.R4
CFG2: JXDP1.15 RC406.2 UCPU1.T3
CFG3: JXDP1.17 RC253.1 RC407.2 UCPU1.R3
CFG4: JXDP1.27 RC408.2 UCPU1.J4
CFG5: JXDP1.29 RC409.2 UCPU1.M4
CFG6: JXDP1.33 RC410.2 UCPU1.J3
CFG7: JXDP1.35 RC411.2 UCPU1.M3
CFG8: JXDP1.10 RC412.2 UCPU1.R2
CFG9: JXDP1.12 RC413.2 UCPU1.N2
CFG10: JXDP1.16 RC414.2 UCPU1.R1
CFG11: JXDP1.18 RC415.2 UCPU1.N1
CFG12: JXDP1.28 RC416.2 UCPU1.J2
CFG13: JXDP1.30 RC417.2 UCPU1.L2
CFG14: JXDP1.34 RC418.2 UCPU1.J1
CFG15: JXDP1.36 RC419.2 UCPU1.L1
CFG16: JXDP1.6 UCPU1.L3
CFG17: JXDP1.4 UCPU1.L4
CFG18: JXDP1.24 UCPU1.N3
CFG19: JXDP1.22 UCPU1.N4
CFG_RCOMP: RC124.2 UCPU1.AB5
CHG_ACIN: PC211.1 PR201.1 PR204.1 PR209.2 PR1506.2 PU200.19
CHG_ACIN_R: PQ1500.1 PQ1507.1 PR1506.1
CHG_ACOK: PR220.2 PU200.24
CHG_ADP: PC226.2 PR206.2 PU200.16
CHG_AMON: PR230.1 PU200.29
CHG_BGATE: PC233.1 PQ202.4 PU200.32
CHG_BST1: PR205.2 PU200.12
CHG_BST2: PC230.1 PU200.4
CHG_CLK: PR214.2 PU200.22
CHG_CMIN: PR212.2 PU200.20
CHG_COMP: PC241.1 PR231.1 PU200.28
CHG_CSIN: PC210.2 PC213.1 PR203.2 PU200.14
CHG_CSIP: PC210.1 PC212.1 PR202.2 PU200.15
CHG_CSON: PC239.2 PC240.1 PR222.2 PU200.1
CHG_CSOP: PC238.2 PC239.1 PR221.2 PU200.2
CHG_DAT: PR213.2 PU200.21
CHG_DCIN: PC227.1 PR208.2 PU200.17
CHG_LG1: PQ201.6 PU200.9
CHG_LG2: PQ203.6 PU200.7
CHG_LX1: PC225.2 PL201.1 PQ201.7 PR215.1 PU200.10
CHG_LX2: PL201.2 PQ203.7 PR210.1 PR216.1 PU200.6
CHG_OTGPG: PR228.2 PU200.26
