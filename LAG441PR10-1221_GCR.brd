# Allegro board LAG441PR10-1221_GCR.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_PWROK: length 28.1
  TOP w0.127: RC381.1 98.2,13.01 98.92,13.73 v1(98.92,14.46) 98.92,14.8 v2(97.9,15.82)
  IN1 w0.061: v2(97.9,15.82) 97.9,15.39 v4(98,15.29)
  IN3 w0.061: v4(98,15.29) 96.99,16.3 96.99,18.43 97.85,19.28 97.85,21.67 97.45,22.07 97.45,22.4 96.47,23.37 96.47,27.05 95.43,28.09 95.43,29.11 95.19,29.36 95.19,31.92 v5(95.58,32.31)
  BOTTOM w0.127: v5(95.58,32.31) 95.87,32.6 95.87,34.23 96.7,35.06 96.7,35.49 97.4,36.19 UCPU1.BP31
PCH_RSMRST#: length 4.1
  TOP w0.127: RE513.2 263.5,49.51 263.99,50.01 264.15,50.01 265.4,51.25 265.4,51.97 UE1.M5
PCH_RSMRST#_AND: length 357.1
  TOP w0.127: v2(61.95,65) 61.94,65.01 v1(61.94,65.58) RC250.1 ; RE513.1 263.59,48.79 263.64,48.74 v2(263.86,48.74)
  IN1 w0.061: v2(61.95,65) 61.89,65 61.72,65.18 v4(61.72,65.24) ; v2(263.86,48.74) 264.53,48.74 265.16,49.37 v4(265.16,49.51) ; v4(45.3,50.92) 45.68,50.54 46.43,50.54 49.6,47.36 49.6,42.21 52.87,38.95 53.12,38.95 53.75,38.32 53.75,36.15 57.21,32.68 57.21,28.26 56.59,27.64 56.59,16.96 59.96,13.59 68.44,13.59 69.11,14.27 73.58,14.27 73.91,14.6 78.76,14.6 79.77,13.59 90.4,13.59 91.26,14.45 92.64,14.45 93.41,15.23 93.41,15.86 94.9,17.35 95.49,17.35 96.1,17.97 96.1,18.45 98.11,20.46 101.07,20.46 v4(101.43,20.82)
  IN3 w0.061: v5(99.54,29.39) 100.15,28.79 100.15,27.75 101.84,26.06 101.84,22.61 101.43,22.21 v4(101.43,20.82) 101.29,20.68 101.29,19.87 101.95,19.21 101.95,18.52 104.18,16.28 104.87,16.28 105.62,17.03 110.23,17.03 110.47,16.78 114.3,16.78 114.56,17.04 119.97,17.04 121.01,18.08 128.52,18.08 v5(130.28,16.32) ; v4(45.3,50.92) 45.32,50.92 45.86,51.46 45.86,52.34 44.44,53.76 42.95,53.76 42.49,54.22 42.49,55.93 41.84,56.58 41.84,60.3 41.22,60.92 41.22,61.83 41.67,62.27 41.67,63.54 43.91,65.79 52.35,65.79 53.18,64.96 53.82,64.96 55.25,63.52 58.83,63.52 60.84,65.53 60.84,65.73 61.01,65.9 61.38,65.9 61.71,65.57 61.71,65.26 v4(61.72,65.24) ; v5(208.04,20.82) 208.29,21.08 208.29,23.8 208.72,24.22 209.01,24.22 213.65,28.86 213.65,29.4 214.01,29.76 215.9,29.76 218.05,27.6 228.01,27.6 228.83,26.79 236.41,26.79 238.01,25.19 251.05,25.19 252.68,26.82 263.64,26.82 266.86,30.04 266.86,35.74 267.49,36.37 267.49,44.63 265.78,46.34 265.78,48.89 v4(265.16,49.51)
  BOTTOM w0.076: UCPU1.BR36 98.09,33.2 99,32.29 99,31.16 RC568.1 99.24,30.32 99.24,29.7 v5(99.54,29.39)
  BOTTOM w0.127: v5(208.04,20.82) 207.43,20.21 203.6,20.21 198.14,25.67 186.83,25.67 176.55,15.39 139.28,15.39 138.68,14.8 136.68,14.8 136.52,14.95 135.52,14.95 135.09,14.52 131.19,14.52 130.28,15.43 v5(130.28,16.32)
PCH_RTCRST#: length 278.6
  TOP w0.127: v2(186.87,27.72) 186.87,27.57 184.59,25.29 v3(184.53,25.29) 184.44,25.29 178.3,19.15 153.83,19.15 149.81,20.3 141.5,22.88 133.87,30.51 133.87,32.43 132.7,33.6 132.7,36.43 131.32,37.81 129.5,37.81 129.3,37.61 JAPS1.9 128.17,37.61 127.1,38.68 124.81,38.68 120.47,34.33 118.25,34.33 116.66,35.93 116.66,36.94 115.83,37.77 113.3,37.77 112.61,37.08 110.94,37.08 109.18,35.31 107.31,35.31 107.12,35.51 106.22,35.51 105.99,35.27 98.64,35.27 v2(98.05,34.68) ; RB35.2 309.69,2.25 v6(309.5,2.44)
  IN1 w0.061: v4(97.96,35.04) 97.96,34.76 v2(98.05,34.68) ; v6(248.42,45.41) 248.15,45.68 229.89,45.68 229.75,45.55 224.67,45.55 223.8,44.68 212.5,44.68 211.81,43.99 206.86,43.99 195.21,32.34 194.76,32.34 193.45,31.03 190.15,31.03 186.87,27.75 v2(186.87,27.72)
  IN3 w0.061: v5(298.33,12.59) 298.33,12.16 298.78,11.71 301.53,11.01 303.03,10.23 307.23,6.04 307.23,5.52 309.5,3.25 v6(309.5,2.44) ; v5(97.53,28.4) 97.55,28.42 97.55,32.52 98.05,33.02 98.05,34.65 v5(98.09,34.7) 97.96,34.83 v4(97.96,35.04)
  BOTTOM w0.127: v5(97.53,28.4) 97.22,28.09 CC11.1 96.91,27.46 CLCMOS1.1 ; v6(248.42,45.41) 248.86,44.97 248.86,35.25 250.84,33.26 250.84,31.02 253.17,28.69 253.17,27.67 254.44,26.39 254.44,21.31 264.21,11.54 285.93,11.54 288.2,13.81 290.03,13.81 290.33,13.51 297.42,13.51 v5(298.33,12.59)
PCH_RTCX1: length 10.4
  IN3 w0.076: v5(96.49,36.39) 97.05,35.83 97.05,33.47 96.47,32.89 96.47,30.18 96.63,30.02 96.63,28.93 97.43,28.13 98.11,28.13 98.41,27.83 v5(98.53,27.83)
PCH_RTCX1_R: length 3.3
  BOTTOM w0.127: RC403.2 RC66.1 98.53,26.18 CC8.1 98.78,25.29 YC2.1
PCH_RTCX2: length 9.6
  IN3 w0.076: v5(97.89,27.83) 97.86,27.81 97.86,27.75 97.79,27.67 97.24,27.67 96.17,28.74 96.17,29.83 96.01,29.99 96.01,33.08 96.58,33.65 96.58,35.65 v5(96.49,35.74)
PCH_RTCX2_R: length 3.4
  BOTTOM w0.127: RC404.2 97.94,27.2 RC66.2 98.14,26.36 CC10.1 98.14,25.38 YC2.2
PCH_SPI_CLK: length 4.1
  BOTTOM w0.076: RC481.2 106.98,30.14 106.98,29.57 RC466.2
  BOTTOM w0.127: UCPU1.CH37 105.64,32.51 106.53,31.63 RC481.2
PCH_SPI_CLK_R: length 147.3
  TOP w0.127: v2(104.93,26.7) 105.18,26.45 v1(105.18,26.04) 105.18,23.7 105,23.51 104.14,23.51 104,23.37 104,23.1 104.14,22.95 105,22.95 105.14,22.81 105.14,22.61 105,22.47 104.14,22.47 104,22.33 104,22.09 104.14,21.95 105,21.95 105.14,21.81 105.14,21.56 105,21.42 104.14,21.42 104,21.28 104,18.21 103.01,17.22 103.01,16.13 103.97,15.17 RC474.2 106.59,15.17 106.91,14.86 v2(106.91,12.3) ; RZ29.1 46.2,37.72 46.33,37.85 46.56,37.85 46.75,38.04 v2(46.75,39.16)
  IN1 w0.061: v2(106.91,12.3) 106.91,12.82 107.09,13 110.73,13 110.87,13.14 110.87,13.53 110.77,13.63 110.64,13.63 110.55,13.54 110.55,13.36 110.45,13.26 110.32,13.26 110.23,13.36 110.23,13.54 110.14,13.63 110.01,13.63 109.92,13.54 109.92,13.36 109.82,13.26 109.69,13.26 109.6,13.36 109.6,13.54 109.51,13.63 109.38,13.63 109.29,13.54 109.29,13.36 109.19,13.26 109.06,13.26 108.97,13.36 108.97,13.54 108.88,13.63 108.75,13.63 108.66,13.54 108.66,13.36 108.56,13.26 108.43,13.26 108.34,13.36 108.34,13.54 108.25,13.63 108.12,13.63 108.03,13.54 108.03,13.36 107.94,13.26 107.8,13.26 107.71,13.36 107.71,13.54 107.62,13.63 107.42,13.63 107.33,13.54 107.33,13.36 107.23,13.26 107.08,13.26 106.98,13.36 106.98,13.55 106.92,13.62 106.62,13.62 106.55,13.55 106.55,12.24 106.46,12.15 106.28,12.15 106.18,12.24 106.18,13.53 106.09,13.62 105.89,13.62 105.8,13.53 105.8,12.03 106.04,11.8 v4(106.81,11.8) 106.81,11.6 106.55,11.35 56.57,11.35 54.66,13.26 54.66,24.64 55.48,25.46 55.48,27.94 55.02,28.4 55.02,33.13 50.81,37.34 50.81,37.78 49.42,39.16 46.75,39.16 v2(46.75,39.16) ; v2(104.93,26.7) 104.93,26.2 104.86,26.13 104.74,26.13 104.66,26.21 104.66,26.69 104.6,26.75 104.43,26.75 104.37,26.69 104.37,26.22 104.29,26.14 104.17,26.14 104.09,26.22 104.09,26.69 104.02,26.76 103.88,26.76 103.81,26.69 103.81,26.23 103.74,26.16 103.59,26.16 103.53,26.22 103.53,26.69 103.46,26.76 103.31,26.76 103.22,26.68 103.22,26.02 103.33,25.91 107.35,25.91 107.44,26 107.44,26.74 107.38,26.8 107.2,26.8 107.14,26.74 107.14,26.21 107.09,26.16 106.89,26.16 106.83,26.22 106.83,26.76 106.78,26.82 106.62,26.82 106.55,26.75 106.55,26.24 106.49,26.18 105.52,26.18 105.4,26.31 v4(105.4,27.18)
  IN3 w0.061: v5(107.22,28.72) 106.21,27.7 105.92,27.7 v4(105.4,27.18) ; v5(106.93,12.24) 106.81,12.11 v4(106.81,11.8)
  BOTTOM w0.127: RC466.1 107.23,28.72 v5(107.22,28.72) ; JSPI1.4 106.77,12.08 v5(106.93,12.24)
PCH_SPI_CLK_TPM: length 1.8
  TOP w0.127: RZ32.2 RZ29.2 46.07,36.75 UZ6.19
PCH_SPI_CS0#: length 2.9
  BOTTOM w0.127: UCPU1.CG36 104.99,32.41 105.12,32.28 105.12,31.89 105.96,31.06 RC471.2
PCH_SPI_CS0#_R: length 50.3
  TOP w0.127: U27.1 UC18.1 114.25,12.08 114.65,12.49 114.65,13.12 114.98,13.45 114.98,16.93 110.38,21.52 108.44,21.52 107.15,22.81 107.15,26.32 108.02,27.19 108.02,28.26 107.75,28.53 106.98,28.53 106.89,28.62 v3(106.89,28.72) 106.89,28.87 107,28.98 107.22,28.98 107.38,29.14 107.38,29.44 107.19,29.63 v2(106.46,29.63)
  IN1 w0.061: v2(113,12.1) 113.45,11.65 113.45,11.54 113.3,11.39 113.17,11.39 v4(112.71,11.85) ; v4(105.96,30.36) 105.96,30.19 106.46,29.69 v2(106.46,29.63)
  IN3 w0.061: v4(112.71,11.85) 112.71,12.33 112.79,12.41 113.11,12.41 113.18,12.35 113.18,11.54 113.27,11.45 113.47,11.45 113.56,11.54 113.56,12.98 113.65,13.07 113.9,13.07 113.97,13.01 113.97,11.17 113.89,11.09 112.41,11.09 112.32,11.19 112.32,12.32 112.23,12.41 111.98,12.41 111.89,12.32 111.89,11.58 111.79,11.49 111.64,11.49 111.54,11.58 111.54,12.32 111.45,12.41 111.25,12.41 111.16,12.32 111.16,11.85 111.07,11.75 110.89,11.75 110.79,11.85 110.79,12.3 110.7,12.39 110.49,12.39 110.37,12.27 v5(110.37,11.28) ; v5(105.96,30.02) v4(105.96,30.36)
  BOTTOM w0.127: v5(110.37,11.28) 110.37,10.8 110.26,10.69 110.01,10.69 109.89,10.8 109.89,11.35 109.78,11.46 109.47,11.46 109.37,11.36 109.37,10.83 109.23,10.69 106.68,10.69 106.27,11.1 JSPI1.5
PCH_SPI_CS1#: length 8.8
  TOP w0.127: v2(104.99,32.96) 105.43,33.4 105.43,33.65 v1(105.83,34.04) 106.53,34.04 108.11,32.45 108.11,29.3 RC472.2
  IN1 w0.061: v2(104.99,32.96) v4(104.99,33.34)
  IN3 w0.061: v5(104.99,33.72) v4(104.99,33.34)
PCH_SPI_CS1#_R: length 29.4
  TOP w0.127: v2(108.29,11.45) 114.03,11.45 114.91,12.32 114.91,13.02 115.28,13.39 115.28,17.11 v1(111.92,20.47) 110.61,21.78 108.59,21.78 107.4,22.97 107.4,26.13 108.5,27.23 RC472.1
  IN1 w0.061: v2(108.29,11.45) 108.27,11.47 v4(108.27,11.8)
  IN3 w0.061: v5(108.27,12.26) v4(108.27,11.8)
  BOTTOM w0.127: JSPI1.1 v5(108.27,12.26)
PCH_SPI_CS2#: length 122.7
  IN1 w0.061: v2(45.1,37.51) 44.75,37.86 44.75,38.14 44.87,38.26 45.19,38.26 45.26,38.33 45.26,38.43 45.18,38.51 44.67,38.51 44.6,38.58 44.6,38.67 44.67,38.74 45.11,38.74 45.17,38.81 45.17,38.91 45.1,38.99 44.67,38.99 44.6,39.06 44.6,40.23 45.1,40.73 45.1,41.35 44.67,41.78 43.96,41.78 43.46,42.28 43.46,42.93 43.76,43.22 46.04,43.22 46.48,42.78 46.48,40.73 46.37,40.62 46.18,40.62 46.1,40.7 46.1,41.28 46.03,41.35 45.93,41.35 45.86,41.28 45.86,40.97 45.78,40.89 45.69,40.89 45.61,40.97 45.61,41.28 45.54,41.35 45.44,41.35 45.37,41.28 45.37,40.44 45.04,40.12 45.04,39.42 45.5,38.96 45.5,38.74 45.68,38.56 45.68,37.52 45.76,37.45 45.9,37.45 45.96,37.51 45.96,38.4 46.03,38.47 46.13,38.47 46.2,38.4 46.2,37.56 46.28,37.48 46.4,37.48 46.46,37.54 46.46,38.41 46.58,38.53 49.25,38.53 49.83,37.94 49.83,37.2 50.17,36.86 50.51,36.86 53.47,33.9 v4(53.47,31.53)
  IN2 w0.061: v4(106.29,22.67) 106.28,22.66 105.55,22.66 104.81,21.91 103.07,21.91 101.02,19.86 95.52,19.86 95.03,20.35 95.03,21.65 94.04,22.64 94.04,25.62 94.26,25.84 94.26,27.73 93.65,28.33 74.96,28.33 73.82,27.19 71.73,27.19 71.67,27.25 71.67,27.76 71.59,27.83 71.49,27.83 71.42,27.76 71.42,27.26 71.35,27.19 71.25,27.19 71.18,27.25 71.18,27.77 71.12,27.83 71,27.83 70.93,27.77 70.93,27.26 70.86,27.19 70.76,27.19 70.69,27.25 70.69,27.77 70.63,27.83 70.51,27.83 70.45,27.77 70.45,27.26 70.37,27.19 70.27,27.19 70.2,27.25 70.2,27.75 70.13,27.83 70.03,27.83 69.96,27.76 69.96,27.26 69.88,27.19 69.78,27.19 69.72,27.25 69.72,27.75 69.64,27.83 69.54,27.83 69.47,27.76 69.47,27.26 69.4,27.19 69.29,27.19 69.23,27.25 69.23,27.72 69.16,27.79 69.06,27.79 68.98,27.72 68.98,27.26 68.91,27.19 68.81,27.19 68.74,27.25 68.74,27.7 68.67,27.77 68.57,27.77 68.5,27.7 68.5,27.26 68.42,27.19 68.21,27.19 66.87,28.53 65.57,28.53 65.26,28.23 60.16,28.23 59.9,28.48 57.16,28.48 56.34,29.3 55.47,29.3 54.27,30.5 54.27,31.04 53.79,31.53 v4(53.47,31.53)
  IN3 w0.061: v4(106.29,22.67) 106.72,23.1 106.72,27.65 107.6,28.53 107.6,28.96 107.43,29.13 106.95,29.13 106.34,29.74 106.34,30.82 105.36,31.79 105.36,33.76 105.12,34 105.12,34.58 v5(105.24,34.7)
  BOTTOM w0.127: UCPU1.CH34 v5(105.24,34.7)
PCH_SPI_CS2#_TPM: length 1.6
  TOP w0.127: RZ30.2 45.06,36.65 45.26,36.45 45.48,36.45 45.61,36.33 45.61,36.15 45.57,36.11 UZ6.20
PCH_SPI_IO2: length 9.3
  IN3 w0.061: v5(104.74,34.66) 104.61,34.54 104.61,32.09 105.48,31.22 105.48,30.01 106.36,29.13 106.36,28.5 v5(105.97,28.1)
  BOTTOM w0.127: RC469.2 107.24,28.09 RC483.1 RC486.1 105.98,28.09 v5(105.97,28.1) ; v5(104.74,34.66) 104.38,34.66 UCPU1.CF34
PCH_SPI_IO2_R: length 161.4
  TOP w0.127: v2(111.29,11.79) 111.29,14.24 112.3,15.26 113.7,15.26 113.99,15.55 RC476.2 114.34,15.86 110.68,19.51 110.68,20.49 110.15,21.01 108.2,21.01 106.51,22.7 v1(106.51,24.78) v2(106.51,27.21) ; v2(50.64,60.1) 50.37,60.37 50.37,61.5 51.09,62.22 51.09,63.86 51.5,64.27 51.5,65.82 51.95,66.27 51.95,66.82 51.66,67.11 RC243.2
  IN1 w0.061: v2(106.51,27.21) 107.05,27.21 v4(107.55,27.72) ; v4(51.14,59.89) 50.85,59.89 v2(50.64,60.1) ; v4(53.07,54.26) 52.64,53.83 50.98,53.83 50.4,53.25 50.4,52.96 49.91,52.14 48.55,50.77 47.74,50.77 46.13,51.32 45.17,51.32 44.86,51.01 44.86,50.6 44.96,50.5 44.96,50.25 44.73,50.02 42.73,50.02 42.58,49.87 42.42,49.45 42.23,48.3 42.23,47.12 42.56,46.78 42.56,44.75 43.26,44.05 43.26,42.22 44.02,41.46 44.7,41.46 44.91,41.25 44.91,40.81 44.41,40.31 44.41,37.93 44.83,37.35 44.96,37.22 46.05,37.22 51.59,31.69 51.59,30.56 51.83,30.32 51.83,28.42 54.09,26.16 54.09,13.04 56.33,10.79 110.51,10.79 v4(110.83,11.12) 110.83,11.33 v2(111.29,11.79)
  IN2 w0.061: v4(51.14,59.89) 50.63,59.38 50.63,56.94 53.07,54.5 v4(53.07,54.26)
  IN3 w0.061: v5(111.15,10.98) 110.97,10.98 v4(110.83,11.12) ; v5(107.29,27.45) v4(107.55,27.72)
  BOTTOM w0.127: JSPI1.6 105.77,11.24 106.58,10.43 110.53,10.43 111.07,10.98 v5(111.15,10.98)
PCH_SPI_IO3: length 6.3
  BOTTOM w0.076: RC484.1 106.58,29.43 RC470.2 105.94,29.43 105.62,29.75 105.62,30.3 RC487.1
  BOTTOM w0.127: UCPU1.CG34 104.99,34.17 104.66,33.83 104.66,32.42 104.97,31.66 105.32,31.31 RC487.1
PCH_SPI_IO3_R: length 46.3
  TOP w0.127: v2(104.62,14.05) 104.47,13.9 RC477.2 103.9,13.9 103.75,14.05 103.75,14.31 103.49,14.56 103.21,14.56 102.58,15.2 102.58,17.75 103.57,18.74 103.57,23.72 v1(104.34,24.5) 104.34,26.67 v2(104.73,27.06)
  IN1 w0.061: v4(105.4,27.72) 105.39,27.72 v2(104.73,27.06) ; v4(105.38,11.8) 105.21,11.8 104.98,12.03 104.98,12.44 104.89,12.53 103.06,12.53 103,12.59 103,12.74 103.07,12.82 104.88,12.82 104.96,12.91 104.96,13.04 104.89,13.11 103.54,13.11 103.47,13.19 103.47,13.34 103.54,13.42 105.1,13.42 105.18,13.49 105.18,13.67 105.1,13.75 101.76,13.75 101.68,13.67 101.68,12.33 101.59,12.24 101.46,12.24 101.37,12.33 101.37,13.66 101.28,13.75 101.15,13.75 101.05,13.66 101.05,12.33 100.96,12.24 100.83,12.24 100.74,12.33 100.74,13.66 100.65,13.75 100.52,13.75 100.42,13.66 100.42,12.33 100.33,12.24 100.2,12.24 100.11,12.33 100.11,14 100.16,14.05 v2(104.62,14.05)
  IN3 w0.061: v4(105.4,27.72) 105.4,27.98 106.06,28.65 v5(106.06,28.87) ; v5(105.38,12.25) v4(105.38,11.8)
  BOTTOM w0.127: JSPI1.7 105.27,12.14 v5(105.38,12.25)
PCH_SPI_SI: length 7.9
  BOTTOM w0.076: RC485.1 104.71,30.6 104.8,30.51 104.8,29.48 RC468.2 104.75,29.25 104.67,29.17 104.4,29.17 RC482.1
  BOTTOM w0.102: UCPU1.CF36 104.14,33.4 104.01,33.27 104.01,32.99
  BOTTOM w0.127: RC485.1 104.76,30.87 104.76,31.11 104.51,31.36 103.49,31.36 103.36,31.49 103.36,31.88 103.49,32.01 103.76,32.01 103.86,31.91 104.08,31.91 104.21,32.04 104.21,32.29 104.07,32.43 103.88,32.43 103.76,32.56 103.76,32.74 104.01,32.99
PCH_SPI_SI_R: length 255.9
  TOP w0.127: v2(57.23,64.07) 57.11,63.96 56.1,63.96 55.77,64.29 55.77,64.63 56.27,65.14 57.54,65.14 RC241.1 ; RZ28.1 46.3,39.75 46.42,39.86 47.18,39.86 47.32,40 47.32,40.27 47.17,40.42 41.97,40.42 41.75,40.65 41.75,41.24 41.93,41.43 46.94,41.43 47.07,41.56 47.07,41.85 46.88,42.04 43.29,42.04 43.18,42.15 43.18,43.06 43.29,43.17 47.01,43.17 47.12,43.27 47.12,43.59 47,43.7 42.81,43.7 42.61,43.5 42.61,42.15 42.5,42.04 42.14,42.04 42.01,42.17 42.01,43.2 41.86,43.35 41.45,43.35 41.12,43.69 41.12,44.12 42.18,45.18 42.18,47.11 42.04,47.25 38.61,47.25 38.47,47.39 38.47,47.59 38.61,47.73 42.04,47.73 42.18,47.87 42.18,48.11 42.04,48.25 41.03,48.25 40.89,48.39 40.89,48.67 41.03,48.81 42.05,48.81 42.18,48.94 42.18,49.16 42.02,49.32 38.71,49.32 38.56,49.47 38.56,49.68 38.71,49.83 41.96,49.83 42.12,49.98 42.12,50.2 41.98,50.33 41.73,50.33 41.58,50.48 41.58,50.75 41.43,50.9 41.22,50.9 41.07,50.75 41.07,50.48 40.93,50.33 40.71,50.33 40.57,50.48 40.57,50.75 40.42,50.9 40.21,50.9 40.06,50.75 40.06,50.48 39.91,50.33 39.7,50.33 39.55,50.48 39.55,50.75 39.4,50.9 39.19,50.9 39.04,50.75 39.04,50.48 38.89,50.33 38.64,50.33 38.49,50.49 38.49,51.1 38.7,51.32 40.25,51.32 40.38,51.44 40.38,51.62 40.5,51.74 41.63,51.74 41.79,51.58 41.79,51.18 42.72,50.25 43.13,50.25 43.47,50.58 43.47,52.02 43.62,52.17 43.85,52.17 43.97,52.04 43.97,50.62 44.1,50.49 44.55,50.49 v2(44.67,50.37) ; v2(104.8,28.2) 105.19,27.81 105.19,27.08 105.62,26.66 105.62,21.06 105.49,20.94 v1(104.63,20.94) 104.51,20.81 104.51,20.52 104.63,20.39 105.49,20.39 105.62,20.26 105.62,20.02 105.49,19.89 104.65,19.89 104.52,19.77 104.52,19.51 104.65,19.39 105.49,19.39 105.62,19.26 105.62,19 105.47,18.85 104.64,18.85 104.52,18.74 104.52,18.43 104.65,18.31 105.49,18.31 105.6,18.19 105.6,18.01 105.47,17.89 105.47,17.44 105.62,17.3 107.27,17.3 107.39,17.18 107.39,16.95 107.26,16.82 105.03,16.82 104.95,16.9 104.95,17.31 104.82,17.44 104.47,17.44 104.36,17.33 104.36,16.98 104.11,16.73 RC473.2 107.11,16.44 107.34,16.21 v2(107.34,12.29)
  IN1 w0.061: v2(46.32,39.12) 46.25,39.19 45.8,39.19 45.69,39.07 45.69,38.88 45.8,38.77 49.27,38.77 50.02,38.02 50.02,37.27 50.24,37.05 50.59,37.05 54.65,32.98 54.65,28.23 55.12,27.77 55.12,25.62 54.28,24.78 54.28,13.12 56.41,10.98 106.87,10.98 v4(107.69,11.8) 107.69,12.15 107.83,12.3 108.53,12.3 108.63,12.19 108.63,11.12 108.74,11.02 108.89,11.02 109,11.12 109,12.19 109.11,12.3 109.26,12.3 109.36,12.19 109.36,11.11 109.47,11 109.62,11 109.73,11.11 109.73,12.19 109.84,12.3 109.99,12.3 110.1,12.19 110.1,11.11 110.2,11 110.33,11 110.44,11.11 110.44,12.54 110.35,12.63 107.43,12.63 107.34,12.54 v2(107.34,12.29) ; v2(57.23,64.07) v4(57.54,63.94) ; v4(104.58,28.66) 104.58,28.86 104.66,28.94 104.95,28.94 105.04,28.85 105.04,28.41 105.12,28.33 105.29,28.33 105.35,28.38 105.35,28.68 105.42,28.76 105.59,28.76 105.65,28.7 105.65,28.4 105.83,28.23 106.18,28.23 106.23,28.17 106.23,27.82 106.31,27.74 106.5,27.74 106.58,27.82 106.58,28.19 106.62,28.23 106.83,28.23 106.89,28.17 106.89,27.63 106.76,27.49 106.2,27.49 106.12,27.42 106.12,26.99 106.06,26.93 105.88,26.93 105.8,27.01 105.8,27.84 105.57,28.08 104.92,28.08 v2(104.8,28.2) ; v2(44.67,50.37) 44.67,51.15 45.21,51.68 v4(45.45,51.68)
  IN3 w0.061: v4(104.58,28.66) 104.8,28.88 v5(104.8,28.91) ; v5(107.61,12.25) 107.69,12.17 v4(107.69,11.8) ; v4(57.54,63.94) 55.24,63.94 53.94,65.25 53.3,65.25 52.47,66.08 43.79,66.08 41.36,63.65 41.36,62.38 40.93,61.95 40.93,60.8 41.55,60.18 41.55,56.46 41.68,56.33 41.68,54.62 42.83,53.48 44.32,53.48 45.45,52.34 v4(45.45,51.68)
  BOTTOM w0.127: JSPI1.2 107.77,12.09 v5(107.61,12.25)
PCH_SPI_SI_TPM: length 8.8
  TOP w0.127: UZ6.21 45.07,36.27 44.9,36.44 44.8,36.44 44.68,36.57 44.68,37.68 44.51,37.85 44,37.85 43.89,37.97 43.89,38.14 44.02,38.27 44.66,38.27 45,37.93 45.21,37.93 45.33,38.06 45.33,38.59 45.21,38.72 v1(44.74,38.72) 44.56,38.72 44.43,38.85 44.43,39.44 44.56,39.57 44.79,39.57 44.93,39.43 44.93,39.22 45.06,39.09 45.39,39.09 45.44,39.13 RZ28.2
PCH_SPI_SO: length 4
  BOTTOM w0.076: 104.96,31.26 104.96,29.78 105.06,29.69 105.06,29.37 105.13,29.29 105.24,29.29 RC467.2
  BOTTOM w0.127: 104.96,31.26 104.7,31.53 104.53,32.12 104.4,32.52 UCPU1.CF37
PCH_SPI_SO_R: length 157.6
  TOP w0.127: v2(114.34,14.28) 114.6,14.28 114.73,14.41 114.73,15.9 114.48,16.15 114.48,16.39 114.73,16.64 114.73,16.82 114.55,17 114.35,17 114.15,16.81 113.96,16.81 113.81,16.95 113.81,17.15 114,17.34 114,17.54 113.86,17.68 113.66,17.68 113.47,17.49 113.27,17.49 113.13,17.63 113.13,17.83 113.32,18.03 113.32,18.22 113.18,18.37 112.98,18.37 112.79,18.17 112.59,18.17 112.45,18.32 112.45,18.52 112.64,18.71 112.64,18.91 112.5,19.05 112.3,19.05 112.11,18.86 111.91,18.86 111.77,19 111.77,19.2 111.96,19.39 111.96,19.59 111.81,19.73 111.61,19.73 111.42,19.54 111.22,19.54 111.08,19.68 111.08,19.88 111.27,20.07 111.27,20.27 110.28,21.27 108.33,21.27 106.88,22.72 v1(106.88,26.76) 106.88,27 107.05,27.17 107.58,27.17 107.75,27.34 107.75,28.02 107.52,28.25 107.12,28.25 106.43,27.55 106.21,27.55 106.05,27.71 106.05,27.91 106.48,28.33 106.48,29.24 106.39,29.33 105.93,29.33 105.84,29.24 105.84,28.68 v2(106.01,28.52) ; v2(42.37,37.55) 42.35,37.55 42.26,37.46 RZ27.1
  IN1 w0.061: v2(114.34,14.28) 114.17,14.28 113.95,14.49 113.8,14.49 113.67,14.36 113.67,14.23 114.29,13.61 114.29,13.48 114.19,13.39 114.06,13.39 113.47,13.98 113.34,13.98 113.25,13.89 113.25,13.76 114.18,12.82 114.18,12.69 114.09,12.6 113.96,12.6 113,13.56 112.87,13.56 112.78,13.47 112.78,13.34 113.73,12.38 113.73,12.25 113.64,12.16 113.51,12.16 112.54,13.13 112.41,13.13 112.32,13.04 112.32,12.91 112.67,12.55 112.67,12.42 112.58,12.33 112.45,12.33 112.13,12.64 112,12.64 111.92,12.56 111.92,12.42 112.32,12.02 112.32,11.7 112.67,11.35 112.67,11.25 112.58,11.16 112.47,11.16 112.06,11.56 111.98,11.56 111.86,11.45 111.86,11.33 112.27,10.93 112.27,10.85 112.15,10.74 112.05,10.74 111.68,11.11 v4(111.6,11.11) 111.44,10.94 111.44,10.72 111.13,10.42 56.16,10.42 53.71,12.86 53.71,13.29 53.62,13.38 53.48,13.38 53.39,13.47 53.39,13.6 53.48,13.7 53.62,13.7 53.71,13.79 53.71,13.92 53.62,14.01 53.48,14.01 53.39,14.1 53.39,14.23 53.48,14.33 53.62,14.33 53.71,14.42 53.71,14.55 53.62,14.64 53.48,14.64 53.39,14.73 53.39,14.86 53.48,14.96 53.62,14.96 53.71,15.05 53.71,15.18 53.62,15.27 53.48,15.27 53.39,15.36 53.39,15.49 53.48,15.59 53.62,15.59 53.71,15.68 53.71,15.81 53.62,15.9 53.48,15.9 53.39,15.99 53.39,16.12 53.48,16.22 53.62,16.22 53.71,16.31 53.71,16.44 53.62,16.53 53.48,16.53 53.39,16.62 53.39,16.75 53.48,16.85 53.62,16.85 53.71,16.94 53.71,17.13 53.66,17.19 53.33,17.19 53.25,17.27 53.25,17.43 53.31,17.49 53.6,17.49 53.69,17.58 53.69,17.71 53.6,17.8 53.35,17.8 53.25,17.91 53.25,18.04 53.32,18.12 53.6,18.12 53.69,18.21 53.69,18.34 53.59,18.44 53.34,18.44 53.25,18.54 53.25,18.67 53.34,18.76 53.61,18.76 53.69,18.84 53.69,18.97 53.6,19.06 53.37,19.06 53.28,19.16 53.28,19.29 53.37,19.38 53.6,19.38 53.69,19.47 53.69,19.6 53.6,19.69 53.37,19.69 53.28,19.79 53.28,19.92 53.37,20.01 53.6,20.01 53.69,20.1 53.69,20.23 53.6,20.32 53.37,20.32 53.28,20.41 53.28,20.54 53.37,20.63 53.58,20.63 53.67,20.72 53.67,20.86 53.58,20.95 53.37,20.95 53.28,21.04 53.28,21.19 53.35,21.27 53.6,21.27 53.69,21.36 53.69,21.49 53.6,21.59 53.34,21.59 53.22,21.7 53.22,22.02 52.75,22.49 52.75,24.09 52.84,24.19 53.59,24.19 53.68,24.28 53.68,24.45 53.59,24.54 52.84,24.54 52.75,24.63 52.75,25.38 52.84,25.47 53.59,25.47 53.68,25.57 53.68,25.7 53.59,25.79 52.84,25.79 52.75,25.88 52.75,26.01 52.84,26.1 53.27,26.1 53.36,26.2 53.36,26.33 53.27,26.42 52.84,26.42 52.75,26.51 52.75,26.7 51.87,27.59 50.86,27.59 50.54,27.91 50.54,30.64 50.64,30.74 51.06,30.74 51.15,30.83 51.15,30.96 51.06,31.05 50.64,31.05 50.54,31.14 50.54,31.27 50.64,31.37 51.05,31.37 51.14,31.46 51.14,31.59 51.05,31.68 50.64,31.68 50.54,31.77 50.54,32.2 45.95,36.79 44.85,36.79 43.95,37.69 42.51,37.69 v2(42.37,37.55) ; v2(106.01,28.52) 106.01,28.63 105.51,29.13 v4(105.42,29.13)
  IN3 w0.061: v5(112.04,11.11) v4(111.6,11.11) ; v4(105.42,29.13) 105.42,28.88 v5(105.33,28.79)
  BOTTOM w0.127: v5(112.04,11.11) 111.43,11.72 109.05,11.72 108.28,10.94 107.44,10.94 107.27,11.11 JSPI1.3
PCH_SPI_SO_TPM: length 3.6
  TOP w0.127: UZ6.24 43.57,36.2 43.27,36.5 42.32,36.5 RZ27.2 41.91,36.87 41.25,36.21 v1(40.99,36.21)
PCH_TBT_PERST#: length 218.3
  TOP w0.127: v2(125.72,27.13) 125.61,27.13 v1(124.95,26.47) 122.57,24.09 122.57,21.21 120.09,18.73 120.09,17.53 119.58,17.02 v2(119.58,16.77) ; RT284.1 RT183.2 33.58,57.08 v2(33.4,57.26)
  IN1 w0.061: v4(32.98,57.28) 33.36,57.28 33.37,57.26 v2(33.4,57.26) ; v4(119.2,16.3) 119.2,16.38 v2(119.58,16.77) ; v4(125.77,27.53) 125.77,27.24 125.72,27.2 v2(125.72,27.13)
  IN2 w0.061: v4(108.33,47.41) 108.43,47.52 109.62,47.52 110.04,47.09 111.34,47.09 112.04,46.4 114.11,46.4 119.27,41.24 121.17,41.24 126.12,36.29 126.12,35.98 126.12,35.42 126.12,34.39 126.12,34.39 126.12,29.36 125.18,28.43 125.18,27.84 125.5,27.53 v4(125.77,27.53) ; v4(31.36,63.25) 30.8,62.7 30.8,59.4 29.15,57.75 29.15,47.42 29.53,47.03 29.53,45.45 26.08,42.01 22.35,42.01 22.01,41.67 22.01,41.35 22.65,40.71 22.65,38.42 23.05,38.01 23.05,34.03 18.81,29.79 18.81,25.15 19.45,24.51 19.45,20.62 21.69,18.39 21.69,17.11 23.09,15.72 24.7,15.72 26.95,13.47 35.39,13.47 38.08,10.77 48.14,10.77 48.73,11.37 53.32,11.37 53.49,11.54 55.26,11.54 55.84,10.96 110.11,10.96 111.65,12.5 112.43,12.5 115.29,15.36 118.82,15.36 119.2,15.74 v4(119.2,16.3)
  IN3 w0.061: v4(32.98,57.28) 32.79,57.47 32.79,57.92 32.63,58.08 32.42,58.08 32.19,58.31 32.19,62.41 v4(31.36,63.25) ; v5(108.19,47.76) 108.33,47.62 v4(108.33,47.41)
  BOTTOM w0.076: v5(108.19,47.76) 108.27,47.76 108.49,47.54 109.38,47.54 UCPU1.CR14
  BOTTOM w0.127: UCPU1.CR14 110.32,47.23 110.6,47.52 RC503.2 RC395.2
PCIE_PRX_C_DTX_N1: length 1.5
  TOP w0.112: CR17.2 289.69,33.62 289.86,33.8 290.11,33.8 290.31,33.99 290.47,33.99 290.54,33.92 UR1.8
PCIE_PRX_C_DTX_N9: length 2.2
  BOTTOM w0.076: UT2.V22 26.14,47.38 26.14,46.65 26.36,46.43 26.62,46.43 26.73,46.33 26.73,46.22 CT4.2
PCIE_PRX_C_DTX_N10: length 1.9
  BOTTOM w0.076: UT2.P22 24.3,47.37 24.3,46.59 24.48,46.41 24.48,46.21 CT21.2
PCIE_PRX_C_DTX_N11: length 1.9
  BOTTOM w0.076: UT2.K22 22.45,47.36 22.45,46.77 22.24,46.56 22.24,46.2 CT8.2
PCIE_PRX_C_DTX_N12: length 2
  BOTTOM w0.076: CT12.2 19.83,46.04 20.03,46.23 20.03,46.43 20.62,47.02 20.62,47.37 UT2.F22
PCIE_PRX_C_DTX_N13: length 2.5
  TOP w0.112: RN57.2 204.78,63.45 204.25,63.45 v6(204.05,63.65)
  BOTTOM w0.112: JNGFF2.5 204.71,63.61 204.53,63.43 204.26,63.43 v6(204.05,63.65)
PCIE_PRX_C_DTX_N14: length 3.1
  TOP w0.112: v6(203.75,60.72) 203.98,60.5 204.81,60.5 RN59.2
  BOTTOM w0.112: v6(203.75,60.72) 204.01,60.47 204.36,60.47 204.51,60.61 JNGFF2.17
PCIE_PRX_C_DTX_N15: length 2.5
  TOP w0.112: RN61.2 204.79,57.49 204.25,57.49 v6(204.06,57.68)
  BOTTOM w0.112: v6(204.06,57.68) 204.29,57.44 204.44,57.44 204.61,57.61 JNGFF2.29
PCIE_PRX_C_DTX_N16: length 2.5
  TOP w0.112: RN64.2 204.77,54.26 204.33,54.26 v6(204.06,53.99)
  BOTTOM w0.112: JNGFF2.43 204.5,54.11 204.41,54.2 204.27,54.2 v6(204.06,53.99)
PCIE_PRX_C_DTX_P1: length 1.6
  TOP w0.112: CR6.2 289.88,34 290.03,34 290.22,34.19 290.41,34.19 290.54,34.32 UR1.7
PCIE_PRX_C_DTX_P9: length 2.2
  BOTTOM w0.076: CT2.2 26.89,46.24 26.89,46.39 26.69,46.6 26.43,46.6 26.31,46.71 26.31,46.82 26.41,46.92 26.48,46.92 26.54,46.98 26.54,47.29 26.49,47.34 26.41,47.34 26.34,47.28 UT2.V23
PCIE_PRX_C_DTX_P10: length 1.8
  BOTTOM w0.076: UT2.P23 24.5,47.22 24.57,47.29 24.65,47.29 24.71,47.24 24.71,46.94 24.65,46.88 24.55,46.88 24.47,46.8 24.47,46.66 24.65,46.48 24.65,46.25 CT19.2
PCIE_PRX_C_DTX_P11: length 1.9
  BOTTOM w0.076: CT6.2 22.41,46.25 22.41,46.49 22.62,46.7 22.62,46.84 22.7,46.92 22.77,46.92 22.88,47.02 22.88,47.28 22.81,47.34 22.73,47.34 22.66,47.28 UT2.K23
PCIE_PRX_C_DTX_P12: length 2
  BOTTOM w0.076: UT2.F23 20.87,47.26 20.95,47.26 21.02,47.18 21.02,46.94 20.95,46.87 20.7,46.87 20.2,46.36 20.2,46.22 CT10.2
PCIE_PRX_C_DTX_P13: length 2.5
  TOP w0.112: v6(204.05,63.01) 204.29,63.25 204.8,63.25 RN58.2
  BOTTOM w0.112: JNGFF2.7 204.73,63.11 204.62,63.23 204.27,63.23 v6(204.05,63.01)
PCIE_PRX_C_DTX_P14: length 3.1
  TOP w0.112: RN60.2 204.77,60.29 203.95,60.29 v6(203.75,60.09)
  BOTTOM w0.112: v6(203.75,60.09) 203.92,60.26 204.36,60.26 204.51,60.11 JNGFF2.19
PCIE_PRX_C_DTX_P15: length 2.5
  TOP w0.112: RN62.2 204.79,57.29 204.31,57.29 v6(204.06,57.04)
  BOTTOM w0.112: v6(204.06,57.04) 204.26,57.24 204.42,57.24 204.55,57.11 JNGFF2.31
PCIE_PRX_C_DTX_P16: length 2.5
  TOP w0.112: v6(204.06,54.63) 204.23,54.46 204.81,54.46 RN63.2
  BOTTOM w0.112: v6(204.06,54.63) 204.29,54.4 204.47,54.4 204.68,54.61 JNGFF2.41
PCIE_PRX_DTX_N1: length 223
  TOP w0.112: v2(279.75,35.79) 279.85,35.9 280.06,35.9 v7(281.06,34.9) 282.15,33.81 288.92,33.81 CR17.1
  IN1 w0.074: v2(279.75,35.79) 279.75,35.61 279.7,35.57 279.53,35.57 279.46,35.63 279.46,35.88 279.41,35.94 270.22,35.94 268.78,34.5 259.27,34.5 258.84,34.92 250.04,34.92 248.28,36.69 218.6,36.69 217.98,36.06 215.66,36.06 214.75,35.15 213.96,35.15 204.96,26.15 203.11,26.15 196.07,19.11 181.95,19.11 176.99,14.16 176.96,14.16 176.93,14.13 157.52,14.13 154.07,14.94 154.06,14.94 153.73,15.03 152.98,15.22 152.96,15.23 152.19,15.44 149.7,16.13 149.53,16.18 149.52,16.19 147.51,16.95 146.88,17.22 145.47,17.89 143.35,19.08 143.34,19.09 142,19.97 139.64,21.66 137.95,23 137.07,23.71 136.65,24.09 134.79,25.83 133.69,26.97 133.31,27.35 131.61,29.43 128.55,32.48 127.23,32.48 126.18,33.54 124.26,33.54 123.63,34.16 120.95,34.16 120.73,34.39 118.46,34.39 116.52,36.32 116.52,38.75 114.57,40.7 114.57,43.87 113.37,45.07 113.37,46.7 112.99,47.08 112.99,48.12 113.37,48.5 113.37,49.22 111.01,51.57 111.01,52.67 109.16,54.51 107.03,54.51 106.86,54.68 105.58,54.68 105.33,54.43 105.33,54.3 104.74,53.71 103.19,53.71 102.7,53.22 102.7,52.69 102.63,52.62 102.42,52.62 102.35,52.69 v4(102.35,52.96)
  IN3 w0.074: v5(102.16,52.68) 102.16,52.81 102.31,52.96 v4(102.35,52.96)
PCIE_PRX_DTX_N6: length 159.2
  IN1 w0.074: v4(205.53,37.34) 205.72,37.34 205.97,37.09 205.97,36.57 205.72,36.32 205.33,36.32 204.3,35.29 204.3,34.37 202.53,32.6 201.4,32.6 194.03,25.23 189.34,25.23 188.8,24.69 180.51,24.69 174.89,19.07 158.66,19.07 158.16,19.12 157.67,19.23 154.85,20 154.09,20.18 153.32,20.38 152.75,20.57 152.4,20.65 150.88,21.17 150,21.5 149.48,21.67 147.9,22.47 146.55,23.2 145.08,24.13 143.37,25.29 143.2,25.41 142.82,25.68 142.2,26.14 141.25,26.91 140.52,27.55 139.07,28.94 138.98,29.1 138.58,29.55 137.74,30.54 136.93,31.43 136.54,31.96 134.49,35.16 133.95,36.03 133.07,37.59 132.26,38.95 130.27,41.22 129.79,41.22 129.08,41.93 129.08,43.39 127.43,45.04 121.53,45.04 121.27,45.3 121.27,49.26 121.64,49.63 121.64,50.57 121.3,50.91 120.46,50.91 118.68,52.68 118.68,53.74 118.04,54.39 118.04,57.44 115.56,59.91 108.69,59.91 108.48,59.69 105.2,59.69 105.04,59.54 103.51,59.54 101.82,57.85 100.23,57.85 98.98,56.6 98.98,54.47 98.88,54.37 98.88,53.04 98.56,52.72 98.56,52.17 98.77,51.96 98.99,51.96 v4(99.15,51.8)
  IN3 w0.074: v4(205.53,37.34) 205.53,37.47 v5(205.32,37.68) ; v5(99.38,52.03) v4(99.15,51.8)
  BOTTOM w0.112: v5(205.32,37.68) 206.39,36.61 206.39,36.3 206.36,36.27 206.36,35.7 206.39,35.67 206.39,33.12 205.8,32.53 205.8,31.19 207.05,29.94 209.28,29.94 209.42,29.8 JNGFF3.43
PCIE_PRX_DTX_N7: length 186
  TOP w0.112: v6(248.65,29.26) 248.5,29.11 248.5,28.55 248.25,28.29 248.25,27.69 248.22,27.66 248.22,27.34 248.3,27.25 248.42,27.25 248.71,27.55 UN1.12
  IN3 w0.074: v6(248.65,29.26) 248.65,28.36 247.69,27.4 242.21,27.4 227.71,32.61 225.99,34.33 222.95,34.33 218.79,34.52 217.41,34.58 213.78,34.58 212.05,34.43 211.25,34.25 210.58,33.92 205.77,29.11 201.93,29.11 200.37,28.53 198.6,27.67 198.58,27.66 197.46,27.08 197.43,27.07 195.3,26.4 193.59,26.14 190.8,26.14 190.56,26.14 190.14,26.14 190.13,26.14 188.16,24.17 188.12,24.13 186.62,22.67 183.83,20.38 183.74,20.31 183.73,20.32 179.78,17.93 178.72,17.35 178.71,17.35 177.21,16.56 177.19,16.55 177.18,16.55 172.71,14.77 172.7,14.77 172.65,14.75 172.64,14.74 171.49,14.39 169.01,13.94 155.3,13.94 149.04,15.82 148.98,15.83 147.57,16.36 146.7,16.69 146.06,17.03 143.99,18.04 142.71,18.85 142.27,19.16 142.12,19.27 141.61,19.62 140.39,20.59 137.88,22.73 137.87,22.75 137.74,22.86 137.73,22.88 131.3,29.34 131.23,29.41 130.26,30.06 127.77,31.25 125.96,31.96 125.41,32.1 125.41,32.1 123.33,32.26 123.32,32.26 123.3,32.26 123.25,32.28 123.24,32.28 122.57,32.55 121.04,33.07 117.86,33.07 116.77,33.47 115.97,34.27 115.68,34.62 115.44,35.03 115.42,35.05 115.42,35.05 115.11,36.03 114.83,37.8 114.83,38.37 114.41,40.08 113.91,40.58 113.91,44.18 111.99,47.91 110.73,51.95 107.84,54.83 105.75,54.83 104.9,53.98 102.89,53.98 102.18,54.7 101.53,54.7 101.33,54.58 100.99,54.19 100.66,53.86 100.26,53.67 99.33,53.12 98.89,52.68 98.76,52.39 98.76,51.92 v5(98.46,51.38)
PCIE_PRX_DTX_N8: length 205.1
  TOP w0.112: v2(261.83,33.47) 261.79,33.52 261.79,33.75 261.9,33.87 262.05,33.87 262.19,33.72 262.19,33.04 262.73,32.51 263.86,32.51 265.11,31.25 v7(265.34,31.02) 267.1,29.27 267.1,29.22 267.56,28.76 267.61,28.76 267.8,28.56 267.8,27.42 267.63,27.25 267.63,27.05 267.62,27.04 RN101.1
  IN1 w0.074: v2(261.83,33.47) 262.08,33.71 v4(262.08,33.84)
  IN3 w0.074: v4(262.08,33.84) 261.92,33.69 261.92,33.33 261.56,32.96 257.59,32.96 254.53,31.13 253.7,30.3 251.47,28.38 250.73,27.95 250.47,27.87 248.32,26.74 241.7,26.74 241.62,26.76 240.65,27.19 237.15,28.48 219.01,33.81 217.26,33.81 217.18,33.81 216.04,33.99 215.44,34.09 214.18,34.09 214.14,34.09 212,33.87 211.27,33.72 210.82,33.45 205.99,28.62 202.12,28.62 198.79,26.06 198.5,25.98 197.43,25.66 190.68,25.66 190.44,25.66 190.33,25.66 188.51,23.84 188.37,23.69 188.15,23.48 186.21,21.6 186.2,21.6 185.52,21.02 185.51,21.01 184.13,19.95 183.67,19.7 181.08,17.98 179.98,17.31 179.95,17.29 179.22,16.9 178.9,16.73 178.83,16.7 178.82,16.7 176.06,15.57 174.81,14.95 174.8,14.94 174.19,14.64 172.44,13.96 169.35,13.43 169.33,13.42 155.32,13.42 155.31,13.42 153.95,13.73 152.88,14.11 151.51,14.55 151.37,14.62 147.82,15.68 146.39,16.22 144.59,17.12 143.77,17.59 143.42,17.84 142.45,18.45 142.12,18.68 141.85,18.88 141.32,19.24 140.17,20.15 140.13,20.18 140.08,20.22 139.94,20.33 139.94,20.35 137.56,22.38 137.54,22.4 137.33,22.59 135.88,24.04 135.16,24.69 131.61,28.33 130.93,28.96 129.92,29.56 128.39,30.18 128.01,30.37 126.93,31.02 126.17,31.33 125.34,31.5 124.64,31.67 123.42,31.67 121.48,32.41 120.89,32.58 117.72,32.58 116.5,33.03 115.47,34.06 115,34.8 114.64,35.92 114.35,37.76 114.35,37.92 114.21,38.89 113.99,39.77 113.26,40.5 113.26,41.63 112.56,42.33 112.56,43.99 112.12,45.64 112.12,46.18 111.89,46.62 111.8,46.74 110.9,47.63 110.78,47.77 110.48,48.31 110.46,48.41 110.46,48.97 109.99,50.22 109.11,51.1 107.57,51.1 107.37,51.3 106.06,51.3 105.83,51.07 105.83,50.18 105.2,49.55 102.32,49.55 102.16,49.4 101.21,49.4 100.77,49.84 99.8,49.84 v5(99.71,49.75)
  BOTTOM w0.112: UCPU1.BU9 v5(99.71,49.75)
PCIE_PRX_DTX_N9: length 96.4
  IN1 w0.074: v4(26.49,44.99) 26.68,45.19 26.68,45.41 26.86,45.59 27.38,45.59 27.46,45.51 28.77,45.51 28.97,45.71 28.97,55.44 28.84,55.56 28.84,58.44 31.75,61.34 32.02,61.34 33.64,62.95 33.64,63.23 39.01,68.61 39.54,68.61 39.56,68.63 45.67,68.63 47.72,67.09 48.59,66.62 49.87,66.14 50.25,66.12 51.4,66.08 51.97,65.92 53.03,65.58 54.04,65.13 54.6,64.72 55.06,64.28 55.22,64.22 55.64,64.1 56.4,63.95 56.71,63.82 56.97,63.74 57.43,63.55 57.61,63.51 58.92,63.08 59.95,62.7 60.86,62.28 61.94,62.04 64.95,62.04 65.06,62.15 67.29,62.15 67.4,62.04 71.85,62.04 72.26,62.45 73.96,62.45 74.12,62.29 74.84,62.29 75.29,62.74 80.15,62.74 84.32,58.57 85.05,58.57 86.79,56.83 94.48,56.83 97.62,53.69 97.62,53.06 v4(97.77,52.91)
  IN3 w0.074: v4(26.49,44.99) 26.54,45.04 v5(26.54,45.38) ; v5(97.54,52.68) v4(97.77,52.91)
  BOTTOM w0.112: CT4.1 v5(26.54,45.38)
PCIE_PRX_DTX_N10: length 99.3
  IN1 w0.074: v4(96.85,52.26) 97.19,52.83 97.19,53.09 97.1,53.18 97.1,53.53 94.28,56.35 86.59,56.35 84.85,58.08 84.12,58.08 79.95,62.26 75.51,62.26 75.03,61.78 73.94,61.78 73.75,61.97 72.48,61.97 72.07,61.57 67.18,61.57 67.07,61.67 65.27,61.67 65.17,61.57 61.89,61.57 61.06,61.72 60.71,61.82 60.44,61.93 60.41,61.95 59.86,62.2 59.44,62.37 58.47,62.71 58.47,62.72 57.51,63.02 56.18,63.5 55.29,63.67 54.76,63.88 54.29,64.34 53.82,64.66 53.15,65 51.93,65.43 51.51,65.53 50.84,65.62 50.26,65.63 49.75,65.66 49.14,65.86 48.27,66.22 47.55,66.62 45.63,68.05 45.45,68.13 39.21,68.13 34.11,63.03 34.11,62.76 32.22,60.86 31.95,60.86 29.32,58.24 29.32,55.76 29.45,55.64 29.45,45.42 29.06,45.03 27.61,45.03 27.18,44.61 25.73,44.61 25.51,44.82 25.51,45.12 25.02,45.61 24.66,45.61 24.43,45.37 24.43,45.12 v4(24.3,44.99)
  IN3 w0.074: v5(24.3,45.45) v4(24.3,44.99) ; v4(96.85,52.26) v5(96.61,52.03)
PCIE_PRX_DTX_N11: length 101.4
  IN1 w0.074: v4(22.07,45.12) 22.25,44.94 22.25,44.32 22.71,43.86 27.39,43.86 27.89,44.35 29.34,44.35 30.12,45.14 30.12,55.92 30,56.04 30,57.96 32.21,60.17 32.49,60.17 34.82,62.5 34.82,62.77 38.91,66.86 43.4,66.86 46.81,66.06 47.14,65.92 49.32,65.04 49.73,64.97 50.88,64.92 51.45,64.84 52.11,64.64 52.26,64.58 52.95,64.31 52.96,64.31 53.43,64.09 53.96,63.69 54.46,63.21 54.9,63.06 55.95,62.85 56.72,62.56 58.44,62 58.85,61.83 59.41,61.64 59.72,61.51 60.03,61.37 60.06,61.35 60.42,61.2 60.84,61.07 61.99,60.84 64.74,60.84 65.17,60.42 65.91,60.42 66.27,60.78 75.01,60.78 75.7,61.46 79.49,61.46 83.58,57.37 84.57,57.37 86.28,55.66 92.57,55.66 94.29,53.94 94.86,53.94 95.82,52.98 95.82,52.25 96.27,51.81 96.27,50.52 96.53,50.26 96.74,50.26 96.85,50.15 v4(96.85,50.05)
  IN3 w0.074: v5(22.07,45.45) v4(22.07,45.12) ; v4(96.85,50.05) v5(96.61,49.81)
PCIE_PRX_DTX_N12: length 101.1
  IN1 w0.074: v4(95.39,52.18) 94.8,52.18 94.51,52.46 94.51,53 92.33,55.18 85.37,55.18 83.89,56.66 83.59,56.66 79.38,60.88 75.82,60.88 75.23,60.3 66.51,60.3 66.12,59.92 64.96,59.92 64.55,60.33 61.95,60.33 61.09,60.5 60.26,60.75 59.79,60.95 58.6,61.4 57.59,61.75 56.67,62.04 55.78,62.38 54.36,62.67 54.01,62.95 54,62.96 53.77,63.16 53.76,63.17 53.27,63.57 53.12,63.7 52.62,63.92 51.58,64.29 51.35,64.37 50.87,64.42 49.47,64.49 49.09,64.6 47.23,65.34 46.76,65.54 42.92,66.38 40.46,66.38 39,64.93 38.17,64.93 36.82,63.57 36.82,62.1 34.85,60.13 34.85,57.42 33.57,56.14 32.51,56.14 32.36,56.29 31.54,56.29 30.62,55.37 30.62,44.96 29.54,43.88 28.09,43.88 27.59,43.38 21.05,43.38 20.02,44.41 20.02,44.93 v4(19.83,45.12)
  IN3 w0.074: v5(95.69,52.03) 95.54,52.18 v4(95.39,52.18) ; v5(19.83,45.45) v4(19.83,45.12)
PCIE_PRX_DTX_N13: length 175.3
  TOP w0.112: v6(206.48,63.65) 206.29,63.46 205.75,63.46 RN57.1
  IN3 w0.074: v5(94.77,52.03) 95.03,52.63 95.03,53.08 95.09,53.14 96.21,53.52 97.34,53.71 98.33,54.02 98.45,54.11 98.6,54.26 98.6,56.21 98.63,56.28 98.7,56.38 98.87,56.5 99.54,56.85 99.8,57 100.17,57.31 100.21,57.35 100.24,57.38 100.32,57.41 101.17,57.41 101.29,57.37 101.35,57.33 101.35,57.33 101.46,57.24 101.52,56.87 101.79,56.68 102.4,56.6 104.43,56.6 104.78,56.96 108.68,56.96 109.1,56.54 110.2,56.54 112.7,54.04 112.7,52.5 113.1,52.11 113.1,50.84 113.69,50.24 113.69,49.65 115.7,47.64 115.7,42.46 116.03,41.86 116.27,40.31 116.59,39.45 116.96,36.27 117.04,35.99 117.37,35.44 117.75,35.06 118.32,34.71 118.97,34.5 119.63,34.5 120.16,34.63 122.17,34.63 123.58,34.44 123.58,34.44 124.44,34.17 125.55,34.17 131.26,31.82 131.92,31.31 132.85,30.38 134.19,29.03 134.2,29.02 134.39,28.83 135.99,27.18 136.27,26.93 136.47,26.75 136.47,26.74 136.47,26.74 136.82,26.39 136.86,26.35 136.87,26.34 138.91,24.3 140.68,22.77 140.69,22.76 140.7,22.75 140.8,22.67 141.14,22.39 141.28,22.29 141.38,22.2 143.27,20.76 143.32,20.73 143.33,20.72 143.51,20.58 143.81,20.34 145,19.66 146.92,18.67 147.49,18.42 149.11,17.78 150.42,17.34 155.44,15.79 167.16,15.79 168.65,15.9 169.19,16.03 170.44,16.38 171.56,16.66 171.85,16.76 171.85,16.77 174.43,17.69 175.36,18.11 176.64,18.61 177.78,19.12 177.79,19.13 180.34,20.62 182.03,21.7 182.04,21.71 183.35,22.6 183.36,22.61 183.55,22.76 185.23,24.09 187.47,26.31 188.39,27.06 188.47,27.13 189.23,27.75 189.51,27.9 191.33,28.88 191.78,29.01 195.22,29.01 197.88,30.72 198.87,31.46 199.56,32.09 200.18,32.51 200.96,32.89 203.27,33.16 203.96,33.62 204.68,34.97 205.01,35.47 206.19,36.21 206.25,36.26 207.69,38.32 209.23,43.87 209.36,45.23 210.54,49.09 210.55,49.81 210.55,55.33 209.61,58.44 208.78,60.52 208.24,61.47 207.33,62.97 206.94,63.45 206.86,63.49 206.71,63.49 v6(206.48,63.65)
PCIE_PRX_DTX_N14: length 171.8
  TOP w0.112: v6(207.53,60.65) 207.34,60.47 205.75,60.47 RN59.1
  IN3 w0.074: v5(93.84,52.03) 93.94,52.13 94.1,52.13 94.31,52.34 94.31,53.29 94.59,53.67 96.11,54.43 97.14,55.45 97.14,56.55 97.78,57.19 99.14,57.19 99.41,57.33 99.43,57.34 99.63,57.49 99.88,57.75 100.11,57.89 101.85,57.89 102.24,58.27 104.06,58.27 104.81,57.53 108.89,57.53 109.31,57.11 110.36,57.11 113.32,54.15 113.32,52.71 113.6,52.42 113.6,51 114.17,50.44 114.17,49.85 116.18,47.84 116.18,42.87 116.73,42.31 116.73,40.83 118.43,39.13 120.31,39.13 120.7,39 122.69,37.01 124.85,37.01 127.44,34.42 127.99,34.42 128.3,34.11 128.99,34.11 130.01,33.09 130.35,33.09 130.82,32.8 131.29,32.52 131.4,32.44 131.77,32.13 132.85,31.05 132.86,31.05 139.23,24.65 141,23.13 141.44,22.77 143.55,21.15 143.58,21.13 143.61,21.11 143.62,21.1 143.79,20.97 144.04,20.82 144.16,20.73 145.11,20.16 145.11,20.15 145.18,20.12 145.19,20.12 146.25,19.58 147.02,19.16 148.6,18.52 149.89,18.04 149.89,18.03 150.71,17.78 151.1,17.63 152.4,17.23 152.4,17.23 154.54,16.57 157.12,16.27 166.94,16.27 169.48,16.68 171.82,17.26 173.31,17.79 173.98,18.07 174,18.07 174.05,18.1 174.11,18.13 174.18,18.16 174.18,18.16 176.05,18.96 176.7,19.22 177.08,19.39 178.3,20 179.47,20.67 179.46,20.66 181.35,21.84 182.74,22.77 183.62,23.49 185.95,25.66 187.4,27.09 189.48,28.5 191.21,29.36 191.87,29.53 195.1,29.53 197.8,31.35 198.51,31.92 199.28,33.71 200.75,35.18 201.4,35.18 204.49,38.27 205.24,38.27 206.1,39.14 206.1,39.85 207.95,41.69 207.95,47.06 210.03,49.14 210.03,55.39 208.4,60.09 208,60.49 207.7,60.49 v6(207.53,60.65)
PCIE_PRX_DTX_N15: length 171.5
  TOP w0.112: RN61.1 205.76,57.48 206.6,57.48 207.09,57.96 208.23,57.96 v6(208.44,58.17)
  IN3 w0.074: v5(92.92,52.68) 92.92,52.52 92.99,52.45 93.12,52.45 93.21,52.54 93.21,52.79 93.43,53.02 93.43,54.55 94.4,55.52 96.03,55.52 96.46,55.94 96.46,56.85 97.32,57.71 97.32,58.29 98.6,59.56 101.68,59.56 102.23,59.01 104.3,59.01 105.1,58.21 109.18,58.21 109.6,57.79 110.65,57.79 114.03,54.41 114.03,53.18 114.8,52.41 114.8,50.9 114.87,50.83 114.87,50.11 116.86,48.12 116.86,43.15 117.44,42.57 117.44,41.09 118.71,39.82 120.54,39.82 121.08,39.58 122.97,37.69 126.38,37.69 130.27,33.8 131.03,33.8 132.04,32.79 132.23,32.64 133.33,31.53 133.34,31.53 139.25,25.59 139.74,25.16 139.85,25.06 140.53,24.46 140.95,24.09 140.99,24.05 141.44,23.67 141.68,23.47 141.91,23.28 143.85,21.78 143.96,21.69 144.03,21.64 144.17,21.53 144.77,21.16 145.36,20.8 146.74,20.1 147.36,19.75 148.07,19.51 151.72,18.16 151.81,18.13 151.9,18.11 152.38,17.97 154.72,17.23 157.24,16.95 166.68,16.95 167.45,17.08 168.87,17.3 173.12,18.46 175.02,19.36 176.05,19.74 177.5,20.38 178.88,21.17 180.17,21.95 181.09,22.53 181.66,22.93 181.94,23.14 182,23.19 182.03,23.21 183.47,24.28 185.48,26.15 186.97,27.61 187.7,28.11 188.01,28.42 188.52,28.76 189.2,29.13 189.21,29.14 189.28,29.17 189.28,29.17 189.56,29.33 190.89,29.97 191.74,30.2 191.85,30.22 194.8,30.22 200.45,35.86 201.11,35.86 207.1,41.86 207.1,47.24 209.35,49.49 209.35,54.9 208.8,55.45 208.8,56.15 207.84,57.12 207.84,57.75 208.05,57.96 208.23,57.96 v6(208.44,58.17)
PCIE_PRX_DTX_N16: length 171.2
  TOP w0.112: v6(208.42,54.6) 208.22,54.8 207.86,54.8 207.31,54.24 205.75,54.24 RN64.1
  IN3 w0.074: v6(208.42,54.6) 208.63,54.81 208.75,54.81 208.87,54.69 208.87,49.7 206.58,47.41 206.58,42.01 200.92,36.36 200.26,36.36 194.61,30.71 191.79,30.71 190.71,30.43 190.21,30.23 187.8,28.91 186.85,28.27 183.87,25.32 182.27,23.98 181.75,23.6 180.77,22.92 178.8,21.74 177.76,21.19 176.35,20.42 174.27,19.58 173.06,19.01 170.95,18.46 167.94,17.67 166.46,17.42 158.02,17.42 154.78,17.72 152.67,18.39 151.98,18.58 150.91,18.99 148.71,19.8 147.71,20.15 145.53,21.29 145.22,21.47 145.21,21.47 145.16,21.5 144.87,21.66 141.66,24.14 141.08,24.62 141.06,24.63 140.03,25.57 139.98,25.63 139,26.52 133.68,31.86 133.67,31.87 132.55,32.99 132.5,33.03 131.24,34.29 131.17,34.29 131.17,34.29 130.46,34.29 126.57,38.18 123.16,38.18 121.36,39.98 120.64,40.3 118.93,40.3 117.94,41.29 117.94,42.76 117.33,43.37 117.33,48.43 115.66,50.11 115.66,51.65 115.9,51.89 115.9,57.32 114.3,58.92 106.59,58.92 106.35,58.68 105.3,58.68 104.46,59.53 102.43,59.53 101.91,60.05 98.41,60.05 96.84,58.48 96.84,57.91 95.98,57.05 95.98,56.19 95.75,55.96 94.26,55.96 92.9,54.61 92.9,53.54 92.41,53.05 92.41,52.45 92.25,52.29 91.92,52.29 91.81,52.4 91.81,52.61 91.88,52.68 v5(91.99,52.68)
PCIE_PRX_DTX_P1: length 223.1
  TOP w0.112: v2(279.75,36.2) 279.85,36.1 280.15,36.1 280.97,35.27 281.02,35.27 281.43,34.87 281.43,34.82 282.24,34.01 288.92,34.01 CR6.1
  IN1 w0.074: v4(102.39,52.26) 102.02,52.84 102.02,53.02 102.08,53.15 102.22,53.29 102.49,53.29 103.11,53.91 104.66,53.91 105.13,54.38 105.13,54.51 105.49,54.88 106.95,54.88 107.11,54.71 109.25,54.71 111.21,52.75 111.21,51.66 113.57,49.3 113.57,48.41 113.19,48.04 113.19,47.16 113.57,46.79 113.57,45.15 114.77,43.95 114.77,40.78 116.72,38.83 116.72,36.4 118.54,34.59 120.81,34.59 121.04,34.36 123.72,34.36 124.34,33.74 126.26,33.74 127.31,32.68 128.64,32.68 131.76,29.56 133.46,27.49 133.83,27.12 134.93,25.97 136.78,24.24 137.2,23.87 138.07,23.15 139.76,21.82 142.12,20.14 143.45,19.26 145.56,18.07 146.96,17.4 147.59,17.13 149.59,16.38 149.59,16.38 149.76,16.32 152.25,15.63 152.42,15.58 152.43,15.58 152.57,15.54 153.01,15.42 153.02,15.42 153.05,15.41 153.78,15.22 154.11,15.13 154.12,15.13 155.32,14.85 157.42,14.36 157.55,14.33 176.85,14.33 176.88,14.36 176.91,14.36 181.87,19.31 195.99,19.31 203.03,26.35 204.88,26.35 213.88,35.35 214.67,35.35 215.58,36.26 217.89,36.26 218.52,36.89 248.36,36.89 250.13,35.12 258.93,35.12 259.35,34.7 268.7,34.7 270.14,36.14 279.68,36.14 v2(279.75,36.2)
  IN3 w0.074: v5(102.16,52.03) v4(102.39,52.26)
PCIE_PRX_DTX_P6: length 159.1
  IN1 w0.074: v4(99.15,52.45) 99.15,52.28 99.03,52.16 98.86,52.16 98.76,52.25 98.76,52.63 99.08,52.95 99.08,54.29 99.18,54.38 99.18,56.52 100.31,57.65 101.9,57.65 103.59,59.34 105.13,59.34 105.28,59.49 108.56,59.49 108.77,59.71 115.48,59.71 117.83,57.35 117.83,54.3 118.48,53.66 118.48,52.6 120.37,50.71 121.22,50.71 121.44,50.49 121.44,49.72 121.07,49.35 121.07,45.22 121.45,44.84 127.35,44.84 128.88,43.31 128.88,41.85 129.71,41.02 130.18,41.02 131.14,39.92 132.1,38.83 132.9,37.49 133.77,35.93 133.78,35.92 134.45,34.86 136.38,31.84 136.77,31.3 137.59,30.41 138.37,29.47 138.37,29.47 138.82,28.98 138.91,28.81 140.44,27.35 140.45,27.35 141.13,26.76 142.07,25.99 142.7,25.52 142.82,25.43 143.13,25.21 143.25,25.13 144.97,23.96 146.44,23.02 147.8,22.29 149.4,21.49 149.93,21.31 150.81,20.98 152.35,20.46 152.7,20.38 153.26,20.19 154.04,19.99 154.8,19.81 157.62,19.04 158.13,18.92 158.65,18.87 174.98,18.87 180.59,24.49 188.89,24.49 189.43,25.03 194.11,25.03 201.48,32.4 202.62,32.4 204.5,34.29 204.5,35.2 205.42,36.12 205.8,36.12 206.17,36.49 206.17,37.17 205.87,37.47 205.87,37.62 v4(205.93,37.68)
  IN3 w0.074: v4(205.93,37.68) 205.69,37.92 v5(205.67,37.92) ; v5(99.38,52.68) v4(99.15,52.45)
  BOTTOM w0.112: JNGFF3.41 209.44,30.3 209.28,30.14 207.13,30.14 206,31.27 206,32.45 206.59,33.04 v7(206.59,35.98) 206.59,36.69 205.88,37.4 205.88,37.56 205.95,37.64 205.95,37.8 205.83,37.92 v5(205.67,37.92)
PCIE_PRX_DTX_P7: length 185.9
  TOP w0.112: v6(248.01,29.26) 248.3,28.98 248.3,28.63 248.01,28.35 v7(248.01,27.98) 248.01,27.26 248.22,27.05 UN1.13
  IN3 w0.074: v5(98.46,52.03) 98.56,52.13 98.56,52.44 98.72,52.8 99.21,53.28 100.16,53.85 100.54,54.03 100.84,54.33 101.2,54.74 101.48,54.9 102.26,54.9 102.98,54.18 104.82,54.18 105.67,55.03 107.93,55.03 110.91,52.05 112.18,47.98 114.11,44.23 114.11,40.66 114.59,40.18 115.03,38.39 115.03,37.81 115.31,36.07 115.61,35.14 115.61,35.14 115.85,34.74 116.12,34.41 116.89,33.64 117.9,33.27 121.07,33.27 122.64,32.74 123.31,32.47 123.34,32.46 125.44,32.3 126.02,32.15 127.85,31.44 130.36,30.24 131.36,29.56 137.93,22.97 137.93,22.96 138.01,22.9 138.02,22.88 140.52,20.74 141.73,19.79 142.24,19.44 142.82,19.01 144.09,18.22 146.15,17.21 146.78,16.87 149.04,16.02 149.09,16.01 155.33,14.14 168.99,14.14 171.44,14.59 172.58,14.94 172.63,14.95 177.1,16.73 177.11,16.74 178.62,17.52 178.62,17.52 179.68,18.11 183.69,20.52 183.7,20.53 186.49,22.82 187.98,24.27 188.02,24.31 190.05,26.34 190.14,26.34 190.56,26.34 190.88,26.34 193.57,26.34 195.25,26.6 196.66,27.04 197.37,27.26 198.49,27.84 200.29,28.71 201.9,29.31 205.68,29.31 210.46,34.09 211.18,34.45 212.02,34.63 213.77,34.78 217.33,34.78 217.34,34.78 218.79,34.72 218.79,34.72 222.96,34.53 226.08,34.53 227.82,32.79 242.25,27.6 242.25,27.6 247.61,27.6 248.45,28.44 248.45,28.9 248.38,28.97 248.08,28.97 248.01,29.04 v6(248.01,29.26)
PCIE_PRX_DTX_P8: length 205
  TOP w0.112: RN102.1 268.14,27.04 268.13,27.05 268.13,27.26 268,27.39 268,28.65 v7(267.47,29.18) 265.71,30.94 265.71,30.99 265.3,31.39 265.26,31.39 264.51,32.14 263.94,32.71 262.81,32.71 262.39,33.13 262.39,33.81 262.13,34.07 261.97,34.07 v2(261.83,34.21)
  IN1 w0.074: v2(261.83,34.21) 261.57,33.94 v4(261.57,33.84)
  IN3 w0.074: v4(261.57,33.84) 261.72,33.69 261.72,33.41 261.47,33.16 257.54,33.16 254.4,31.29 253.56,30.45 251.35,28.55 250.65,28.14 250.4,28.06 248.27,26.94 241.73,26.94 241.69,26.95 240.73,27.38 237.22,28.67 219.04,34.01 217.26,34.01 217.19,34.01 216.08,34.19 215.46,34.29 214.09,34.29 214.08,34.29 211.96,34.07 211.19,33.91 210.7,33.61 205.91,28.82 202.05,28.82 198.69,26.24 197.4,25.86 190.68,25.86 190.44,25.86 190.25,25.86 188.36,23.98 188.29,23.9 188.22,23.83 188.01,23.62 186.07,21.75 185.39,21.17 184.02,20.12 183.57,19.87 180.97,18.15 179.88,17.48 179.85,17.46 179.13,17.08 178.81,16.91 175.98,15.75 174.71,15.12 174.71,15.12 174.11,14.83 172.39,14.15 169.25,13.62 155.34,13.62 154.55,13.8 154.01,13.93 152.94,14.3 151.59,14.74 151.44,14.8 149.66,15.34 147.89,15.87 146.47,16.4 144.69,17.3 143.87,17.76 143.53,18.01 142.56,18.62 142.18,18.89 142.18,18.89 141.96,19.04 141.44,19.4 140.29,20.31 140.25,20.34 140.21,20.37 140.13,20.44 140.13,20.45 137.69,22.53 137.68,22.55 137.61,22.6 137.47,22.73 136.02,24.19 135.3,24.84 133.53,26.66 131.75,28.48 131.05,29.12 130.01,29.74 128.48,30.36 128.11,30.55 127.02,31.2 126.23,31.52 125.38,31.7 124.66,31.87 123.46,31.87 121.54,32.6 121,32.76 120.98,32.78 117.76,32.78 116.61,33.21 115.63,34.19 115.19,34.88 114.84,35.96 114.56,37.77 114.56,37.93 114.41,38.93 114.17,39.88 113.46,40.59 113.46,41.71 112.76,42.41 112.76,44.01 112.32,45.66 112.32,46.23 112.06,46.72 111.95,46.87 110.95,47.87 110.66,48.41 110.66,49.01 110.16,50.34 109.2,51.3 107.66,51.3 107.45,51.5 105.98,51.5 105.63,51.15 105.63,50.26 105.12,49.75 102.23,49.75 102.08,49.6 101.29,49.6 100.85,50.04 99.79,50.04 99.71,50.11 v5(99.71,50.4)
  BOTTOM w0.112: UCPU1.BU8 v5(99.71,50.4)
PCIE_PRX_DTX_P9: length 96.4
  IN1 w0.074: v4(27.05,44.99) 26.88,45.16 26.88,45.32 26.95,45.39 27.29,45.39 27.37,45.31 28.85,45.31 29.17,45.63 29.17,55.52 29.05,55.65 29.05,58.36 31.83,61.14 32.11,61.14 33.84,62.87 33.84,63.15 39.1,68.41 39.62,68.41 39.65,68.43 45.6,68.43 47.61,66.93 48.51,66.44 49.16,66.19 49.82,65.94 50.62,65.91 51.36,65.88 51.91,65.73 52.96,65.39 53.93,64.95 54.47,64.57 54.95,64.11 55.16,64.03 55.59,63.9 56.35,63.76 56.64,63.64 56.91,63.55 57.37,63.36 57.55,63.32 58.85,62.89 59.87,62.51 60.8,62.09 61.91,61.84 65.04,61.84 65.15,61.95 67.2,61.95 67.31,61.84 71.94,61.84 72.34,62.25 73.88,62.25 74.04,62.09 74.92,62.09 75.37,62.54 80.07,62.54 84.24,58.36 84.97,58.36 86.7,56.63 94.4,56.63 97.42,53.6 97.42,52.61 v4(97.77,52.26)
  IN3 w0.074: v5(27.1,45.38) 27.1,45.04 v4(27.05,44.99) ; v5(97.54,52.03) v4(97.77,52.26)
  BOTTOM w0.112: CT2.1 v5(27.1,45.38)
