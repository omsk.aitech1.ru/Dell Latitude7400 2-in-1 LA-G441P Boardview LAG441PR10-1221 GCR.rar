# Allegro board LAG441PR10-1221_GCR.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
AUD_PWR_EN_R: length 56.7
  TOP w0.127: v6(262.17,29.85) 261.85,29.53 v1(261.85,28.23) 261.85,16.21 267.11,10.95 RA126.2 280.44,10.69 282.7,10.69 283,10.98 UA7.3 ; UA8.5 265.83,41.95 265.96,42.08 RA122.2 266.63,42.06 UA8.3
  IN1 w0.061: v2(266.67,42.01) 266.13,42.01 266.09,41.97 v4(265.52,41.97)
  IN3 w0.061: v6(262.17,29.85) 262.17,30.06 263.4,31.3 264.11,31.3 265.56,32.75 265.56,36.2 265.33,36.43 265.33,41.78 v4(265.52,41.97)
AUX_EN_WOWL: length 35.3
  TOP w0.102: v2(264.61,59.24) 264.24,58.87 UE1.D3
  TOP w0.127: v2(257.99,59.71) 257.99,58.13 257.42,57.56 257.42,56.86 256.69,56.14 256.69,54.03 256.55,53.89 255.41,53.89 255.08,53.56 255.08,49.52 255.7,48.9 255.7,48.34 v1(255.97,48.08) 256.13,47.91 256.13,46.49 256.46,46.16 256.46,44.74 255.18,43.45 252.02,43.45 251.8,43.67 DN7.3 251.8,44.63 252.01,44.84 252.64,44.84 252.88,45.08 RN108.2 253.45,46.11 RN107.1 253.83,46.11 254.21,45.73 RN116.2
  IN1 w0.061: v2(257.99,59.71) 258.38,59.71 v2(259.22,60.54) 259.58,60.18 260.75,60.18 261.15,59.78 263.17,59.78 263.26,59.69 263.43,59.69 263.74,59.38 264.24,59.38 264.38,59.24 v2(264.61,59.24)
AUX_EN_WOWL_R: length 13.9
  TOP w0.127: U4.5 254.72,42.06 v2(254.74,42.08) ; v1(252.45,40.94) v2(252.45,42.25) 251.05,43.65 v2(251.05,45.54) ; RN107.2 253.88,45.15 v2(254.34,45.15)
  IN1 w0.061: v2(251.05,45.54) 251.42,45.9 253.59,45.9 v2(254.34,45.15) ; v2(252.45,42.25) 252.74,42.54 254.25,42.54 254.71,42.08 v2(254.74,42.08)
B+: length 61.2
  TOP w0.254: PR218.2 35.42,17.16 35.85,17.6 35.85,18.76 37.63,20.54 37.63,25.93
  TOP w0.508: v2(40.93,26.73) 40.37,26.17 v3(39.89,26.17) 37.86,26.17 37.63,25.93 36.9,25.93 35.22,24.25 29.89,24.25 27.38,26.76 22.67,26.76 v3(21.77,25.86) 20.95,25.04 PD202.2 ; v2(51.83,61.24) 52.99,61.24 QV4.3 ; RV75.1 130.73,27.73 v3(129.79,26.79) 128.27,25.27 v6(128.27,21.25)
  IN1 w0.508: v4(43.25,28.32) 43.25,27.57 42.66,26.98 42.25,26.98 41.99,26.73 v2(40.93,26.73) ; v2(51.83,61.24) 50.62,61.24 v4(50.21,61.65)
  IN2 w0.254: v4(131.17,44.25) 132.18,45.25 132.18,49.93 v6(131.03,51.08)
  IN3 w0.254: v4(131.17,44.25) 131.86,43.56 131.86,41.83 v5(131.72,41.69)
  BOTTOM w0.254: v5(131.72,41.69) 130.99,40.95 PR704.1
  vias: v2(34.37,72.52) v2(34.37,72.21) v2(35.09,72.52) v2(35.09,72.21) v2(39.89,35.26) v2(39.89,34.82) v4(31.98,55.54) v4(32.23,55.88) v4(32.5,55.53) v4(32.59,59.85) v4(32.61,59.44) v4(32.6,59.03) v4(32.6,58.62) v4(32.91,55.47) v4(33.27,59.39) v4(33.31,55.5) v4(34.72,72.54) v4(34.72,72.12) v4(39.49,35.98) v4(39.91,35.98) v4(40.24,35.31) v4(40.26,34.78) v4(40.33,35.99) v4(40.68,36.68) v4(40.76,36) v4(41.09,35.03) v4(41.17,35.99) v4(41.54,35.82) v4(41.63,35.03) v4(41.79,33.75) v4(42.1,32.68) v4(42.18,35.02) v4(42.23,33.76) v4(42.75,35.05) v4(42.81,33.74) v4(43.05,32.56) v4(43.14,31.38) v4(43.27,35.03) v4(43.3,33.73) v4(43.6,32.57) v4(43.91,30.8) v4(44.11,33.73) v4(44.13,34.82) v4(44.16,32.57) v4(44.16,31.39) v4(44.38,30.75) v4(44.66,34.81) v4(44.63,33.72) v4(44.66,32.56) v4(44.65,31.38) v4(44.9,30.76) v4(45.14,34.81) v4(45.15,33.75) v4(45.19,32.58) v4(45.18,31.39) v4(45.33,30.75) v4(45.62,34.78) v4(45.66,33.73) v4(45.68,32.56) v4(45.68,31.37) v4(45.88,30.85) v4(48.03,68.23) v4(48.46,68.23) v4(66.38,74.34) v4(66.36,73.93) v4(66.81,73.93) v4(66.84,74.34) v4(67.27,74.34) v4(67.27,73.93) v4(67.73,74.34) v4(67.73,73.93) v4(68.19,74.34) v4(68.19,73.93) v4(68.69,74.34) v4(68.68,73.93) v4(88.94,72.66) v4(88.94,72.15) v4(89.45,72.66) v4(89.45,72.15) v4(89.95,72.66) v4(89.95,72.15) v4(95.8,72.66) v4(95.8,72.15) v4(96.3,72.66) v4(96.3,72.15) v4(96.81,72.66) v4(96.81,72.15) v4(106.97,15.97) v4(107.38,15.97) v4(107.81,15.97) v4(120.06,23.75) v4(120.57,23.75) v4(129.27,75.12) v4(129.45,73.68) v4(129.45,73.17) v4(130.33,72.63) v4(130.73,72.9) v4(131.13,72.64) v4(201.72,34.7) v4(201.84,34.31) v4(202.13,34.67) v4(202.38,35.28) v4(202.35,34.31) v4(202.48,34.88) v4(202.7,34.54) v4(202.77,35.39) v4(202.97,34.86) v5(31.89,55.87) v5(32.23,55.29) v5(32.67,55.23) v5(32.95,59.52) v5(32.95,59.26) v5(32.94,59.01) v5(32.95,58.65) v5(33.21,59.01) v5(33.22,58.66) v5(33.13,55.22) v5(33.18,54.83) v5(33.36,54.6) v5(33.46,59.02) v5(33.49,58.64) v5(33.49,55.22) v5(33.49,54.86) v5(39.2,35.63) v5(39.5,35.62) v5(39.58,35.35) v5(39.79,35.64) v5(39.9,35.33) v5(39.91,34.79) v5(39.95,36.35) v5(40.1,35.67) v5(40.49,35.67) v5(40.54,36.38) v5(40.58,35.32) v5(40.59,34.79) v5(40.83,36.37) v5(40.99,35.65) v5(41.09,35.36) v5(41.09,34.7) v5(41.21,36.33) v5(41.23,36.6) v5(41.35,35.46) v5(41.63,35.36) v5(41.63,34.69) v5(41.79,34.08) v5(41.81,33.34) v5(41.76,32.63) v5(41.83,35.58) v5(41.91,35.3) v5(42.18,35.35) v5(42.18,34.69) v5(42.23,34.09) v5(42.25,33.35) v5(42.44,32.63) v5(42.75,35.39) v5(42.75,34.72) v5(42.81,34.07) v5(42.81,33.41) v5(43.05,32.89) v5(43.05,32.23) v5(43.12,27.95) v5(43.14,31.71) v5(43.17,30.98) v5(43.17,30.73) v5(43.27,35.36) v5(43.28,34.69) v5(43.3,34.06) v5(43.3,33.4) v5(43.43,27.94) v5(43.6,32.9) v5(43.61,32.24) v5(43.55,30.98) v5(43.55,30.73) v5(43.63,31.72) v5(43.93,31.14) v5(44.11,34.06) v5(44.11,33.4) v5(44.13,35.15) v5(44.13,34.49) v5(44.16,32.9) v5(44.17,32.23) v5(44.16,31.72) v5(44.21,30.47) v5(44.25,31.06) v5(44.52,31.08) v5(44.66,35.14) v5(44.67,34.48) v5(44.63,34.06) v5(44.64,33.39) v5(44.66,32.9) v5(44.67,32.23) v5(44.65,31.72) v5(44.65,30.52) v5(44.79,31.07) v5(45.06,31.08) v5(45.11,30.5) v5(45.14,35.14) v5(45.14,34.48) v5(45.15,34.08) v5(45.16,33.41) v5(45.19,32.92) v5(45.19,32.25) v5(45.18,31.72) v5(45.33,31.09) v5(45.62,35.11) v5(45.6,31.05) v5(45.63,34.45) v5(45.66,34.06) v5(45.67,33.39) v5(45.68,32.9) v5(45.69,32.23) v5(45.68,31.7) v5(45.64,30.62) v5(46.11,31.11) v5(65.5,75.3) v5(65.49,74.97) v5(65.81,75.18) v5(65.95,74.8) v5(66,74.49) v5(65.98,74.19) v5(65.98,73.86) v5(66.14,75.18) v5(66.28,74.82) v5(66.46,75.3) v5(66.61,74.82) v5(66.79,75.3) v5(67.12,75.3) v5(67.45,75.3) v5(67.78,75.3) v5(68.09,75.3) v5(107.19,15.63) v5(107.48,15.63) v5(107.77,15.63) v5(108.08,15.63) v5(118.45,26.07) v5(118.73,25.8) v5(119.01,26.08) v5(129.07,73.87) v5(129.07,73.42) v5(129.28,75.45) v5(130.34,72.97) v5(130.74,72.57) v5(131.12,72.98) v5(202.66,34.19) v5(203.11,35.32) v5(203.09,34.5) v5(203.23,34.27) v5(203.36,35.32) v5(203.36,35.07) v5(203.36,34.82) v5(203.36,34.49) v6(129.71,52.73) v6(129.91,75.43) v6(129.91,74.87) v6(130.2,53.16) v6(130.47,75.43) v6(130.47,74.87) v6(130.44,74.25) v6(131.02,74.25) v6(131.05,75.46) v6(131.05,74.87) v6(131.06,52.56) v6(131.52,51.51) v6(131.55,52.98) v6(293.72,50.25) v6(293.72,49.61) v6(293.72,48.98) v6(294.3,50.25) v6(294.3,49.61) v6(294.3,48.98)
B+_1.2V_DDR: length 1.5
  TOP w0.127: 48.82,29.5 49,29.67 v1(49,30.19)
  IN1 w0.061: v2(49.36,27.93) 49.22,27.93 v4(49.06,28.08) 49.22,28.24 v2(49.36,28.24)
  vias: v2(49.33,29.04) v2(49.43,29.48) v4(49.13,29.32) v5(49.42,28.27) v5(49.42,27.95) v5(49.43,29.48) v5(49.43,29.17)
B+_1.8VPRIM: length 1.6
  IN1 w0.061: v4(117.73,25.11) v2(117.3,25.11)
  IN3 w0.061: v5(116.97,24.24) 116.97,24.35 v4(117.73,25.11)
BAT1_LED#: length 180.7
  TOP w0.102: v2(270.15,59.05) 270.08,59.05 UE1.D10
  IN1 w0.061: v4(250.09,43.22) 250.19,43.12 250.94,43.12 251.58,43.77 252.7,43.77 253.13,43.35 272.68,43.35 280.92,51.59 280.92,59 278.84,61.08 276.38,61.08 275.86,60.55 273.21,60.55 272.76,60.09 271.25,60.09 270.3,59.15 270.25,59.15 v2(270.15,59.05)
  IN2 w0.061: v4(250.09,43.22) 249.91,43.22 248.84,42.15 237.38,42.15 223.66,28.43 222.27,28.43 v4(222.19,28.52)
  IN3 w0.061: v5(207.78,26.61) 210.46,26.61 213.89,30.05 216.02,30.05 216.74,29.32 221.51,29.32 222.19,28.64 v4(222.19,28.52)
  BOTTOM w0.127: R151.1 143.27,17.66 143.43,17.82 143.43,19.2 144.3,20.06 145.67,20.06 146.39,19.34 147.44,19.34 148.1,18.67 149.1,18.67 149.55,18.22 152.91,18.22 154.41,16.72 176.14,16.72 v1(184.11,24.69) 187,27.58 190.13,27.58 192.06,29.51 196.12,29.51 196.7,28.93 196.7,27.98 197.78,26.9 207.49,26.9 v5(207.78,26.61)
BAT1_LED#_Q: length 7.1
  BOTTOM w0.127: QZ21.1 150.58,16.97 150.23,16.62 v1(149.74,16.62) 145.21,16.62 QZ20.2
BAT1_LED#_R: length 8.2
  BOTTOM w0.254: QZ20.3 144.51,18.34 143.65,17.48 143.65,17.04 143.36,16.74 R151.2 142.51,16.74 142.16,17.09 v1(141.67,17.09) 141.62,17.13 138.37,17.13 138.17,16.93 JLED1.3
BAT2_LED#: length 178.1
  IN1 w0.061: v2(270.64,58.81) 270.64,59.31 271.3,59.97 272.81,59.97 273.27,60.42 275.91,60.42 276.44,60.95 278.79,60.95 280.8,58.95 280.8,51.64 272.62,43.47 253.18,43.47 252.75,43.89 251.25,43.89 v4(251.15,43.99)
  IN2 w0.061: v4(222.59,28.82) 223.87,28.82 237.33,42.28 248.65,42.28 250.36,43.99 v4(251.15,43.99)
  IN3 w0.061: v4(222.59,28.82) 222.59,28.85 221.99,29.44 216.8,29.44 216.07,30.17 213.84,30.17 210.41,26.74 208.25,26.74 v5(208.06,26.93)
  BOTTOM w0.127: R152.1 143.9,20.31 145.82,20.31 146.51,19.63 147.51,19.63 148.21,18.93 149.2,18.93 149.66,18.47 153.02,18.47 154.47,17.02 175.93,17.02 186.74,27.83 190.02,27.83 191.99,29.8 196.18,29.8 196.95,29.04 196.95,28.09 197.82,27.22 v1(201.15,27.22) 207.77,27.22 v5(208.06,26.93)
BAT2_LED#_R: length 6.3
  BOTTOM w0.254: JLED1.2 137.68,16.97 138.21,17.51 140.1,17.51 v1(140.62,18.03) 141.75,18.03 142.12,18.41 R152.2
BC_CLK_ECE1117: length 89
  TOP w0.127: UE1.D13 272.23,58.81 v2(272.23,58.8) ; v6(234.92,12.61) 235.1,12.44 235.1,12.26 234.95,12.11 UK1.33
  IN1 w0.061: v4(275.74,57.47) 275.56,57.65 275.56,57.88 275.28,58.16 274.18,58.16 273.85,58.49 272.03,58.49 271.91,58.62 271.91,58.72 271.99,58.8 v2(272.23,58.8)
  IN3 w0.061: v4(275.74,57.47) 275.55,57.28 275.55,56.38 275.83,56.1 275.83,47.73 276.5,47.06 276.5,45.56 276.96,45.11 276.96,44.4 276.11,43.55 276.11,42.31 277.35,41.06 277.35,39.06 276.35,38.05 276.35,31.32 274.79,29.76 274.79,28.24 275.82,27.21 275.82,25.09 275,24.27 275,23.41 271.24,19.65 267.87,19.65 265.21,16.99 252.39,16.99 247.06,11.67 235.65,11.67 235.12,12.19 235.12,12.42 v6(234.92,12.61)
BC_DAT_ECE1117: length 92.1
  TOP w0.102: 271.45,58.82 271.83,59.2 272.75,59.2 273.55,60
  TOP w0.127: v6(235.53,12.62) 235.35,12.44 235.35,12.26 235.45,12.15 UK1.34 ; 273.55,60 274.33,60.79 RE126.1 ; v2(271.44,58.79) UE1.D12 271.45,58.82
  IN1 w0.061: v2(271.44,58.79) 271.66,58.79 271.72,58.73 271.72,58.54 271.96,58.3 273.77,58.3 274.1,57.97 275.21,57.97 275.38,57.8 275.38,57.64 v4(275.21,57.47)
  IN3 w0.061: v4(275.21,57.47) 275.36,57.32 275.36,56.3 275.64,56.02 275.64,47.65 276.31,46.98 276.31,45.48 276.77,45.03 276.77,44.48 275.92,43.63 275.92,42.23 277.17,40.99 277.17,39.14 276.16,38.13 276.16,31.4 274.6,29.84 274.6,28.16 275.63,27.13 275.63,25.17 274.81,24.35 274.81,23.49 271.16,19.84 267.79,19.84 265.13,17.18 252.31,17.18 246.99,11.85 235.72,11.85 235.31,12.27 235.31,12.39 v6(235.53,12.62)
BC_INT#_ECE1117: length 91.4
  TOP w0.102: UE1.E2 263.43,58.01 v2(263.42,58.01)
  TOP w0.127: v2(234.44,10.89) 234.45,10.91 UK1.32 ; v6(226.52,45.99) v1(226.52,44.95)
  IN1 w0.061: v4(263.17,57.78) 263.4,58.01 v2(263.42,58.01) ; v2(234.44,10.89) 234.31,10.77 226.66,10.77 223.48,13.95 v6(223.48,15.17)
  IN2 w0.061: v4(263.17,57.78) 263.17,58.07 262.89,58.35 262.05,58.35 259.86,56.17 251.45,56.17 244.68,49.4 230.96,49.4 227.55,45.99 v6(226.52,45.99)
  BOTTOM w0.127: v6(223.48,15.17) 223.48,19.54 228.09,24.15 228.09,38.15 226.21,40.03 226.21,45.69 v6(226.52,45.99)
BCM5882_ALERT#: length 55.3
  TOP w0.127: v6(272.27,17.86) 272.27,17.31 v1(272.43,17.15) ; v2(270.22,55.31) 270.22,56.03 UE1.G10
  IN1 w0.061: v2(270.22,55.31) 270.68,55.78 272.99,55.78 273.85,56.64 275.52,56.64 276.31,55.85 v4(278.51,55.85) 278.51,55.92 v2(278.74,56.15)
  IN3 w0.061: v6(272.27,17.86) 273.69,17.86 277.34,21.51 277.34,23.63 278.9,25.18 278.9,33.47 279.98,34.55 279.98,35.17 279.39,35.76 279.39,51.88 278.95,52.31 278.95,55.4 v4(278.51,55.85)
  BOTTOM w0.127: v6(272.27,17.86) 272.06,18.08 JUSH1.13
BEEP: length 55.8
  TOP w0.127: v1(293.41,27.77) 292.99,28.19 v6(292.73,28.19) 292.63,28.09 RA2.1 ; v2(273.94,56) 273.93,56.01 271.03,56.01 270.63,55.61 UE1.H11
  IN1 w0.061: v2(273.94,56) 274.14,56.2 275.33,56.2 276.2,55.34 277.62,55.34 v4(278.53,54.43)
  IN2 w0.061: v4(278.53,54.43) 278.53,48.52 276.62,46.61 276.62,45.23 276.77,45.08 276.77,44.43 276.45,44.11 276.45,36.53 277.28,35.71 288.84,35.71 289.22,35.32 292.52,35.32 293.66,34.18 293.66,32.28 295.06,30.88 295.06,28.97 294.27,28.19 v6(292.73,28.19)
BGPO0: length 14.2
  TOP w0.127: v2(257.61,63.47) 258.5,62.58 258.94,62.58 259.12,62.4 RE531.1
  IN1 w0.061: v4(257.19,63.53) 257.55,63.53 v2(257.61,63.47) ; v2(266.6,58.82) 266.6,59.07 v4(266.34,59.33)
  IN2 w0.061: v4(257.19,63.53) 257.98,63.53 260.49,61.03 264.64,61.03 v4(266.34,59.33)
BIA_PWM: length 5
  TOP w0.254: RV84.2 RV25.1 CV19.1
  IN1 w0.254: v4(34.66,75.39) 34.66,75.46 34.47,75.66 v2(34.47,75.7)
  IN3 w0.061: v5(34.38,75.73) 34.38,75.67 v4(34.66,75.39)
  BOTTOM w0.127: JEDP1.4 33.22,76.14 33.63,75.73 v5(34.38,75.73)
BIA_PWM_EC: length 336.5
  TOP w0.102: v2(262.27,51.63) 262.61,51.63 262.63,51.61 UE1.N1
  TOP w0.127: DV3.2 36.45,70.17 36.82,70.54 37.88,70.54 38.33,70.1 38.33,69.47 39.06,68.74 v7(40.41,68.74) 40.83,68.74 41.29,68.28 v2(41.29,67.47)
  IN1 w0.061: v4(40.81,67.46) 41.27,67.46 v2(41.29,67.47) ; v2(262.27,51.63) 262.31,51.63 262.64,51.96 v4(262.8,51.96)
  IN2 w0.061: v4(262.8,51.96) 263.14,51.96 263.63,52.46 263.63,52.56 265.08,54.01 265.5,54.01 266.29,53.23 268.59,53.23 269.15,52.66 269.15,51.68 268.64,51.17 268.64,48.83 267.75,47.94 267.75,45.75 265.79,43.8 263.88,43.8 263.3,43.22 257.25,43.22 256.98,43.49 253.96,43.49 250.94,40.47 238.22,40.47 217.59,19.84 212.55,19.84 211.64,18.93 202.16,18.93 200.69,17.46 182.6,17.46 178.93,13.78 152.92,13.78 152.65,14.05 146.86,14.05 144.15,16.76 133.55,16.76 131.9,18.41 128.66,18.41 126.87,19.14 123.24,19.14 122.77,18.66 113.74,18.66 109.17,14.09 104.16,14.09 103.85,14.4 100.8,14.4 100.6,14.2 97.26,14.2 97.12,14.34 89.67,14.34 89.14,13.81 80.54,13.81 79.9,14.44 75.57,14.44 74.88,13.74 58.26,13.74 57.18,14.82 53.37,14.82 53.22,14.67 52.6,14.67 52.11,14.17 49.37,14.17 46.31,17.23 40.46,17.23 39.2,18.49 38,18.49 37.73,18.22 34.49,18.22 28.51,24.2 28.51,29.47 28.8,29.77 28.8,34.97 30.87,37.04 30.87,39.25 32.88,41.26 32.88,43.1 35.02,45.25 35.02,48.29 35.86,49.13 35.86,53.21 36.14,53.49 36.14,54.09 36.98,54.92 36.98,61.99 38.25,63.26 38.59,63.26 38.87,63.54 38.87,65.09 39.07,65.3 39.07,66.71 39.5,67.14 40.49,67.14 v4(40.81,67.46)
BL_PWR_MONITOR: length 3
  TOP w0.127: RV41.1 59.34,63.64 QV5.2
BOARD_ID: length 4.6
  TOP w0.127: UE1.J13 273.02,54.81 273.96,53.87 CE44.1 274.94,53.41 275.97,53.41 RE200.2
BREATH_LED#: length 104.5
  TOP w0.102: UE1.C11 270.64,59.86 v2(270.46,60.04)
  TOP w0.127: v1(287.91,70.04) 287.37,69.5 v6(287.37,69.49)
  IN1 w0.061: v6(287.37,69.49) 287.37,68.62 281.33,62.58 278.21,62.58 277.78,63.01 274.57,63.01 273.64,62.08 273.64,61.66 272.73,60.75 271.85,60.75 v4(271.63,60.97) 270.84,60.97 270.38,60.51 270.38,60.12 v2(270.46,60.04)
  IN2 w0.061: v4(271.63,60.97) 270.78,60.97 270.57,61.18 260.51,61.18 257.49,64.2 230.44,64.2 229.18,62.95 223.68,62.95 219.99,66.64 207.07,66.64 205.88,65.45 203.58,65.45 202.32,64.19 202.32,62.74 201.75,62.17 v6(198.65,62.17)
  BOTTOM w0.127: LED1.1 198.26,62.57 v6(198.65,62.17)
  BOTTOM w0.254: QN11.3 287.44,69.55 v6(287.37,69.49)
BST_1.0V: length 0.7
  TOP w0.127: v6(123.94,55.52) v1(123.25,55.52)
BST_1.2V_DDR: length 2.1
  TOP w0.127: v1(45.59,23.78) 46.1,23.27 47.08,23.27 v6(47.33,23.02)
  vias: v6(47.32,22.45)
BST_1.8VPRIM: length 1.8
  IN3 w0.254: v5(112.15,22.17) 112.15,22.25 v5(113.38,23.48)
BST_PRIM_CORE: length 0.7
  TOP w0.127: v6(124.99,48.2) v3(125.74,48.2)
BT_RADIO_DIS#: length 77.6
  TOP w0.127: RE131.1 260.58,59.39 260.77,59.58 v2(260.8,59.58) 260.92,59.58 261.11,59.39 262.2,59.39 262.37,59.23 263.05,59.23 UE1.C2 ; QN9.6 221.33,26.37 221.72,26.75 221.72,27.19 232.52,38 v1(232.52,41.5) 232.52,49.63 231.54,50.61 231.54,61.95 v6(233.45,63.85)
  IN1 w0.061: v2(260.8,59.58) 260.74,59.58 260.41,59.92 259.57,59.92 259.3,60.19 259.04,60.19 257.81,58.96 253.39,58.96 252.09,60.26 249.36,60.26 247.09,62.53 234.77,62.53 v6(233.45,63.85)
BT_RADIO_DIS#_R: length 5.8
  TOP w0.127: v1(221.33,28.36) QN9.1 221.33,26.95 221.09,26.7 v6(219.94,26.7) 219.74,26.9 RN77.2
  BOTTOM w0.127: v6(219.94,26.7) 219.6,27.05 JNGFF3.54
CAPS_LED: length 37.6
  TOP w0.254: v6(242.52,19.3) 243.07,19.86 v1(244.37,19.86) 248.6,19.86 249.76,18.7 249.76,13.89 RK7.2
  BOTTOM w0.254: JKB1.30 226.13,18.81 225.87,19.07 225.87,20.3 229.3,23.73 240.13,23.73 242.52,21.34 v6(242.52,19.3)
CAPS_LED#: length 3.2
  TOP w0.127: UK1.41 237.85,14.34 v1(238.53,13.66) 239.63,12.56 QK3.3
CAPS_LED#_R: length 8
  TOP w0.127: QK2.2 244.17,13.68 246.42,11.44 v1(247.2,11.44)
  TOP w0.254: QK3.1 241.74,12.88 RK6.2 CK11.1 242.86,13.57 243.36,14.06 QK2.2
CAPS_LED_R: length 4.1
  TOP w0.254: v1(249.95,12.2) 249.87,12.27 248.63,12.27 RK7.1 247.8,13.1 QK2.1
CBN: length 2.5
  TOP w0.203: UA1.24 286.14,20.97 v6(286.66,20.45) 287.41,19.7 CA152.2
CBP: length 4.2
  TOP w0.203: UA1.23 285.3,20.56 285.71,20.15 285.71,20.15 285.9,19.96 v1(286.19,19.96) 286.5,19.96 286.74,19.72 286.74,18.99 287.41,18.32 CA152.1
CD_WAKE#: length 2.2
  TOP w0.127: RR8.2 RR9.2 291.69,38.97 UR1.32
CFG0: length 48.9
  TOP w0.127: v2(67.42,70.94) 67.18,71.18 JXDP1.9 ; RC256.1 58.36,65.47 57.75,64.87 56.47,64.87 v2(56.12,64.52)
  IN1 w0.061: v4(55.77,64.69) v2(56.12,64.52) ; v2(67.42,70.94) 67.47,70.88 67.49,70.88 68.27,70.1 68.27,68.51 v4(68.24,68.48)
  IN3 w0.061: v4(68.24,68.48) 68.23,68.48 ; 68.23,68.48 68.22,68.48 68.22,68.48 68.24,68.5 68.24,69.34 68,69.58 67.63,69.58 67.55,69.5 67.18,69.5 66.95,69.73 66.95,69.84 66.75,70.04 64.82,70.04 63.6,68.82 63.6,67.42 63.4,67.22 63.07,67.22 62.72,67.57 62.37,67.57 61.97,67.97 61.53,67.97 61.23,68.26 59.84,68.26 59.66,68.45 59.35,68.45 59.21,68.3 59.21,68.02 58.87,67.68 55.78,67.68 54.95,66.85 54.95,64.76 55.14,64.57 55.66,64.57 v4(55.77,64.69) ; 68.23,68.48 68.23,66.6 71.63,63.2 74.78,63.2 75.17,62.81 75.17,61.82 74.76,61.42 74.76,60.89 v5(74.33,60.46)
  BOTTOM w0.076: v5(74.33,60.46) 74.33,60.35 73.7,59.71 73.7,57.11 73.81,56.99 73.81,54.74 73.7,54.64 73.7,54 UCPU1.T4
CFG1: length 23.3
  TOP w0.127: v2(66.94,70.88) 66.58,71.25 JXDP1.11
  IN1 w0.061: v4(67.51,68.14) 67.46,68.2 67.43,68.2 67.25,68.38 67.25,68.72 67.58,69.05 67.58,69.49 67.76,69.67 67.76,70.36 67.49,70.64 67.19,70.64 v2(66.94,70.88)
  IN3 w0.061: v5(73.06,60.46) 73.06,60.98 67.51,66.53 v4(67.51,68.14)
  BOTTOM w0.076: v5(73.06,60.46) 73,60.4 73,59.84 72.8,59.63 v1(72.8,59.59) 72.6,59.4 72.6,57.49 72.68,57.41 72.68,57.14 73.2,56.63 73.2,56.01 72.84,55.65 72.84,55.55 72.47,55.17 72.47,54.52 72.47,54.52 72.47,54.51 72.46,54.51 72.46,54.29 72.48,54.27 72.58,54.03 73.18,53.43 UCPU1.R4
CFG2: length 25.3
  TOP w0.127: v2(73.18,61.37) 72.93,61.37 v1(72.52,61.78) 72.28,62.01 72.28,63.32 71.53,64.08 71.53,66.45 70.85,67.13 70.09,67.13 69.66,67.56 69.66,69.69 68.73,70.62 67.31,70.62 67.22,70.53 66.56,70.53 65.38,71.71 JXDP1.15
  IN1 w0.061: v2(73.18,61.37) 73.5,61.37 v4(73.51,61.35)
  IN3 w0.061: v5(74.33,61.72) 74.07,61.72 73.7,61.35 v4(73.51,61.35)
  BOTTOM w0.076: UCPU1.T3 73.96,54.41 73.96,57.08 73.87,57.17 73.87,59.67 74.35,60.15 74.56,60.15 74.65,60.25 74.65,61.35 RC406.2
CFG3: length 26.9
  TOP w0.127: v2(74.27,62.67) 73.74,62.67 v1(72.69,63.72) 71.78,64.63 71.78,66.63 70.86,67.54 RC253.1 70.31,67.54 70.01,67.84 70.01,69.97 v2(68.52,71.47)
  IN1 w0.061: v2(64.78,72.26) 64.78,72.05 65.25,71.58 67.61,71.58 67.73,71.47 v2(68.52,71.47) ; v2(74.27,62.67) v4(74.67,62.67)
  IN3 w0.061: v5(72.99,61.73) 72.99,61.8 73.87,62.67 v4(74.67,62.67)
  BOTTOM w0.076: UCPU1.R3 73.39,54.18 73,54.57 73,55.11 72.99,55.13 72.99,55.58 73.35,55.94 73.35,56.78 72.94,57.19 72.94,59.26 73.17,59.49 73.17,60.03 73.38,60.23 73.38,61.35 RC407.2
CFG4: length 23.6
  TOP w0.127: v2(62.37,71.62) 62.24,71.62 61.78,72.08 JXDP1.27
  IN1 w0.061: v2(62.37,71.62) 62.4,71.59 62.4,71.39 63.93,69.86 64.2,69.86 v4(64.69,69.37)
  IN3 w0.061: v5(67.37,61.72) 67.35,61.74 67.35,64.37 64.33,67.38 64.33,69.02 v4(64.69,69.37)
  BOTTOM w0.076: UCPU1.J4 69.63,53.55 69.35,53.83 69.35,53.94 69.25,54.04 68.95,54.04 68.81,54.18 68.81,55.72 67.16,57.37 67.16,59.54
  BOTTOM w0.127: 67.16,59.54 66.7,60 66.55,60 v1(66.48,60.06) 66.48,60.19 66.78,60.48 66.78,61.08 67.35,61.66 RC408.2 67.35,61.69 v5(67.37,61.72)
CFG5: length 25
  TOP w0.127: v2(61.59,71.67) 61.58,71.67 61.58,71.7 61.46,71.7 61.18,71.98 JXDP1.29
  IN1 w0.061: v4(65.54,69.73) 65.54,70.21 65.34,70.41 64.04,70.41 63.39,71.06 63.39,71.7 63.21,71.88 62.18,71.88 61.97,71.67 v2(61.59,71.67)
  IN3 w0.061: v4(65.54,69.73) 65.49,69.68 65.49,66.77 69,63.27 69,60.71 v5(69.25,60.46)
  BOTTOM w0.076: v5(69.25,60.46) 69.28,60.43 69.28,59.14 70.27,58.15 v1(70.27,57.38) 70.27,56.36 70.83,55.8 70.93,55.8 71.2,55.53 71.2,54.27 71.51,53.96 UCPU1.M4
CFG6: length 23.5
  IN1 w0.061: v4(64.73,68.74) 64.73,68.88 62.79,70.82 62.4,71.16 61.83,71.32 60.19,71.98 v2(59.98,72.26)
  IN3 w0.061: v4(64.73,68.74) 64.73,67.18 67.98,63.94 v5(67.98,61.66)
  BOTTOM w0.076: v5(67.98,61.66) 68.3,61.35 68.3,60.25 68.21,60.15 68.03,60.15 67.91,60.03 67.91,59.81 68.13,59.58 68.13,57.17 69.57,55.74 69.66,55.74 69.87,55.52 69.87,55.52 69.87,54.57 69.63,54.33 UCPU1.J3
CFG7: length 26.7
  TOP w0.127: JXDP1.35 59.38,72.5 v2(59.38,72.51)
  IN1 w0.061: v2(59.38,72.51) 59.39,72.52 59.96,72.52 60.1,72.48 60.57,72.01 63.26,72.01 63.52,71.75 63.52,71.11 64.09,70.54 64.77,70.54 64.86,70.63 65.3,70.63 66.05,69.88 v4(66.05,69.7)
  IN3 w0.061: v5(69.25,61.66) 69.25,63.21 65.65,66.82 65.65,69.29 v4(66.05,69.7)
  BOTTOM w0.076: v5(69.25,61.66) 69.58,61.33 69.58,60.26 69.43,60.11 69.43,59.23 70.56,58.1 70.56,56.39 71.36,55.59 71.36,54.55 UCPU1.M3
CFG8: length 20.4
  TOP w0.127: JXDP1.10 66.88,69.7 67.13,69.94 67.96,69.94 v2(68.03,70.01)
  IN1 w0.061: v4(67.9,69.24) 67.93,69.27 67.93,69.91 v2(68.03,70.01)
  IN3 w0.061: v4(67.9,69.24) 67.77,69.24 67.45,68.92 67.45,68.61 67.6,68.46 67.64,68.46 67.91,68.19 67.91,67.81 67.81,67.71 67.81,66.41 73.7,60.52 v5(73.7,60.46)
  BOTTOM w0.076: UCPU1.R2 73.39,54.79 73.23,54.95 73.23,55.06 73.15,55.25 73.15,55.52 73.5,55.88 73.5,56.84 73.25,57.09 v1(73.25,58.38) 73.25,58.75 73.35,58.85 73.35,59.99 73.7,60.34 v5(73.7,60.46)
CFG9: length 17.5
  TOP w0.127: v2(66.26,69.26) 66.26,69.31 66.28,69.33 JXDP1.12
  IN1 w0.061: v2(66.26,69.26) 66.06,69.06 v4(65.96,69.06)
  IN3 w0.061: v4(65.96,69.06) 65.96,68.94 66.27,68.63 66.27,66.6 69.63,63.23 69.63,60.71 v5(69.89,60.46)
  BOTTOM w0.076: v5(69.89,60.46) 70.08,60.27 70.08,60.1 70.48,59.7 70.48,58.64 71,58.12 71,56.37 71.66,55.71 71.66,54.91 71.85,54.73 UCPU1.N2
CFG10: length 20.7
  TOP w0.127: JXDP1.16 65.08,69.11 65.31,68.89 65.95,68.89 66.36,68.48 66.61,68.48 66.81,68.28 v1(66.93,68.28) 67.19,68.28 v2(67.49,68.57)
  IN1 w0.061: v4(67.77,68.74) 67.59,68.57 v2(67.49,68.57)
  IN3 w0.061: v5(73.74,61.73) 73.72,61.72 73.32,61.72 73.09,61.49 72.9,61.49 67.93,66.46 67.93,67.65 68.03,67.76 68.03,68.24 67.77,68.51 v4(67.77,68.74)
  BOTTOM w0.076: RC414.2 74.01,61.35 74.01,60.25 73.52,59.75 73.52,57.06 73.66,56.92 73.66,55.65 UCPU1.R1
CFG11: length 19.8
  TOP w0.127: JXDP1.18 64.48,69.41 64.95,69.88 65.39,69.88 65.77,70.26 v2(66,70.26)
  IN1 w0.061: v2(66,70.26) 66.21,70.26 66.58,69.89 v4(66.58,69.7)
  IN3 w0.061: v5(69.89,61.66) 69.89,63.15 66.39,66.65 66.39,68.68 66.27,68.8 66.27,69.39 v4(66.58,69.7)
  BOTTOM w0.076: UCPU1.N1 71.94,55.38 71.82,55.5 71.82,55.78 71.18,56.41 71.18,58.32 v1(71.14,58.36) 70.69,58.82 70.69,59.73 70.23,60.19 70.23,61.32 v5(69.89,61.66)
CFG12: length 19.8
  TOP w0.127: JXDP1.28 61.48,68.74 v2(60.73,67.99)
  IN1 w0.061: v4(60.92,67.48) 60.87,67.53 60.87,67.68 60.73,67.83 v2(60.73,67.99)
  IN3 w0.061: v5(67.36,60.52) 67.36,60.78 66.46,61.68 66.46,64.04 65.39,65.1 64.5,65.1 62.52,67.08 62.17,67.08 61.8,67.45 60.95,67.45 v4(60.92,67.48)
  BOTTOM w0.076: UCPU1.J2 69.03,55.33 69.03,55.75 67.65,57.13 v1(67.65,58.84) 67.5,58.99 67.5,60.3 RC416.2
CFG13: length 21.6
  TOP w0.127: v2(60.39,68.24) 60.88,68.74 JXDP1.30
  IN1 w0.061: v4(60.44,67.66) 60.39,67.71 v2(60.39,68.24)
  IN3 w0.061: v4(60.44,67.66) 60.62,67.84 61.14,67.84 61.38,67.6 61.82,67.6 62.22,67.21 62.57,67.21 64.55,65.23 65.44,65.23 66.58,64.09 66.58,61.77 66.82,61.53 66.82,61.53 67.72,60.62 67.72,60.4 67.87,60.25 68.11,60.25 68.22,60.36 68.22,60.36 68.37,60.51 v5(68.6,60.51)
  BOTTOM w0.076: RC417.2 68.62,60.34 68.97,59.98 68.97,58.95 69.75,58.17 69.75,56.32 70.71,55.36 70.71,55.23 70.95,54.99 UCPU1.L2
CFG14: length 20.4
  TOP w0.127: JXDP1.34 59.68,69.11 60.02,68.77 v2(60.02,68.48)
  IN1 w0.061: v2(60.02,68.48) 60.02,67.88 v4(59.95,67.8)
  IN3 w0.061: v5(67.98,60.49) 67.98,60.57 66.84,61.71 66.84,64 65.49,65.35 64.6,65.35 62.62,67.33 62.27,67.33 61.87,67.72 61.43,67.72 61.16,67.99 60.13,67.99 v4(59.95,67.8)
  BOTTOM w0.076: RC418.2 67.7,60.18 67.7,59.8 67.92,59.58 67.92,57.13 69.63,55.42 UCPU1.J1
CFG15: length 22.2
  TOP w0.127: v2(59.63,68.73) 59.6,68.73 59.08,69.25 JXDP1.36
  IN1 w0.061: v4(59.53,68.13) 59.63,68.23 v2(59.63,68.73)
  IN3 w0.061: v4(59.53,68.13) 61.19,68.13 61.48,67.84 61.92,67.84 62.32,67.45 62.67,67.45 64.65,65.47 65.63,65.47 66.96,64.14 66.96,61.76 67.31,61.41 68.36,61.41 v5(68.62,61.66)
  BOTTOM w0.076: UCPU1.L1 70.95,55.42 69.95,56.42 69.95,58.21 69.13,59.04 69.13,60.05 68.96,60.22 68.96,61.32 v5(68.62,61.66)
CFG16: length 21.1
  TOP w0.127: JXDP1.6 68.08,69.06 67.9,68.89 67.19,68.89 67.12,68.82 v2(66.44,68.82)
  IN1 w0.061: v4(66.7,68.56) v2(66.44,68.82)
  IN3 w0.061: v4(66.7,68.56) 66.61,68.47 66.61,66.6 70.14,63.07 70.14,60.14 69.77,59.78 68.83,59.78 v5(68.58,60.03)
  BOTTOM w0.076: UCPU1.L3 70.95,54.17 70.66,54.45 70.66,55.06 70.55,55.17 70.55,55.28 69.49,56.34 69.49,58.18 68.71,58.97 v1(68.71,59.57) 68.71,59.9 v5(68.58,60.03)
CFG17: length 25.5
  TOP w0.127: v2(64.58,69.93) 65.2,70.55 66.18,70.55 66.45,70.27 67.33,70.27 67.42,70.37 68.44,70.37 68.68,70.12 JXDP1.4
  IN1 w0.061: v2(64.58,69.93) 64.99,69.52 64.99,69.43 65.15,69.27 v4(65.15,69.06)
  IN3 w0.061: v4(65.15,69.06) 65.15,66.94 68.88,63.21 68.88,60.4 68.74,60.27 68.4,60.27 68.2,60.07 v5(68.2,59.91)
  BOTTOM w0.076: v5(68.2,59.91) 68.44,59.67 68.44,58.84 v1(69.14,58.15) 69.14,56.43 69.67,55.9 69.71,55.9 70.03,55.58 70.03,55.58 70.03,54.51 70.02,54.51 70.02,54.12 70.31,53.84 70.69,53.84 70.95,53.58 UCPU1.L4
CFG18: length 25
  TOP w0.127: JXDP1.24 62.68,69.19 63.64,68.23 64.77,68.23 64.92,68.38 65.74,68.38 65.93,68.19 65.93,68.03 66.02,67.93 66.48,67.93 v2(66.61,68.07)
  IN1 w0.061: v2(66.61,68.07) 66.75,68.2 66.85,68.2 67.13,68.48 67.13,69.04 v4(67.27,69.18)
  IN3 w0.061: v4(67.27,69.18) 67.25,69.16 67.25,68.33 66.98,68.07 66.98,66.89 72.83,61.04 72.83,60.66 72.71,60.53 v5(72.71,60)
  BOTTOM w0.076: v5(72.71,60) 72.27,59.57 72.27,57.4 v1(72.41,57.26) 72.41,57.11 73.05,56.47 73.05,56.07 72.69,55.71 72.69,55.61 72.31,55.24 72.31,54.58 72.31,54.57 72.31,54.57 72.31,54.32 UCPU1.N3
CFG19: length 21.7
  TOP w0.127: v2(66.22,68.22) 66.22,68.26 65.85,68.63 65.18,68.63 64.93,68.89 63.42,68.89 63.28,69.02 JXDP1.22
  IN1 w0.061: v4(65.96,68.5) 66.04,68.5 66.26,68.27 66.26,68.27 v2(66.22,68.22)
  IN3 w0.061: v5(69.68,60.01) 69.51,60.18 69.51,63.19 65.95,66.74 65.95,68.49 v4(65.96,68.5)
  BOTTOM w0.076: UCPU1.N4 72.07,53.55 71.83,53.79 71.83,54.48 71.51,54.8 71.51,55.65 70.8,56.36 70.8,58.07 70.1,58.77 v1(70.1,59.57) 70.1,59.59 v5(69.68,60.01)
CFG_RCOMP: length 0.8
  IN1 w0.305: v2(77.52,53.16) 77.3,53.16 v4(77.16,53.02)
  IN3 w0.305: v5(77.21,52.68) 77.21,52.97 v4(77.16,53.02)
CHG_ACIN: length 42.7
  TOP w0.203: PR209.2 24.15,18.83 v2(24.21,18.78) 24.24,18.81 25.37,18.81 v1(25.39,18.8) 25.88,18.31 PU200.19
  IN1 w0.254: v2(23.24,8.83) 23.24,10.62 23.96,11.35 23.96,13.14 21.96,15.14 21.96,18 v4(22.2,18.25) 23.97,18.25 24.22,18.5 24.22,18.76 v2(24.21,18.78)
  IN2 w0.254: v4(22.2,18.25) 22.2,18.52 21.75,18.98 21.75,26.16 22.95,27.36 22.95,33.12 23.44,33.61 23.44,38.18 23.04,38.59 23.04,40.91 v4(22.43,41.52)
  IN3 w0.254: v5(21.65,41.52) 22.42,41.52 v4(22.43,41.52)
  BOTTOM w0.254: PR204.1 PC211.1 21.49,41.59 PR201.1
CHG_ACIN_R: length 48.4
  TOP w0.127: PQ1500.1 22.33,8.33 PR1506.1 22.33,10.55 23.56,11.78 24.87,11.78 25.02,11.93 v2(25.02,12.88) ; PQ1507.1 34.74,35.34 v1(33.23,35.34) 21.96,35.34 v2(21.69,35.07)
  IN1 w0.061: v2(21.69,35.07) 21.63,35.01 v4(21.63,34.37) ; v4(24.13,15.26) 24.13,13.77 v2(25.02,12.88)
  IN2 w0.061: v4(24.13,15.26) 23.14,15.26 21.4,17 21.4,18.27 19.16,20.5 19.16,24.36 18.4,25.13 18.4,30.51 19.96,32.07 19.96,33.01 21.32,34.37 v4(21.63,34.37)
CHG_ACOK: length 2.4
  TOP w0.203: PU200.24 25.99,16.31 24.97,15.28 PR220.2
CHG_AMON: length 1.8
  TOP w0.203: PU200.29 28.74,14.31 28.67,14.24 PR230.1
CHG_BGATE: length 20.6
  TOP w0.254: v6(45.12,22.85) 44.53,22.85 PC233.1 43.75,23.64 v1(41.93,23.64) v2(41.04,23.64)
  IN1 w0.254: v2(29.94,15.61) 33.69,15.61 36.01,17.93 36.01,19.55 40.1,23.64 v2(41.04,23.64)
  BOTTOM w0.508: v6(45.12,22.85) 44.94,23.03 PQ202.4
CHG_BST1: length 1.4
  TOP w0.127: PR205.2 v1(29.06,23.74)
CHG_BST2:
  vias: v1(32.09,17.57)
CHG_CLK: length 2.1
  TOP w0.203: PR214.2 24.79,16.81 25.09,17.11 PU200.22
CHG_CMIN: length 2.5
  TOP w0.203: PR212.2 25.14,18.26 25.5,17.9 26.44,17.9 PU200.20
CHG_COMP: length 3
  TOP w0.203: 28.34,15.02 PU200.28
  TOP w0.305: PR231.1 PC241.1 27.78,14.17 28.34,14.72 28.34,15.02
CHG_CSIN: length 3.9
  TOP w0.203: PU200.14 27.94,21.54 PC210.2
  TOP w0.254: PR203.2 PC213.1 28.07,22.75 PC210.2
CHG_CSIP: length 4.4
  TOP w0.203: PC210.1 27.54,20.79 PU200.15
  TOP w0.254: PC212.1 PR202.2 26.26,22.4 26.25,22.39 26.25,22.08 PC210.1
CHG_CSON: length 5.9
  TOP w0.203: v2(33.91,14.61) 33.91,14.6 33.85,14.54 PC239.2 32.69,14.89 32.17,14.89 v7(32.04,15.03) 31.85,15.21 31.85,15.7 31.25,16.3 31.12,16.3 31.12,16.31 PU200.1
  IN1 w0.203: v2(35.48,14.74) 34.03,14.74 v2(33.91,14.61)
CHG_CSOP: length 5.2
  TOP w0.203: PR221.2 PC238.2 33.48,15.5 33.44,15.45 PC239.1 32.81,15.22 32.35,15.22 32.18,15.4 32.18,15.84 v7(31.68,16.34) 31.39,16.63 31.17,16.63 31.09,16.71 PU200.2
CHG_DAT: length 2
  TOP w0.203: PR213.2 24.52,17.51 v1(25.39,17.51) PU200.21
CHG_DCIN: length 2
  TOP w0.102: v1(21.47,18.9) 22.07,19.5 PR208.2
CHG_LG1: length 16.1
  IN3 w1.016: 27.63,19.98 27.1,20.51 21.33,20.51 17.18,24.66 17.18,28.34
  vias: v5(16.98,29.89) v5(17,29.61) v6(30.45,19.81) v6(30.77,20.32)
CHG_LG2: length 11.4
  IN3 w1.016: 32.4,20.37 33.1,21.07 33.1,21.77 36.54,25.2 36.54,28.95 36.85,29.27 36.85,29.91 36.84,29.91
  vias: v5(36.72,30.51) v5(36.98,30.51) v6(31.85,19.68) v6(32.42,19.68)
CHG_LX1: length 13.2
  TOP w0.127: PR215.1 v3(24.73,33.83)
  IN1 w1.016: 30.43,22.11 30.43,23.78 29.47,24.75 29.47,27.15 26.29,30.34 24.75,30.34
  vias: v6(24.57,31.03) v6(25.13,31.03) v6(30.14,20.63) v6(30.64,20.89)
CHG_LX2: length 17.1
  TOP w0.127: PR216.1 v1(34.3,34.09)
  IN1 w1.016: 34.83,32.46 34.48,32.11 34.48,28.24 36.29,26.42 36.29,24.87 33.64,22.22 33.64,19.04
  vias: v6(32.3,19.11) v6(32.8,18.84) v6(35.66,32.77) v6(35.67,32.14)
CHG_OTGPG: length 4.8
  TOP w0.127: PR228.2 24.79,13.91 24.45,13.57 v1(23.96,13.57)
  TOP w0.203: PR228.2 25.27,14.2 25.81,14.74 27.09,14.74 27.54,15.19 PU200.26
CHG_PROCHOT#: length 58
  TOP w0.203: v1(25.38,16.23) 25.86,16.71 PU200.23
  TOP w0.254: v2(38.9,63.38) 38.85,63.33 PR114.2 ; v1(25.38,16.23) 25.2,16.05 v2(24.46,16.05)
  IN1 w0.254: v2(24.46,16.05) 24.9,16.05 25.46,16.6 v4(25.46,19.51) ; v2(38.9,63.38) 38.71,63.38 v4(38.42,63.67)
  IN2 w0.254: v4(38.42,63.67) 38.42,63.66 38.33,63.66 36.75,62.08 36.75,55.03 35.9,54.18 35.9,53.59 35.64,53.32 35.64,49.22 34.8,48.38 34.8,45.34 32.65,43.19 32.65,41.35 30.64,39.34 30.64,37.14 28.57,35.07 28.57,29.86 28.28,29.57 28.28,25.25 25.37,22.33 25.13,22.33 24.99,22.19 24.99,21.93 24.89,21.83 24.89,20.08 v4(25.46,19.51)
CHG_PROG: length 3.2
  TOP w0.203: PU200.27 27.94,15.01 27.26,14.33 26.19,14.33 26.01,14.14 PR226.1
CHG_PSYS: length 1.6
  TOP w0.203: PU200.30 29.14,14.45 PR229.2
CHG_UG1: length 20.8
  IN1 w1.016: 28.31,21.85 26.03,21.85 24.91,22.97 21.88,22.97 20.77,24.07 18.12,24.07 16.08,26.11 16.08,32.93
  vias: v4(17.03,34.26) v5(16.85,34.62) v5(17.18,34.62) v6(29.25,20.7) v6(29.69,21.14)
CHG_UG2: length 22.6
  IN1 w1.016: 33.15,17.79 33.15,17.78 34.13,17.78 34.84,18.5 34.84,20.51 37.98,23.65 37.98,26.36 35.96,28.38 35.96,30.99 36.68,31.71 36.68,33.18 36.15,33.71 36.15,36.25 v4(36.28,36.38)
  vias: v5(36.89,36.32) v5(36.89,36.06) v6(31.79,17.97) v6(32.23,18.41)
CHG_VBAT1: length 4.7
  TOP w0.127: v1(32.12,12.76) PR236.1
  TOP w0.203: PC245.1 30.7,14.09 29.54,15.25 PU200.31
  TOP w0.254: PR236.1 31.99,13.82 PC245.1
CHG_VDDP: length 4.4
  TOP w0.203: 31.22,19.58 31.22,19.32 31,19.11 PU200.8
  TOP w0.254: 31.22,19.58 31.22,19.83 31.52,20.14 v7(32.03,20.14) 32.35,20.14 32.85,20.64 PC228.1 34.07,20.64 PR207.1
CHG_VIN_20V: length 2.9
  TOP w0.127: v2(21.7,38.26) 21.88,38.08 PT200.1
  IN1 w0.061: v2(21.7,38.26) 22.26,38.26 v4(22.62,37.9)
  IN3 w0.061: v5(22.96,38.64) 22.96,38.25 v4(22.62,37.9)
CHG_VSYS: length 3.3
  TOP w0.203: 32.99,17.19 32.91,17.11 PU200.3
  TOP w0.254: PR218.1 33.06,17.16 PC235.1 32.99,17.19
CHR_USB20_N3: length 6.1
  TOP w0.112: UI5.11 19.4,11.11 19.25,10.96 19.25,10.56 v7(18.43,9.73) 17.81,9.11 17.81,8.64 v6(17.98,8.47)
  BOTTOM w0.112: LI4.1 16.55,9.49 17.49,9.49 17.86,9.11 17.86,8.59 v6(17.98,8.47)
CHR_USB20_N3_R: length 5.2
  BOTTOM w0.112: JUSB2.2 12.59,10.74 13.28,10.05 13.28,9.87 13.39,9.75 13.73,9.75 14.16,9.33 14.77,9.33 DI13.1 15.29,9.34 15.81,9.34 LI4.2
CHR_USB20_N4: length 11.3
  TOP w0.112: LI1.1 297.66,57.4 296.78,57.4 296.43,57.05 295.68,57.05 295.65,57.08 295.07,57.08 295.04,57.05 294.3,57.05 293.17,58.18 v7(293.17,58.59) 293.17,58.97 290.24,61.9 289.89,61.9 289.73,62.05 UI4.11
CHR_USB20_N4_R: length 12.4
  TOP w0.112: LI1.2 298.55,57.4 299.2,57.4 DI7.1 299.68,57.4 299.96,57.4 v6(300.2,57.63)
  IN3 w0.074: v6(300.2,57.63) 300.18,57.63 299.96,57.41 299.76,57.41 299.5,57.15 299.5,56.91 299.27,56.69 299.27,56.13 301.4,54 301.4,52.01 302.03,51.37 302.5,51.37 303.26,50.61 JUSB1.2
CHR_USB20_P3: length 6.1
  TOP w0.112: UI5.10 18.9,11.11 19.05,10.96 19.05,10.64 18.51,10.1 18.47,10.1 18.06,9.69 18.06,9.65 17.61,9.2 17.61,8.69 v6(17.39,8.47)
  BOTTOM w0.112: LI4.4 16.85,8.98 16.93,9.06 16.93,9.17 17.04,9.28 17.4,9.28 17.66,9.03 17.66,8.74 v6(17.39,8.47)
CHR_USB20_P3_R: length 5.2
  BOTTOM w0.112: LI4.3 15.78,9.14 15.32,9.14 DI14.1 14.77,9.12 14.07,9.12 13.65,9.55 13.39,9.55 13.23,9.39 13.23,9.08 12.89,8.74 JUSB2.3
CHR_USB20_P4: length 11.2
  TOP w0.112: LI1.4 297.66,57.19 296.86,57.19 296.52,56.85 v7(295.36,56.85) 294.21,56.85 292.93,58.13 292.93,58.91 290.15,61.69 289.88,61.69 289.74,61.55 UI4.10
CHR_USB20_P4_R: length 12.3
  TOP w0.112: LI1.3 298.55,57.19 299.2,57.19 DI8.1 299.68,57.19 300.01,57.19 v6(300.2,57.01)
  IN3 w0.074: v6(300.2,57.01) 300,57.21 299.84,57.21 299.7,57.07 299.7,56.83 299.48,56.6 299.48,56.21 301.6,54.09 301.6,52.09 302.12,51.57 302.46,51.57 302.55,51.66 302.55,52.53 302.63,52.61 JUSB1.3
CLK_CNV_PRX_DTX_N: length 128.9
  IN3 w0.074: v5(108.83,36.46) 109.3,35.99 109.69,35.99 110.01,35.67 110.01,33.5 113.03,30.48 115.8,30.48 116.79,29.49 122.85,29.49 123.72,28.62 125.36,28.62 125.64,28.9 126.26,28.9 126.82,28.33 126.82,28.24 127.71,27.35 127.71,27.07 128.2,26.58 129.22,26.58 129.24,26.6 130.03,26.6 133.72,22.91 133.72,21.3 135.19,19.83 137.01,19.83 137.58,19.26 137.58,17.78 139.47,15.89 142.17,15.89 144.1,14.79 145.46,14.17 147.71,13.36 148.26,13.25 148.27,13.25 149.38,12.98 151.93,12.17 151.94,12.16 152.4,11.98 152.54,11.93 152.6,11.9 155.43,11.24 170.01,11.24 172.7,11.6 173.49,11.82 176.09,12.8 181.93,15.72 181.93,15.72 182.17,15.84 186.81,18.9 189.46,21.73 190.77,23.04 191.26,23.56 200.16,23.56 203.08,26.49 207.02,26.49 210.97,30.44 211.45,30.44 211.82,30.8 211.82,31.19 211.7,31.31 v5(211.7,31.44)
  BOTTOM w0.112: JNGFF3.21 211.1,35.3 211.25,35.15 211.41,35.15 211.68,34.88 211.68,32.37 211.44,32.12 211.44,31.51 211.52,31.44 v5(211.7,31.44)
CLK_CNV_PRX_DTX_P: length 128.9
  IN3 w0.074: v5(211.34,31.06) 211.34,31.13 211.42,31.21 211.51,31.21 211.62,31.1 211.62,30.88 211.37,30.64 210.89,30.64 206.94,26.69 203,26.69 200.08,23.77 191.17,23.77 191.16,23.75 190.62,23.18 189.31,21.87 186.68,19.05 182.07,16.01 181.84,15.9 181.84,15.9 176.01,12.98 173.43,12.01 172.66,11.79 169.99,11.44 155.45,11.44 152.65,12.1 152.61,12.11 152.47,12.17 152.01,12.35 152,12.36 149.51,13.15 149.51,13.16 148.31,13.45 148.3,13.45 147.77,13.56 146.65,13.96 145.54,14.35 144.19,14.97 142.22,16.09 139.55,16.09 137.78,17.86 137.78,19.35 137.1,20.03 135.27,20.03 133.92,21.38 133.92,22.99 130.11,26.8 129.15,26.8 129.13,26.78 128.29,26.78 127.91,27.15 127.91,27.44 127.02,28.33 127.02,28.42 126.34,29.1 125.56,29.1 125.28,28.82 123.8,28.82 122.93,29.69 116.87,29.69 115.89,30.68 113.12,30.68 110.21,33.59 110.21,35.75 109.77,36.19 109.38,36.19 109.13,36.44 109.13,36.57 109.21,36.65 109.46,36.65 109.56,36.54 v5(109.56,36.46)
  BOTTOM w0.112: JNGFF3.23 211.1,34.8 211.25,34.95 211.33,34.95 211.48,34.8 211.48,32.45 211.24,32.21 211.24,31.43 211.42,31.25 211.42,31.13 v5(211.34,31.06)
CLK_CNV_PTX_DRX_N: length 120.6
  IN3 w0.074: v5(108.96,34.67) 109.06,34.56 109.06,32.68 110.73,31.01 110.73,30.42 112.1,29.05 115.11,29.05 116.95,27.21 121.23,27.21 121.38,27.35 124.05,27.35 127.2,24.2 128.83,24.2 129.41,23.61 129.92,23.61 130.93,22.6 130.93,20.17 131.77,19.33 132.44,19.33 133.56,18.2 133.92,18.2 135.35,16.77 136.77,16.77 139.1,14.45 141.75,14.45 144.31,13.13 146.08,12.44 147.17,12.13 148.3,11.93 148.3,11.93 148.46,11.9 148.46,11.9 148.53,11.89 148.54,11.89 148.59,11.88 148.65,11.86 148.72,11.84 149.89,11.47 150.44,11.3 150.47,11.29 150.47,11.29 152.42,10.66 152.57,10.62 155.41,9.98 171.3,9.98 173.49,10.25 177.31,11.71 182.5,14.53 185.25,16.24 187.74,17.79 187.74,17.79 189.9,20.26 192.7,22.2 192.82,22.32 198.9,22.32 200.91,20.31 206.46,20.31 207.14,20.99 207.14,22.09 207.71,22.66 207.71,22.78 207.61,22.88 207.5,22.88 v5(207.43,22.8)
  BOTTOM w0.112: JNGFF3.71 209.33,22.8 209.21,22.68 208.62,22.68 208.39,22.9 207.93,22.9 207.68,22.65 207.58,22.65 v5(207.43,22.8)
CLK_CNV_PTX_DRX_P: length 120.6
  IN3 w0.074: v5(207.83,22.37) 207.8,22.4 207.74,22.4 207.34,22 207.34,20.91 206.54,20.11 200.82,20.11 198.82,22.12 192.9,22.12 192.83,22.05 190.03,20.11 187.88,17.65 187.87,17.64 187.85,17.62 182.6,14.36 177.39,11.53 173.54,10.05 171.31,9.78 155.39,9.78 152.53,10.43 152.52,10.43 152.36,10.47 150.41,11.1 150.38,11.11 150.37,11.11 149.83,11.28 148.67,11.65 148.6,11.67 148.56,11.68 148.56,11.67 148.26,11.74 147.13,11.93 146.02,12.25 144.23,12.95 141.7,14.25 139.02,14.25 136.69,16.57 135.27,16.57 133.83,18 133.48,18 132.36,19.13 131.69,19.13 130.73,20.08 130.73,22.52 129.84,23.41 129.33,23.41 128.74,24 127.12,24 123.97,27.15 121.46,27.15 121.32,27.01 116.87,27.01 115.03,28.85 112.02,28.85 110.53,30.34 110.53,30.92 108.86,32.59 108.86,34.36 108.75,34.48 108.5,34.48 v5(108.31,34.67)
  BOTTOM w0.112: v5(207.83,22.37) 207.81,22.39 207.81,22.5 208.01,22.7 208.31,22.7 208.53,22.48 209.2,22.48 209.38,22.3 JNGFF3.73
CLK_ITPXDP_N: length 38.1
  IN1 w0.074: v2(57.32,67.23) 57.32,67 v4(57.23,66.91)
  IN3 w0.074: v4(57.23,66.91) 57.32,66.81 57.32,66.4 57.6,66.12 59.74,66.12 60.14,66.52 61.62,66.52 61.9,66.24 62.26,66.24 64.2,64.3 65.08,64.3 65.63,63.74 65.63,61.42 66.41,60.63 66.41,60.23 67.64,59.01 70.09,59.01 70.33,59.24 77.34,59.24 77.99,58.59 80.23,58.59 82.7,56.11 82.7,55.92 83.05,55.58 84.06,55.58 84.62,56.15 86.65,56.15 v5(86.74,56.06)
  BOTTOM w0.112: v5(86.74,56.06) 86.81,55.98 86.81,55.47 UCPU1.AU1
CLK_ITPXDP_N_R: length 1.6
  TOP w0.127: RC61.1 57.16,68.03 57.16,68.93 57.28,69.05 JXDP1.42
CLK_ITPXDP_P: length 39.5
  TOP w0.112: v2(58.08,66.91) 58.06,66.91 57.89,67.08 RC60.2
  IN1 w0.074: v4(57.77,66.77) 57.92,66.91 v2(58.08,66.91)
  IN3 w0.074: v4(57.77,66.77) 57.61,66.8 57.52,66.74 57.52,66.48 57.68,66.32 59.65,66.32 60.06,66.72 61.71,66.72 61.99,66.44 62.34,66.44 64.29,64.5 65.16,64.5 65.83,63.83 65.83,61.5 66.61,60.72 66.61,60.31 67.72,59.21 70.01,59.21 70.24,59.44 77.42,59.44 78.07,58.79 80.31,58.79 82.9,56.2 82.9,56.01 83.13,55.78 83.97,55.78 84.54,56.35 86.66,56.35 v5(86.73,56.42)
  BOTTOM w0.112: UCPU1.AU2 87.02,55.03 87.02,56.24 86.83,56.42 v5(86.73,56.42)
CLK_ITPXDP_P_R: length 2
  TOP w0.127: RC60.1 57.89,67.91 57.42,68.37 57.42,68.83 57.55,68.95 57.75,68.95 57.88,69.09 JXDP1.40
CLK_PCIE_N0: length 91.5
  IN1 w0.074: v4(25.77,49.26) 25.93,49.42 25.93,49.62 26.45,50.14 26.45,54.43 25.89,54.99 25.89,56 26.36,56.46 26.36,59.98 28.05,61.68 28.05,61.85 28.72,62.51 29.31,62.51 29.85,63.05 29.85,63.39 31.89,65.43 31.89,66.35 35.67,70.12 36.24,70.12 37.79,71.67 39.99,71.67 40.38,72.06 40.93,72.06 41.14,71.85 42,71.85 42.67,71.17 45.01,71.17 45.97,72.14 47.36,72.14 47.45,72.05 48.9,72.05 50.12,70.83 51.66,70.83 52.42,70.37 53.98,69.51 55.54,68.65 56.48,68.17 58.06,67.54 58.42,67.26 58.63,66.87 58.88,66.66 59.75,66.31 60.29,65.99 60.86,65.47 61.28,65.11 61.7,64.75 62.3,64.55 63.89,64.55 63.99,64.65 68.35,64.65 68.46,64.55 70.69,64.55 71.49,65.35 81.21,65.35 85.49,61.07 86.18,61.07 87.4,59.85 87.77,59.85 v4(87.84,59.92)
  IN3 w0.074: v5(88.18,59.84) 87.92,59.84 v4(87.84,59.92) ; v5(25.53,49.02) v4(25.77,49.26)
  BOTTOM w0.112: v5(88.18,59.84) 88.09,59.75 87.77,59.75 87.53,59.51 87.53,59.07 88.44,58.15 88.44,57.83 88.41,57.8 88.41,57.26 88.44,57.23 88.44,55.13 UCPU1.AW2
CLK_PCIE_N1: length 166
  IN1 w0.074: v4(107.07,65.13) 107.23,64.97 107.23,64.38 107.67,63.93 111.54,63.93 112.98,62.49 114.22,62.49 118.91,57.8 118.91,54.9 119.56,54.25 119.56,53.01 120.71,51.86 121.86,51.86 123.26,50.47 126.95,50.47 127.65,49.77 127.65,48.94 129.43,47.16 129.75,47.16 130.82,46.09 130.82,45.41 130.2,44.79 130.2,43.83 130.77,43.26 131.1,43.26 131.39,42.96 131.84,42.07 132.98,39.91 134.11,37.74 135.55,35.27 135.55,35.27 136.47,33.74 137.11,32.82 137.73,31.97 137.73,31.97 137.79,31.9 137.85,31.81 137.87,31.78 138.68,30.75 138.85,30.55 139.51,29.81 139.87,29.43 140.16,29.15 141.21,28.17 142.24,27.27 142.24,27.27 142.42,27.11 142.89,26.75 143.44,26.34 143.93,26 145.95,24.63 147.18,23.87 147.75,23.56 148.74,23.05 149.4,22.77 149.58,22.69 150.01,22.5 150.02,22.5 150.27,22.39 150.41,22.33 150.45,22.32 150.47,22.31 150.76,22.18 150.76,22.17 151.12,22.05 151.14,22.05 151.79,21.87 153.34,21.33 154.64,20.98 154.76,20.96 154.88,20.93 154.89,20.93 155.15,20.87 158.58,19.94 158.7,19.93 174.44,19.93 180.06,25.55 188.26,25.55 191.29,28.58 196.04,28.58 198.97,31.52 198.97,33.04 202.43,36.5 203.75,36.5 203.82,36.43 203.87,36.38 v4(203.87,36.16)
  IN3 w0.074: v4(107.07,65.13) 106.92,65.28 106.92,65.4 107,65.48 107.22,65.48 107.27,65.53 107.27,65.63 107.17,65.72 103.03,65.72 100.99,63.69 94.49,63.69 91.35,60.55 91.35,57.24 90.21,56.1 90.21,55.15 90.37,54.98 90.58,54.98 90.65,55.05 90.65,55.29 90.57,55.38 v5(90.47,55.38) ; v4(203.87,36.16) 204.17,36.16 204.27,36.06 204.45,36.06 v5(204.52,35.99)
  BOTTOM w0.112: v5(204.52,35.99) 204.63,35.99 205.6,35.02 205.6,33.32 204.95,32.67 204.95,31.74 204.92,31.71 204.92,31.14 204.95,31.11 204.95,29.64 206.18,28.41 206.88,28.41 RN43.1
CLK_PCIE_N1_R: length 2.7
  BOTTOM w0.112: JNGFF3.49 209.41,28.3 209.27,28.44 207.89,28.44 RN43.2
CLK_PCIE_N2: length 164.1
  TOP w0.112: RN21.1 205.77,51.32 206.31,51.32 v6(206.43,51.2)
  IN3 w0.074: v5(91.04,54.4) 90.89,54.26 90.89,54.15 91,54.04 91.12,54.04 91.3,54.22 91.3,54.54 91.92,55.16 91.92,55.93 92.5,56.51 92.5,60.04 94.96,62.49 101.43,62.49 103.41,64.47 105.52,64.47 106.16,63.83 112.73,63.83 118.3,58.26 118.3,53.22 119.84,51.68 119.84,49.97 120.18,49.62 120.18,49.39 120.72,48.85 120.72,43.9 121.2,43.42 122.27,43.42 123.62,42.07 128.09,42.07 132,38.16 134.93,34.71 134.93,34.7 135.52,33.96 135.84,33.52 136.57,32.46 137.07,31.88 138.92,29.97 139.68,29.15 140.84,28.04 142.09,26.92 143.5,25.71 144.26,25.15 147.07,23.21 148.71,22.38 148.73,22.38 150.36,21.77 150.87,21.56 154.48,20.36 158.38,19.72 164.6,19.72 164.99,19.75 166.74,19.99 166.75,19.99 167.41,20.08 168.07,20.19 171.47,21.08 173.01,21.67 174.54,22.27 175.35,22.65 175.72,22.85 175.73,22.85 175.77,22.85 176.2,23.07 176.21,23.07 177.12,23.57 177.13,23.57 177.15,23.58 177.2,23.61 177.26,23.65 177.26,23.66 177.49,23.79 178.4,24.35 180.34,25.62 180.35,25.61 180.4,25.65 180.44,25.68 180.89,26.03 180.89,26.03 181.59,26.57 181.73,26.71 182.85,27.73 182.86,27.75 183.36,28.2 183.36,28.2 184.32,29.12 185.61,30.42 186.92,31.17 187.54,31.56 187.89,31.81 188.13,32.03 189.46,32.48 190.22,32.78 190.37,32.84 191.27,32.96 191.29,32.97 191.64,33.02 193.68,33.02 199.38,38.72 199.97,38.72 203.82,42.57 203.82,48.54 205.91,50.63 205.91,51.17 206.15,51.41 206.36,51.41 206.43,51.34 v6(206.43,51.2)
CLK_PCIE_N2_R: length 3.7
  IN1 w0.074: v2(204.95,51.14) 205.03,51.22 205.34,51.22 205.52,51.4 205.52,51.88 205.27,52.13 204.73,52.13 204.48,51.87 204.48,51.73 204.35,51.6 204.2,51.6 v4(204.09,51.71)
  IN3 w0.074: v5(204.66,51.62) 204.18,51.62 v4(204.09,51.71)
CLK_PCIE_N4: length 249
  TOP w0.112: v2(280.54,38.93) 280.64,39.03 280.76,39.03 280.92,38.86 280.92,36.33 282.41,34.84 282.74,34.84 282.77,34.81 283.38,34.81 283.41,34.84 287.9,34.84 288.1,35.04 288.75,35.04 RR18.1
  IN1 w0.074: v4(110.86,65.25) 110.93,65.32 110.93,65.44 110.84,65.53 110.67,65.53 110.6,65.6 110.6,65.72 110.7,65.83 112.59,65.83 120.15,58.27 120.15,56.86 120.76,56.25 120.76,53.45 121.1,53.11 127.13,53.11 128.36,51.89 128.36,51.21 129.4,50.17 129.4,48.9 129.98,48.32 130.27,48.32 132.19,46.41 135.32,38.14 136.1,36.64 136.55,35.86 136.82,35.41 138.76,32.6 139.57,31.57 140.83,30.2 141.46,29.64 143.31,27.9 143.71,27.6 144.33,27.15 146.69,25.54 147.76,24.88 149.08,24.2 149.52,24 150.54,23.55 152.01,23.03 153.7,22.44 159.08,21.1 173.98,21.1 179.58,26.7 187.25,26.7 190.59,30.04 195.86,30.04 197.05,31.24 197.05,32.8 205.99,41.73 210.7,41.73 211.1,42.12 212.33,42.12 213.37,43.16 216.55,43.16 216.84,42.86 217.94,42.86 218.39,43.31 248.16,43.31 251.41,40.06 263.93,40.06 265.32,38.67 267.14,38.67 267.53,39.06 280.42,39.06 v2(280.54,38.93)
  IN3 w0.074: v5(89.16,55.38) 89.16,55.33 89.26,55.22 89.35,55.22 89.44,55.32 89.44,55.51 89.35,55.6 89.35,56.39 90.57,57.6 90.57,60.93 94.11,64.48 100.68,64.48 102.7,66.5 107.63,66.5 108.29,65.84 110.48,65.84 110.7,65.62 110.7,65.4 v4(110.86,65.25)
CLK_PCIE_N4_R: length 1.7
  TOP w0.112: UR1.6 290.57,34.72 290.47,34.83 290.23,34.83 290,35.05 289.77,35.05 RR18.2
CLK_PCIE_N5: length 234.1
  TOP w0.112: v2(263.85,38.91) 263.96,38.8 263.96,35.29 268.81,30.44 269.6,30.44 270.83,29.21 270.83,28.87 270.8,28.84 270.8,28.19 270.83,28.16 270.83,27.2 270.67,27.04 RN18.1
  IN1 w0.074: v2(263.85,38.91) 263.99,39.05 263.99,39.16 263.79,39.36 256.57,39.36 256.1,38.89 250.96,38.89 248.97,40.88 243.65,40.88 241.8,42.73 218.72,42.73 218.27,42.28 216.6,42.28 216.31,42.57 213.75,42.57 212.7,41.52 211.32,41.52 210.91,41.11 206.21,41.11 198.33,33.23 198.33,31.7 195.94,29.31 190.86,29.31 187.68,26.12 179.82,26.12 174.21,20.52 158.97,20.52 153.56,21.87 153.24,21.98 153.21,21.99 152.91,22.1 152.9,22.1 152.36,22.29 151.23,22.67 150.97,22.76 150.42,22.98 150.38,22.99 150.32,23.01 149.28,23.47 149.04,23.58 149.02,23.58 147.48,24.38 146.28,25.11 145.18,25.86 144.38,26.41 144.38,26.41 143.39,27.11 143.13,27.31 143.12,27.31 143.01,27.39 143.01,27.4 141.79,28.45 141.78,28.46 141.54,28.66 139.68,30.49 138.3,32.26 137.87,32.88 137.47,33.36 136.79,34.35 136.6,34.65 136.15,35.4 136.09,35.49 136.09,35.5 136.05,35.57 134.92,37.53 134.65,38.03 134.65,38.03 134.66,38.06 132.79,41.62 131.87,45.53 131.59,46.15 130,47.74 129.69,47.74 128.23,49.2 128.23,50.03 126.04,52.22 125.46,52.22 124.75,51.5 123.08,51.5 122.12,52.47 120.92,52.47 120.14,53.26 120.14,55.97 119.54,56.57 119.54,58.01 114.48,63.08 113.26,63.08 111.8,64.53 109.1,64.53 108.88,64.76 108.88,65.05 v4(108.7,65.23)
  IN3 w0.074: v4(108.7,65.23) 108.59,65.23 108.49,65.13 108.49,64.98 108.59,64.89 108.84,64.89 108.91,64.81 108.91,64.71 108.82,64.62 106.52,64.62 105.87,65.27 103.11,65.27 101.14,63.3 94.65,63.3 91.72,60.37 91.72,56.98 91.12,56.38 91.12,55.45 91.04,55.38 90.91,55.38 v5(90.9,55.39)
  BOTTOM w0.112: UCPU1.BE1 91.48,55.26 91.03,55.26 v5(90.9,55.39)
CLK_PCIE_N5_R: length 2.7
  TOP w0.112: v6(270.61,25.6) 270.81,25.8 270.81,26.32 270.67,26.46 RN18.2
  BOTTOM w0.112: JNGFF1.53 270.65,24.76 270.8,24.91 270.8,25.41 v6(270.61,25.6)
CLK_PCIE_P0: length 91.4
  IN1 w0.074: v4(87.84,59.38) 87.57,59.65 87.32,59.65 86.1,60.87 85.41,60.87 81.13,65.15 71.58,65.15 70.77,64.34 68.37,64.34 68.27,64.45 64.07,64.45 63.97,64.35 62.26,64.35 61.6,64.57 60.73,65.32 60.17,65.83 59.66,66.13 58.78,66.48 58.48,66.74 58.26,67.13 57.96,67.37 56.4,67.98 55.45,68.47 53.98,69.28 53.98,69.28 52.31,70.2 51.6,70.63 50.04,70.63 48.82,71.85 47.37,71.85 47.28,71.94 46.05,71.94 45.09,70.97 42.59,70.97 41.91,71.65 41.06,71.65 40.84,71.86 40.46,71.86 40.07,71.47 37.87,71.47 36.32,69.92 35.75,69.92 32.09,66.26 32.09,65.35 30.05,63.31 30.05,62.97 29.39,62.31 28.8,62.31 28.25,61.76 28.25,61.6 26.56,59.9 26.56,56.38 26.09,55.91 26.09,55.08 26.65,54.52 26.65,50.06 26.13,49.53 26.13,49.33 26.2,49.26 v4(26.42,49.26)
  IN3 w0.074: v5(88.18,59.43) 87.9,59.43 v4(87.84,59.38) ; v5(26.18,49.02) v4(26.42,49.26)
  BOTTOM w0.112: v5(88.18,59.43) 88.06,59.55 87.86,59.55 87.73,59.42 87.73,59.15 88.64,58.24 v7(88.64,57.51) 88.64,55.05 88.39,54.8 88.39,54.61 UCPU1.AY3
CLK_PCIE_P1: length 166
  IN1 w0.074: v4(204.25,36.57) 204.23,36.55 203.94,36.55 203.79,36.7 202.35,36.7 198.77,33.12 198.77,31.6 195.95,28.78 191.21,28.78 188.17,25.75 179.98,25.75 174.36,20.13 158.71,20.13 158.62,20.14 156.91,20.6 155.2,21.07 155.01,21.11 155.01,21.11 154.93,21.13 154.92,21.13 154.8,21.15 154.68,21.18 153.4,21.52 151.85,22.06 151.19,22.24 151.19,22.24 150.87,22.35 150.54,22.5 150.48,22.52 150.35,22.58 150.1,22.68 150.09,22.68 150.04,22.71 149.66,22.87 149.48,22.95 148.82,23.24 147.97,23.67 147.84,23.74 147.28,24.05 146.06,24.79 144.04,26.16 143.56,26.5 143.01,26.9 142.55,27.27 142.38,27.42 142.38,27.42 141.34,28.32 140.3,29.29 140.01,29.57 139.65,29.95 139,30.69 138.84,30.88 138.03,31.9 138.01,31.93 137.95,32.01 137.89,32.09 137.28,32.93 136.64,33.85 135.72,35.37 134.29,37.84 132.02,42.16 131.56,43.08 131.18,43.46 130.85,43.46 130.4,43.91 130.4,44.71 131.02,45.32 131.02,46.18 129.83,47.36 129.52,47.36 127.85,49.03 127.85,49.85 127.04,50.67 123.34,50.67 121.94,52.06 120.8,52.06 119.76,53.1 119.76,54.33 119.11,54.98 119.11,57.88 114.3,62.69 113.06,62.69 111.62,64.13 107.76,64.13 107.43,64.46 107.43,64.95 v4(107.61,65.13)
  IN3 w0.074: v4(107.61,65.13) 107.47,65.26 107.47,65.71 107.26,65.92 102.94,65.92 100.91,63.89 94.4,63.89 91.14,60.63 91.14,57.32 90,56.18 90,55.06 90.29,54.78 90.42,54.78 v5(90.47,54.73) ; v5(204.81,36.26) 204.54,36.26 204.53,36.26 204.36,36.26 204.25,36.36 v4(204.25,36.57)
  BOTTOM w0.112: RN45.1 207,28.92 206.73,28.92 206.62,28.81 206.62,28.69 206.54,28.61 206.27,28.61 205.15,29.72 v7(205.15,31.43) 205.15,32.59 205.8,33.24 205.8,35.11 204.81,36.09 v5(204.81,36.26)
