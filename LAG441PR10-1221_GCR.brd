# Allegro board LAG441PR10-1221_GCR.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP: 290.21,44.98 290.04,45.15 290.04,45.29 290.11,45.36 290.29,45.36 290.34,45.31 290.79,45.31 292.81,47.33 292.81,50.85 294.93,52.98 299.82,52.98 300.24,53.4 300.24,54.01 299.95,54.3 299.95,54.6 300.21,54.87 300.21,55.62 300.07,55.77 299.83,55.77 299.82,55.77 297.66,55.77 297.47,55.96 296.3,55.96 296.22,55.87 296.22,54.75 296.28,54.69 297.33,54.69 297.41,54.6 297.41,54.37 297.38,54.35 296.25,54.35 296.15,54.25 294.87,54.25 294.74,54.37 293.09,54.37 290.43,51.71 290.43,48.69 289.62,47.88 288.91,47.88 288.84,47.95 288.84,48.18 288.92,48.26 289.46,48.26 290.02,48.83 290.02,51.82 292.63,54.42 292.63,54.43 294.6,56.41 298.98,56.41 299.36,56.03 300.07,56.03 300.58,55.52 300.58,52.47 300.2,52.09 294.49,52.09 293.06,50.66 293.06,47.15 290.89,44.98
GND on TOP: 306.35,25.19 307.59,25.19 307.76,25.36 307.76,26.24 307.44,26.57 306.56,26.57 306.23,26.24 306.23,25.31
GND on TOP: 124.28,58.3 124.21,58.37 124.21,59.28 124.32,59.39 124.37,59.39 125.39,59.39 125.51,59.26 125.51,58.38 125.44,58.3
GND on TOP: 16.99,40.45 16.99,39.8 17.06,39.73 17.06,39.72 17.09,39.7 17.45,39.7 17.56,39.59 17.56,39.38 17.42,39.24 17.11,39.24 16.99,39.12 16.99,38.62 17.11,38.51 17.4,38.51 17.57,38.34 17.57,38.15 17.43,38.01 17.19,38.01 17.17,38.03 16.27,38.03 16.22,38.08 16.22,40.35 16.32,40.45
GND on BOTTOM: 62.39,52.51 62.6,52.3 62.6,50.18 62.48,50.06 55.22,50.06 55.04,50.25 55.04,52.2 55.25,52.41 56.46,52.41 56.55,52.51
GND on BOTTOM: 204.32,47.26 204.19,47.14 204.19,44.34 204.32,44.21 207.36,44.21 207.49,44.34 207.49,46.63 206.86,47.26
GND on BOTTOM: 26.42,75.03 26.5,74.95 26.5,74.89 26.52,74.84 26.52,74.63 26.38,74.4 26.47,74.16 26.49,74.13 26.48,74.1 26.43,73.94 26.47,73.79 26.68,73.6 26.96,73.68 27.02,73.68 27.15,73.55 27.15,73.04 26.9,72.79 25.37,72.79 24.99,73.17 24.77,73.17 24.38,73.56 24.38,73.85 24.52,74.12 24.36,74.36 24.36,76.25 24.45,76.43 24.36,76.62 24.36,76.75 24.45,76.93 24.36,77.12 24.36,77.83 24.52,77.99 25.99,77.99 26.14,77.84 26.14,77.23 26.01,77.11 26.01,77.07 25.97,76.93 26.01,76.8 26.01,76.73 25.96,76.69 25.93,76.66 25.9,76.64 25.86,76.65 25.47,76.43 25.86,76.22 25.89,76.23 25.93,76.21 25.96,76.17 26.45,75.69 26.52,75.69 26.52,75.53 26.44,75.53 26.42,75.55 26.38,75.61 26.31,75.65 26.16,75.71 26,75.65 25.94,75.62 25.87,75.64 25.7,75.69 25.53,75.6 25.46,75.57 25.39,75.6 25,75.43 25.39,75.27 25.46,75.3 25.53,75.27 25.72,75.18 25.91,75.26 25.97,75.29 26.04,75.28 26.07,75.27 26.15,75.22 26.26,75.21 26.31,75.17 26.35,75.09 26.42,75.03
GND on BOTTOM: 22.08,43.61 22.08,41.32 22.12,41.27 22.84,41.27 22.84,41.27 22.89,41.27 23.43,41.82 24.39,41.82 24.52,41.95 24.52,44.62 24.44,44.7 21.18,44.7 21.13,44.64 21.13,43.82 21.24,43.7 21.99,43.7
GND on BOTTOM: 24.61,70.25 25.75,70.25 26.01,70 26.01,69.56 27.15,68.42 27.15,66.19 27.02,66.06 24.36,66.06 24.1,66.31 24.1,69.74
GND on BOTTOM: 290.17,39.73 291.18,39.73 291.31,39.86 291.31,41.26 291.18,41.38 290.17,41.38 290.04,41.26 290.04,39.86
GND on BOTTOM: 17,40.5 17,39.77 17.06,39.71 17.42,39.71 17.56,39.57 17.56,39.35 17.44,39.23 17.11,39.23 17,39.11 17,38.54 17,38.54 17.06,38.48 17.44,38.48 17.57,38.35 17.57,38.11 17.46,38 17.1,38 17,37.9 17,36.22 16.23,36.22 16.23,40.5
GND on BOTTOM: 55.51,41.34 55.51,39.35 55.63,39.23 63.28,39.23 63.39,39.35 63.39,41.29 63.3,41.38 55.55,41.38
GND on BOTTOM: 49.13,25.12 49.13,27.41 49.27,27.55 49.56,27.55 49.74,27.73 49.74,30.58 50.32,31.15 51.52,31.15 51.95,30.73 51.95,27.96 51.24,27.25 50.94,27.25 50.57,26.89 50.31,26.89 50.08,26.65 50.08,25.13 50.07,25.12
GND on BOTTOM: 296.39,59.76 296.54,59.76 296.62,59.68 296.62,56.66 296.39,56.43 293.83,56.43 293.6,56.66 293.6,57.55 294.49,58.44 296.26,58.44 296.34,58.51 296.34,59.71
GND on BOTTOM: 46.22,29.87 46.22,27.7 46.25,27.67 47.65,27.67 47.73,27.75 47.73,28.78 47.95,29 48.34,29 48.52,29.17 48.52,29.96 48.37,30.11 46.83,30.11 46.71,29.99 46.33,29.99
GND on BOTTOM: 290.89,74.31 291.35,74.31 292.07,75.04 292.07,75.63 291.97,75.74 290.85,75.74 290.78,75.66 290.78,74.43
GND on BOTTOM: 53.16,25.56 54,25.56 54.29,25.28 54.29,22.17 54.2,22.08 53.17,22.08 53.06,22.2 53.06,25.46 53.06,25.46
GND on BOTTOM: 201.84,39.8 201.84,37.66 201.89,37.61 202.65,37.61 202.7,37.66 202.7,39.8 202.68,39.82 201.87,39.82
GND on GND1: outline of 322 points within 0.2,0.2 315.91,80.23 ; 16 cut-outs
GND on IN1: 79.89,51.5 80.15,51.5 80.43,51.22 80.43,51.07 80.1,50.74 79.89,50.74 79.74,50.89 79.31,50.89 79.18,50.77 78.98,50.77 78.9,50.84 78.9,51.4 79.01,51.5 79.13,51.5 79.18,51.45 79.84,51.45
GND on IN1: 110.34,71.31 110.26,71.39 108.63,73.02 108.63,76.01 108.79,76.16 122.17,76.16 123.6,74.73 123.6,74.38 123.45,74.22 118.23,74.22 117.98,73.97 117.98,72.22 117.7,71.94 112.27,71.94 112.11,71.78 112.11,71.53 111.88,71.31
GND on IN1: 295.63,56.28 296.52,56.28 296.77,56.03 296.77,54.25 294.74,52.22 293.72,52.22 293.22,52.72 293.22,53.87
GND on GND2: outline of 323 points within 0.2,0.2 315.91,80.23 ; 8 cut-outs
GND on VCC: outline of 295 points within 0.2,14.5 315.91,80.23 ; 4 cut-outs
GND on VCC: 74.86,51.52 72.81,53.56 72.81,53.66 73.06,53.91 73.06,55.26 74.65,55.26 74.65,54.46 75.73,53.38 75.73,51.52
GND on VCC: outline of 102 points within 0.45,0.2 315.36,18.31
GND on GND3: outline of 318 points within 0.2,0.2 315.91,80.23 ; 9 cut-outs
GND on IN3: 24.34,75.23 24.42,75.23 24.57,75.08 25.44,75.08 25.82,74.69 25.82,74.47 25.69,74.34 25.39,74.34 25.36,74.31 25.36,73.88 25.28,73.81 24.68,73.81 24.6,73.88 24.6,74.01 24.7,74.11 24.7,74.64 24.52,74.82 24.37,74.82 24.27,74.92 24.27,75.15
GND on GND4: outline of 321 points within 0.2,0.2 315.91,80.23 ; 31 cut-outs
VCC0V9_LVR_OUT on TOP (solid shape): 21.95,53.13 21.95,52.83 22.06,52.73 22.06,52.64 22.49,52.64 22.55,52.58 22.55,52.14 22.51,52.09 22.09,52.09 22,52.18 22,52.47 21.91,52.56 21.91,52.63 21.42,52.63 21.39,52.67 21.39,53.14 21.45,53.2 21.89,53.2
VCC0V9_LVR_OUT on TOP: 18.64,49.27 20.14,49.27 20.32,49.45 21.33,49.45 21.39,49.5 21.39,49.88 21.28,49.98 18.75,49.98 18.6,49.83 18.6,49.31
VCC0V9_LVR_OUT on BOTTOM: 20.85,49.59 20.85,49.82 21.25,50.21 21.25,52.93 21.38,53.06 22.41,53.06 22.67,52.79 22.67,50.14 22.47,49.94 22.16,49.94 21.74,49.52 20.93,49.52
VCC0V9_LVR_OUT on IN1: 21.77,53.37 22.39,52.75 22.39,52.36 22.32,52.29 21.92,52.29 21.17,53.04 21.17,53.28 21.26,53.37
VCC0V9_SVR on TOP (solid shape): 17.53,62.24 17.53,58.88 17.39,58.74 16.45,58.74 16.33,58.86 16.33,62.21 16.46,62.34 17.43,62.34
VCC0V9_SVR on BOTTOM (solid shape): 18.1,62.22 18.1,58.44 17.89,58.24 16.43,58.24 16.22,58.45 16.22,62.34 16.32,62.45 17.86,62.45
VCC0V9_SVR on IN1 (solid shape): 17.59,62.05 17.59,59.21 17.49,59.11 17,59.11 16.88,59.23 16.88,62.12 16.95,62.19 17.45,62.19
VCC0V9_SVR on TOP: 21.21,53.19 21.28,53.12 21.28,50.78 20.6,50.11 19.66,50.11 19.57,50.19 19.57,50.56 19.67,50.66 19.78,50.66 19.79,50.65 20.57,50.65 20.75,50.83 20.75,51.16 20.57,51.34 20.13,51.34 20.06,51.41 20.06,52.45 20.16,52.55 20.64,52.55 20.72,52.64 20.72,53.1 20.81,53.19 20.81,53.19
VCC0V9_SVR on IN2: 18.03,50.8 16.96,51.87 16.96,56.92 17.52,57.48 17.52,58.23 17.02,58.72 17.02,61.71 17.03,61.72 17.03,61.84 17.44,62.25 18.96,62.25 18.96,62.25 19.59,62.25 19.98,61.86 19.98,58.69 20.46,58.21 20.46,54.9 21.05,54.31 23.43,54.31 23.59,54.14 23.59,53.04 23.43,52.87 22.22,52.87 21.17,51.82 21.17,51.12 20.85,50.8
VCC3V3_ANA_PCIE on TOP (solid shape): 23.18,48.87 22.69,48.87 22.69,51.14 23.18,51.14
VCC3V3_ANA_USB2 on TOP (solid shape): 21.97,51.2 21.97,50.08 21.94,50.06 21.94,49.47 21.89,49.42 21.56,49.42 21.54,49.45 21.54,50.51 21.41,50.64 21.41,51.2 21.46,51.25 21.92,51.25
VIN_PRIM_CORE on BOTTOM (solid shape): 131.85,49 131.85,47.07 131.73,46.95 128.79,46.95 128.15,47.59 126.42,47.59 126.38,47.63 126.38,47.84 126.41,47.88 127.84,47.88 128.61,48.65 130.36,48.65 130.57,48.86 130.57,49.07 130.66,49.16 131.68,49.16
VIN_VCCIO on BOTTOM (solid shape): 104.74,18.92 104.74,17.88 105.66,16.96 105.66,16.15 105.87,15.94 105.87,14.42 105.77,14.32 105.03,14.32 104.94,14.41 104.94,15.18 104.82,15.3 104.13,15.3 104,15.17 104,14.62 103.91,14.53 103.27,14.53 103.18,14.62 103.18,16.72 103.2,16.73 103.73,16.73 104.46,17.46 104.46,18.91 104.54,18.99 104.66,18.99
(no net) on IN1: 110.04,71.61 108.63,73.02 108.63,76.01 108.79,76.16 122.17,76.16 123.6,74.73 123.6,74.38 123.45,74.22 118.23,74.22 117.98,73.97 117.98,72.22 117.7,71.94 114.74,71.94 114.46,72.22 111.86,72.22 111.73,72.09 111.73,71.77 111.57,71.61
(no net) on IN3: 65.82,73.55 65.35,74.02 65.35,75.38 65.6,75.63 68.11,75.63 69.02,74.72 69.02,73.93 68.64,73.55
(no net) on IN3: 108.9,72.72 108.54,73.07 108.54,75.94 108.76,76.15 122.06,76.15 122.53,75.68 122.53,72.98 122.27,72.72
(no net) on IN3: 128.94,76.03 131.16,76.03 131.48,75.71 131.48,72.54 131.29,72.35 129.26,72.35 128.69,72.92 128.69,75.77
+BATT on BOTTOM (solid shape): 42.78,18.91 42.78,15.6 43.01,15.37 43.04,15.34 46.1,15.34 46.13,15.32 46.13,14.48 46.05,14.41 41.57,14.41 41.52,14.46 41.52,18.95 41.62,19.05 42.64,19.05
+BATT on IN3 (solid shape): 39.58,15.32 39.58,12.82 39.39,12.63 38.12,12.63 37.31,13.44 37.31,14.98 37.32,14.98 37.32,15.48 37.43,15.59 39.32,15.59
+BATT on TOP: 41.38,12.97 41.22,13.12 41.22,15.23 41.95,15.96 43.94,15.96 44.55,15.35 44.55,15.14 44.55,15.13 44.55,13.48 44.04,12.97
+BATT on BOTTOM: 37.02,12.14 36.67,12.49 36.67,15.54 36.91,15.78 39.47,15.78 39.57,15.68 39.57,12.46 39.26,12.14
+BATT on IN1: 38.6,11.79 37.67,12.72 37.67,14.74 38.15,15.22 39.52,15.22 39.91,15.61 44.41,15.61 44.93,15.09 44.93,12.46 44.26,11.79
+CHG_SRC_20V on TOP: 17.75,39.67 17.75,39.32 17.53,39.11 17.2,39.11 17.12,39.02 17.12,38.77 17.25,38.64 17.52,38.64 17.73,38.43 17.73,38.37 17.76,38.34 17.81,38.34 18.38,38.34 18.39,38.34 18.39,40.44 18.37,40.46 17.22,40.46 17.12,40.35 17.12,39.97 17.24,39.85 17.57,39.85
+CHG_SRC_20V on BOTTOM: 21.05,33.69 21.43,34.07 21.43,37.15 20.32,38.26 20.32,38.71 20.24,38.79 19.6,38.79 19.32,39.07 19.32,39.34 19.52,39.54 20.2,39.54 20.22,39.56 20.22,40.04 19.99,40.27 19.57,40.27 19.5,40.34 19.5,40.96 19.42,41.05 17.84,41.05 17.68,40.88 17.68,40.49 17.67,40.49 17.51,40.33 17.2,40.33 17.11,40.24 17.11,39.92 17.17,39.86 17.55,39.86 17.55,39.86 17.68,39.73 17.68,39.28 17.52,39.12 17.23,39.12 17.12,39.01 17.12,38.75 17.27,38.6 17.56,38.6 17.58,38.58 17.68,38.48 17.68,37.28 17.29,36.89 17.29,36.29 17.47,36.11 17.74,36.11 17.84,36.01 17.84,34.38 17.72,34.26 16.87,34.26 16.83,34.22 16.83,33.69
+CHG_SRC_20V on IN1, IN3: 17.18,40.4 18.2,40.4 18.33,40.28 18.33,38.5 18.2,38.37 17.31,38.37 17.06,38.63 17.06,40.28
+CHG_VIN_20V on TOP (solid shape): 14.74,63.37 14.74,62.82 14.43,62.52 13.61,62.52 13.54,62.58 13.54,63.42 13.74,63.62 14.49,63.62
+CHG_VIN_20V on TOP (solid shape): 24.68,25.65 24.68,24.51 24.23,24.06 21.82,24.06 21.77,24.11 21.77,24.77 22.71,25.71 24.61,25.71
+CHG_VIN_20V on BOTTOM (solid shape): 11.17,44.77 11.17,43.18 11.04,43.05 10.05,43.05 9.9,43.2 9.9,44.74 10.09,44.92 11.02,44.92
+CHG_VIN_20V on BOTTOM (solid shape): 13.75,59.11 13.75,56.56 13.63,56.43 12.61,56.43 12.58,56.46 12.58,59.04 12.72,59.18 13.68,59.18
+CHG_VIN_20V on BOTTOM (solid shape): 9.83,45.52 9.83,45.14 10.04,44.92 11.02,44.92 11.17,44.77 11.17,43.18 11.04,43.05 9.4,43.05 9.04,43.42 9.04,45.54 9.14,45.64 9.71,45.64
+CHG_VIN_20V on IN1 (solid shape): 27.33,39.28 27.33,38.48 27.14,38.28 25.51,38.28 25.26,38.54 25.26,39.4 25.5,39.64 26.97,39.64
+CHG_VIN_20V on IN3 (solid shape): 13.52,60.17 13.52,56.53 13.49,56.51 12.88,56.51 11.81,57.58 11.81,60 12.12,60.3 13.38,60.3
+CHG_VIN_20V on IN3 (solid shape): 11.71,46.2 11.71,45.4 11.9,45.21 11.9,43.17 11.75,43.02 10.15,43.02 9.89,43.29 9.54,43.29 9.3,43.52 9.3,45.32 10.31,45.32 10.31,45.28 10.32,45.24 10.34,45.2 10.36,45.17 10.39,45.14 10.43,45.11 10.47,45.1 10.51,45.09 10.55,45.09 10.59,45.09 10.63,45.11 10.67,45.13 10.7,45.15 10.73,45.19 10.75,45.22 10.78,45.23 10.82,45.2 10.86,45.18 10.91,45.17 10.96,45.16 11.01,45.16 11.06,45.17 11.1,45.19 11.15,45.22 11.18,45.25 11.22,45.28 11.24,45.33 11.26,45.37 11.27,45.42 11.28,45.47 11.27,45.52 11.26,45.57 11.24,45.61 11.21,45.65 11.18,45.69 11.14,45.72 11.1,45.74 11.05,45.76 11,45.77 10.95,45.77 10.9,45.76 10.86,45.75 10.81,45.73 10.77,45.7 10.74,45.66 10.71,45.62 10.69,45.58 10.67,45.53 10.65,45.52 10.61,45.53 10.57,45.54 10.52,45.54 10.48,45.54 10.44,45.52 10.41,45.5 10.37,45.47 10.35,45.44 10.33,45.4 10.31,45.36 10.31,45.32 9.3,45.32 9.3,46 9.71,46.41 11.5,46.41
+CHG_VIN_20V on TOP: 13.82,40.02 13.82,42.44 13.56,42.69 12.8,42.69 12.57,42.46 10.97,42.46 10.87,42.36 10.87,41.36 11,41.22 11.87,41.22 13.19,39.9 13.69,39.9
+CHG_VIN_20V on BOTTOM: 25.57,43.35 25.57,38.89 25.66,38.79 27.38,38.79 27.5,38.91 27.5,43.32 27.37,43.45 25.67,43.45
+CHG_VIN_20V on IN1: 14.39,62.88 12.23,62.88 11.98,62.63 11.98,57.99 12.3,57.66 12.39,57.66 12.52,57.53 12.52,56.65 12.64,56.53 14.04,56.53 14.52,57 14.52,62.76
+CHG_VIN_20V on IN1: 22.79,26.55 24.62,26.55 25.09,26.08 25.09,25.26 23.82,23.99 21.93,23.99 21.65,24.27 21.65,25.42
+CHG_VIN_20V on IN1: 9.69,46.37 11.47,46.37 11.72,46.12 11.72,42.06 11.59,41.93 10.71,41.93 9.56,43.07 9.56,46.25
+CHG_VIN_20V on IN2: 23.84,25.27 23.38,25.73 23.38,32.96 23.83,33.41 23.83,37.96 24.37,38.5 24.37,39.25 25.02,39.9 27.07,39.9 27.3,39.67 27.3,38.43 26.75,37.88 26.75,36.38 26.62,36.24 26.62,30.74 26.38,30.5 26.38,26.17 25.48,25.27
+CHG_VIN_20V on VCC: 14.9,36.21 14.9,38.03 8.74,44.19 8.74,63.01 14.56,63.01 17.15,65.61 17.6,65.61 17.63,65.58 17.63,47.41 21.08,43.96 23.87,43.96 27.66,40.17 27.66,37.59 26.28,36.21 ; 2 cut-outs
+CHG_VIN_20V on IN3: 25.18,38.58 25.18,39.55 25.78,40.15 27.09,40.15 27.51,39.73 27.51,38.63 27.16,38.28 25.48,38.28
+EC_DEBUG_VCC on TOP (solid shape): 240.51,68.89 240.51,68.51 240.38,68.38 238.85,68.38 238.71,68.51 238.71,68.83 238.89,69.01 239.49,69.01 239.5,69.02 240.38,69.02
+INV_PWR_SRC on IN1 (solid shape): 50,67.64 50,67.17 49.85,67.01 49.14,67.01 48.88,67.27 48.88,67.47 48.88,67.47 48.88,67.8 49.08,68 49.64,68
+INV_PWR_SRC on TOP: 33.12,76.74 33.12,77.74 33.22,77.84 33.92,77.84 34.09,77.68 34.09,74.41 34.08,74.4 33.85,74.17 33.85,73.34 33.51,73.01 32.79,73.01 32.7,73.09 32.7,76.32
+INV_PWR_SRC on TOP: 50.2,68.37 49.83,68.74 49.33,68.74 48.67,68.08 48.67,66.41 48.83,66.24 49.5,66.24 49.83,65.91 49.83,63.95 49.83,63.94 49.83,62.35 50.05,62.35 50.27,62.14 50.6,62.14 50.73,62.26 50.73,64.95 50.69,64.99 50.32,64.99 50.2,65.1
+INV_PWR_SRC on BOTTOM: 31.56,78.14 32.5,78.14 32.54,78.09 32.54,77.53 32.69,77.38 32.94,77.38 33.01,77.31 33.01,76.27 32.92,76.19 31.95,76.19 31.46,76.69 31.46,78.03
+INV_PWR_SRC on IN1: 33.1,77.27 33.1,76.15 33.23,76.02 34.11,76.02 34.21,76.11 34.21,77.31 34.04,77.48 33.31,77.48
+INV_PWR_SRC on VCC: 33.46,77.43 33.04,77.43 32.8,77.19 32.8,70.94 34.56,69.18 35.95,69.18 39.13,66 49.96,66 50.33,66.36 50.33,67.54 49.97,67.9 49.16,67.9 48.79,67.52 40.82,67.52 37.14,71.2 34.21,71.2 33.82,71.59 33.82,77.07
+INV_PWR_SRC on IN3: 32.36,76.33 32.36,76.83 32.37,76.84 32.37,77.24 32.64,77.51 33.4,77.51 33.61,77.3 33.61,76.33 33.48,76.2 32.49,76.2
+INV_PWR_SRC_L on TOP: 31.53,68.74 31.32,68.95 31.32,71.26 31.52,71.46 31.52,72.29 31.06,72.74 30.73,72.74 30.09,73.39 30.09,75.11 30.33,75.35 32.46,75.35 32.55,75.27 32.55,73.09 33.09,72.56 33.09,71.21 33.02,71.14 33.02,68.88 32.88,68.74
+IR_B+ on BOTTOM: 131.07,26.32 130.89,26.15 128.51,26.15 127.98,26.68 127.23,26.68 127.15,26.6 127.15,25.62 127.43,25.35 131.56,25.35 131.57,25.36 133.01,25.36 133.28,25.62 133.96,25.62 134.09,25.75 134.09,25.99 133.86,26.21 131.67,26.21 131.55,26.32
+LCDVDD on TOP: 37.24,75.48 37.24,75.05 37.03,74.85 37.03,73.36 37.1,73.3 37.63,73.3 37.78,73.45 37.78,73.58 37.99,73.8 38.82,73.8 39.03,74 39.03,74.85 38.85,75.03 38.36,75.03 38.27,75.12 38.27,75.54 38.21,75.6 37.78,75.6 37.22,76.16 37.22,76.17 37.12,76.27 37.12,76.7 36.7,77.12 36.7,77.78 36.63,77.85 36.24,77.85 36.15,77.77 36.15,76.98 36.39,76.75 36.39,76.67 36.39,76.66 36.39,75.72 36.52,75.58 37.13,75.58
+LCDVDD_L on TOP: 38.9,71.39 38.39,71.9 38.39,72.1 38.37,72.13 38,72.13 37.9,72.23 37.9,73.45 38,73.55 38.82,73.55 38.92,73.45 38.92,72.52 39.28,72.15 39.9,72.15 40.11,71.95 40.11,71.54 39.95,71.39
+RTCVCC on IN2: 98.54,40.02 99.73,41.22 99.73,42 99.5,42.23 97.5,42.23 97.5,42.23 97.27,42.23 97.1,42.07 97.1,40.27 97.35,40.02
+RTCVCC_R on TOP (solid shape): 311.19,8.78 311.19,7.89 308.52,5.23 307.89,5.23 307.76,5.35 307.76,6.75 308.01,7 308.52,7 309.16,7.64 309.79,7.64 310.04,7.89 310.04,8.78 310.3,9.04 310.93,9.04
+SD_VDD1 on TOP (solid shape): 302.18,34.08 302.18,33.64 301.95,33.41 300.5,33.41 299.31,32.23 298.06,32.23 297.91,32.38 297.91,33.66 298.08,33.83 299.46,33.83 299.9,34.27 301.99,34.27
+SD_VDD1 on IN1: 295.3,33.57 298.79,33.57 298.99,33.36 298.99,32.26 298.78,32.05 296.13,32.05 294.91,30.82 293.59,30.82 293.19,30.42 292.1,30.42 291.86,30.66 291.86,31.36 291.87,31.37 291.87,32.38 292.45,32.96 292.92,32.96 293.02,32.86 293.02,32.57 292.94,32.49 292.94,32.22 293.03,32.13 293.83,32.13 293.83,32.14 293.87,32.14
+SD_VDD2 on TOP: 299.89,37.91 300.04,38.06 312.77,38.06 314.28,36.55 315.2,36.55 315.32,36.43 315.32,35.7 315.19,35.57 313.78,35.57 313.77,35.58 313.48,35.58 312.22,36.84 298.14,36.84 298,36.98 297.99,36.98 297.85,37.12 297.73,37.12 297.48,37.38 297.48,37.95 297.72,38.19 298.03,38.19 298.12,38.11 298.12,37.98 298.19,37.91
+SD_VDD2 on IN1: 295.77,38.12 297.98,38.12 298.28,37.82 298.28,37.09 298.11,36.91 297.75,36.91 297.54,37.12 296.23,37.12 295.85,36.74 295.85,34.56 294.43,33.14 294.43,33.14 293.55,32.26 293.08,32.26 292.99,32.35 292.99,32.49 293.08,32.57 293.08,33.22 293.1,33.25 293.1,34.19 294.62,35.71 294.62,36.98
+SIM_PWR on BOTTOM: 289.28,39.39 291.95,39.39 292.58,38.75 294.11,38.75 294.61,38.25 296.65,38.25 297.28,38.88 299.69,38.88 299.82,38.75 299.82,37.86 299.44,37.48 289.28,37.48 289.03,37.74 289.03,39.13
+TBT_VBUS1 on TOP (solid shape): outline of 102 points within 5.66,52.05 11.52,60.18
+TBT_VBUS1 on BOTTOM (solid shape): 10.2,54.88 10.2,51.58 10.07,51.45 8.42,51.45 8.17,51.7 8.17,54.7 7.43,55.44 7.43,56.03 7.56,56.15 8.93,56.15
+TBT_VBUS1 on IN1 (solid shape): 8.92,55.84 8.92,54.57 8.85,54.5 8.41,54.5 8.41,54.54 7.93,54.8 7.84,54.27 7.85,54.24 7.84,54.2 7.87,53.71 8.36,53.79 8.62,53.79 8.78,53.63 8.78,53.55 8.77,53.54 8.72,53.28 8.89,53.08 8.92,53.07 8.92,52.73 8.88,52.68 8.88,52.68 8.64,52.44 8.29,52.44 7.94,52.09 6.72,52.09 6.66,52.15 6.62,52.19 6.62,52.32 6.63,52.33 6.68,52.5 6.63,52.67 6.62,52.68 6.62,52.71 6.54,52.79 6.46,52.79 6.38,52.81 6.3,52.79 6.19,52.79 6.18,52.8 6.1,52.84 6.01,52.84 5.99,52.83 5.98,52.82 5.91,52.78 5.85,52.71 5.84,52.68 5.78,52.63 5.56,52.63 5.48,52.71 5.48,52.97 5.69,53.17 5.75,53.17 5.89,53.17 6.04,53.32 6.91,53.32 6.92,53.31 7.31,53.41 7.24,53.8 7.24,54.44 7.26,54.51 7.33,54.54 7.57,54.71 7.54,55 7.52,55.13 7.45,55.24 7.45,55.56 7.58,55.69 7.6,55.88 7.6,55.88 7.6,56.02 8.75,56.02
+TBT_VBUS1 on IN2 (solid shape): outline of 498 points within 5.1,52.75 8.97,56.9
+TBT_VBUS1 on IN3 (solid shape): 5.82,56.2 5.88,56.01 6.07,55.95 6.12,55.95 6.27,55.83 6.46,55.82 6.58,55.7 6.58,55.47 6.5,55.4 6.17,55.4 6.09,55.56 5.91,55.61 5.84,55.68 5.84,55.68 5.77,55.73 5.69,55.77 5.65,55.8 5.37,55.8 5.33,55.84 5.28,55.86 5.28,56.14 5.34,56.2
+TBT_VBUS1 on IN3 (solid shape): 8.95,55.83 8.95,55.76 8.95,55.72 8.95,55.65 8.95,55.51 8.97,55.5 9,55.15 9.19,54.87 9.52,54.94 9.54,54.92 9.54,53.86 9.34,53.66 9.08,53.66 9.02,53.66 8.93,53.65 8.72,53.43 8.81,53.14 8.81,53.08 8.66,52.94 7.58,52.94 7.44,53.07 7.44,53.7 7.57,53.83 7.78,53.83 8.27,53.7 8.31,54.2 8.3,54.24 8.31,54.27 8.34,54.7 7.92,54.79 7.74,54.79 7.55,55.04 7.54,55.12 7.5,55.2 7.34,55.57 7.34,55.69 7.65,56 8.79,56
+TBT_VBUS1 on BOTTOM: 3.97,56.28 5.63,56.28 5.7,56.21 5.7,55.97 5.59,55.87 5.09,55.87 4.86,55.64 4.86,53.87 4.74,53.74 3.97,53.74 3.85,53.87 3.85,56.15
+TBT_VBUS2 on TOP (solid shape): 10.84,74.82 11.18,74.63 11.54,74.47 11.7,74.41 11.86,74.36 12.41,73.81 12.41,72.95 11.5,72.04 10.41,72.04 9.79,72.66 9.05,72.66 8.76,72.37 7.22,72.37 7.05,72.2 7.05,70.96 7.28,70.74 8,70.74 8.02,70.71 8.78,70.71 8.91,70.58 8.78,70.46 8.06,70.46 8.04,70.44 7.23,70.44 7.07,70.28 7.07,68.46 7.32,68.21 8.78,68.21 8.91,68.08 8.78,67.96 7.27,67.96 7.11,67.8 7.11,67.34 7.03,67.27 6.66,67.27 6.59,67.33 6.59,67.93 6.35,68.17 5.72,68.17 5.65,68.25 5.65,68.4 5.73,68.48 6.36,68.48 6.57,68.7 6.57,70.46 6.34,70.69 5.73,70.69 5.65,70.77 5.65,70.89 5.73,70.98 6.42,70.98 6.51,71.07 6.51,71.17 6.57,71.33 6.51,71.5 6.51,71.67 6.57,71.84 6.51,72 6.51,72.21 6.51,72.22 6.54,72.33 6.52,72.43 6.51,72.46 6.75,72.7 6.76,72.71 6.9,72.82 7.01,72.96 7.02,72.97 7.08,73.04 8.05,73.04 8.42,73.41 8.42,73.61 8.57,73.75 9.88,73.75 10.18,74.06 10.18,74.58 10.43,74.83 10.83,74.83
+TBT_VBUS2 on IN1 (solid shape): 9,70.99 9,70.82 8.95,70.72 8.96,70.61 8.97,70.53 8.96,70.45 8.95,70.34 9,70.23 9,69.72 8.41,69.72 7.94,70.02 7.87,69.47 7.87,69.44 7.86,68.94 8.36,69.01 8.62,69.01 8.73,68.9 8.73,68.69 8.71,68.58 8.73,68.47 8.73,68.41 8.74,68.41 8.74,68.31 8.91,68.14 8.91,67.97 8.6,67.66 8.29,67.66 7.94,67.31 6.72,67.31 6.66,67.37 6.62,67.41 6.62,67.54 6.68,67.72 6.62,67.9 6.62,67.93 6.54,68.01 6.46,68.01 6.38,68.03 6.3,68.01 6.19,68.01 6.06,68.06 5.93,68.03 5.84,68.12 5.84,68.34 6.04,68.54 6.9,68.54 6.9,68.54 7.3,68.62 7.24,69.02 7.24,69.77 7.54,69.89 7.54,70.22 7.52,70.35 7.45,70.46 7.45,70.78 7.58,70.91 7.6,71.1 7.6,71.24 8.75,71.24
+TBT_VBUS2 on IN3 (solid shape): 8.95,71.05 8.95,70.94 8.95,70.9 9.11,70.74 9.14,70.66 9.11,70.59 9.04,70.21 9.4,70.09 9.5,70.08 9.54,70 9.54,69.08 9.34,68.88 9.08,68.88 9.02,68.88 8.93,68.87 8.72,68.66 8.79,68.37 8.81,68.36 8.81,68.3 8.66,68.16 7.46,68.16 7.33,68.28 7.33,68.65 7.34,68.66 7.36,68.73 7.37,68.81 7.37,68.84 7.56,69.03 7.79,69.03 8.27,68.92 8.32,69.41 8.31,69.42 8.3,69.46 8.31,69.49 8.32,69.5 8.35,69.91 7.96,70.03 7.95,70.03 7.76,70.03 7.57,70.22 7.54,70.35 7.5,70.42 7.34,70.79 7.34,70.91 7.59,71.16 8.84,71.16
+TBT_VBUS2 on BOTTOM: 9.56,68.85 10.18,68.23 10.18,65.72 10.29,65.61 10.67,65.61 10.72,65.55 10.72,65.14 10.7,65.12 8.67,65.12 8.56,65.23 8.56,66.48 8.44,66.6 8.44,68.24 7.96,68.72 7.96,69.95 7.8,70.12 7.52,70.12 7.46,70.18 7.46,71.13 7.47,71.14 7.47,72.08 8.13,72.74 8.13,74.1 7.72,74.5 7.72,75.58 7.82,75.69 8.48,75.69 8.74,75.43 8.8,75.43 9.24,74.98 9.24,70 9.56,69.68
+TBT_VBUS2 on IN2: 9.23,68.78 8.46,68 4.36,68 4,68.36 4,72.08 4.56,72.64 8.82,72.64 9.23,72.22
+V_DDR_REFA_R on BOTTOM: 66.96,33.86 67.18,33.64 67.18,33.36 67.11,32.94 67.2,32.84 67.2,32.04 67.17,32.01 67.17,31.87 67.88,31.16 68.81,31.16 69.04,30.93 69.04,30.53 68.96,30.46 67.2,30.46 66.29,31.37 66.29,31.38 65.66,32.01 65.66,33.47 66.05,33.86
+V_DDR_REFB_R on BOTTOM: 69.48,29.3 69.4,29.39 69.4,29.77 69.48,29.86 69.6,29.86 69.66,29.92 69.66,30.44 69.62,30.48 69.26,30.48 69.17,30.57 69.17,31 68.86,31.31 67.96,31.31 67.3,31.98 67.3,32.27 67.29,32.27 67.29,32.88 67.2,32.97 67.2,33.2 67.3,33.3 67.65,33.3 67.85,33.09 67.85,32.56 68.24,32.17 68.96,32.17 70.52,30.61 70.52,30.23 70.23,29.95 70.23,29.56 69.97,29.3
+VDISPLAY_VCC on TOP (solid shape): 14.03,35.25 16.81,35.25 17.19,34.87 18.08,34.87 18.85,35.63 19.34,35.63 19.53,35.44 19.53,34.75 18.81,34.03 16.33,34.03 16.13,34.23 14.22,34.23 14.11,34.23 13.02,35.32 12.62,35.32 12.39,35.55 12.39,36 12.58,36.19 13.09,36.19
+VREFCA on TOP (solid shape): 89.4,20.44 89.57,20.37 89.74,20.43 90.06,20.43 90.18,20.38 90.31,20.39 90.35,20.35 90.35,20.09 90.24,20.09 90.17,20.09 90.1,20.06 89.69,20.06 89.56,20.09 89.42,20.05 89.07,20.05 88.83,20.08 88.67,19.9 88.08,19.31 88.08,19.21 88.01,19.01 88.12,18.82 88.12,18.45 88.01,18.23 88.13,18.02 88.13,17.9 88.26,17.76 88.26,16.43 88.39,16.3 88.39,15.28 88.34,15.23 87.83,15.23 87.76,15.31 87.76,18 87.77,18.02 87.88,18.24 87.76,18.46 87.76,18.81 87.88,19.03 87.77,19.25 87.77,19.62 87.88,19.82 87.79,20.03 88.15,20.4 88.3,20.37 88.44,20.43 88.76,20.43 88.93,20.37 89.09,20.44
+VREFCA on TOP: 65.02,20.07 65.22,19.88 65.22,18.64 64.98,18.41 64.98,18.4 64.98,18.06 64.92,18 64.74,18 64.2,17.45 64.2,15.23 64.15,15.18 63.8,15.18 63.73,15.25 63.73,17.56 64.3,18.12 64.3,19.85 64.52,20.07
+VREFCA on BOTTOM: 65.97,15.13 65.86,15.24 65.86,17.73 65.66,17.92 65.66,19.99 65.76,20.08 66.4,20.08 66.47,20.02 66.47,15.21 66.39,15.13
+VREFCA on BOTTOM: 89.15,20.29 90.09,20.29 90.35,20.03 90.35,18.05 90.33,18.04 90.4,17.98 90.4,15.39 90.27,15.26 89.89,15.26 89.79,15.36 89.79,15.77 89.46,16.1 89.46,18.41 89.13,18.74 89.13,20.21 89.1,20.24
+VREFDQ_A on BOTTOM: 65.22,25.13 65.74,25.13 65.88,25.28 65.88,25.48 65.88,25.48 65.88,25.57 65.96,25.65 66.94,25.65 67.18,25.88 67.18,27.54 68.2,28.56 68.2,29.3 68.28,29.38 68.7,29.38 68.76,29.44 68.76,29.73 68.54,29.95 68.54,30.33 68.46,30.42 67.93,30.42 67.79,30.28 67.79,29.4 67.66,29.27 66.72,29.27 66.65,29.2 66.65,28.8 66.52,28.67 65.51,28.67 65.06,29.12 64.84,29.12 64.74,29.03 64.74,28.64 65.67,27.71 65.67,26.2 65.44,25.97 65.14,25.97 65.05,25.87 65.05,25.3
+VREFDQ_B on TOP: 90.02,26.94 89.51,27.45 89.13,27.45 88.87,27.2 88.87,26.69 89.13,26.43 89.13,26.18 88.62,25.67 88.62,25.04 88.75,24.91 89.89,24.91 90.02,25.04
+VREFDQ_B on BOTTOM: 89.25,25.16 89.38,25.29 89.38,29.23 89.25,29.36 89,29.36 88.87,29.23 88.87,28.97 88.49,28.59 88.49,25.29 88.62,25.16
B+ on TOP (solid shape): 40.9,35.35 40.9,33.54 40.87,33.5 40.17,33.5 40.14,33.53 40.14,34.2 39.65,34.69 39.65,35.45 39.75,35.55 40.7,35.55
B+ on TOP (solid shape): 34.62,72.73 35.06,72.73 35.3,72.48 35.3,71.57 35.51,71.37 35.51,70.86 35.34,70.69 34.17,70.69 33.52,71.34 33.52,72.79 33.66,72.93 34.42,72.93
B+ on BOTTOM (solid shape): 108.34,15.74 108.34,14.41 108.23,14.3 106.57,14.3 106.45,14.42 106.45,15.69 106.61,15.86 108.23,15.86
B+ on BOTTOM (solid shape): 203.69,35.48 203.69,34.38 203.36,34.05 200.32,34.05 200.19,34.18 200.19,35.58 200.24,35.63 203.54,35.63
B+ on BOTTOM (solid shape): 131.78,53.44 131.78,49.81 131.63,49.67 130.77,49.67 130.6,49.84 130.6,50.32 130.78,50.5 130.78,52.1 130.4,52.47 129.58,52.47 129.11,52.01 128.4,52.01 128.33,52.07 128.33,53.64 128.43,53.74 131.48,53.74
B+ on BOTTOM (solid shape): 32.43,55.72 34.06,55.72 34.3,55.49 34.3,54.19 34.26,54.15 32.8,54.15 32.69,54.26 32.69,54.74 32.34,55.09 31.81,55.09 31.57,55.33 31.57,55.8 31.8,56.03 32.13,56.03
B+ on BOTTOM (solid shape): 71.92,76.09 71.92,75.08 71.79,74.95 68.49,74.95 68.26,75.18 66.97,75.18 66.82,75.03 66.82,73.62 66.8,73.6 65.01,73.6 64.84,73.77 64.84,76.08 64.98,76.22 71.79,76.22
B+ on BOTTOM (solid shape): 131.61,76.09 131.61,72.41 131.48,72.28 128.22,72.28 127.7,71.76 126.45,71.76 126.38,71.83 126.38,73.57 126.45,73.64 126.45,74.98 126.22,75.22 122.65,75.22 122.53,75.34 122.53,76.26 122.61,76.35 131.36,76.35
B+ on BOTTOM (solid shape): 32.79,60.01 33.15,59.64 33.5,60.01 34.02,60.01 34.21,59.82 34.21,58.8 33.95,58.54 32.85,58.54 32.47,58.92 32.47,59.98 32.51,60.01
B+ on BOTTOM (solid shape): 296.01,56.03 296.01,52.34 295.63,51.96 294.74,51.96 294.53,51.75 294.53,48.8 294.48,48.76 290.76,48.76 290.55,48.96 290.55,51.33 290.81,51.59 291.83,52.34 292.58,53.36 292.71,53.49 292.71,53.62 293.03,54.72 293.05,55.86 293.34,56.15 295.88,56.15
B+ on BOTTOM (solid shape): 48.05,39.33 48.05,38.67 47.3,37.93 47.3,31.89 47.07,31.66 47.07,30.48 46.76,30.17 46.21,30.17 45.89,29.84 45.89,26.61 45.81,26.54 45.41,26.54 45.29,26.66 45.29,27.21 44.93,27.57 44.58,27.21 44.58,26.67 44.44,26.54 42.97,26.54 42.92,26.59 42.92,32.21 42.65,32.48 41.69,32.48 41.55,32.62 41.55,33.97 41.24,34.28 36.96,34.28 36.81,34.43 36.81,35.04 37.74,35.04 37.74,35.04 37.74,36.44 38.09,36.79 40.64,36.79 40.8,36.94 40.8,37.64 40.88,37.71 44.16,37.71 44.59,38.14 44.59,39.31 44.78,39.5 47.87,39.5
B+ on IN3 (solid shape): 108.25,16.13 108.25,15.59 108.2,15.53 106.8,15.53 106.71,15.62 106.71,16.13 106.83,16.25 108.14,16.25
B+ on IN3 (solid shape): 131.48,75.71 131.48,72.54 131.29,72.35 129.26,72.35 128.69,72.92 128.69,75.77 128.94,76.03 131.16,76.03
B+ on IN3 (solid shape): 203.55,35.34 203.55,34.16 203.36,33.97 201.62,33.97 201.3,34.29 201.3,34.71 202.25,35.67 203.22,35.67
B+ on IN3 (solid shape): 33.62,55.6 33.62,54.68 33.41,54.48 33.31,54.48 32.69,55.1 32.12,55.1 31.75,55.47 31.75,55.92 31.89,56.06 33.16,56.06
B+ on IN3 (solid shape): 120.05,25.42 120.05,24.69 120.37,24.38 120.73,24.38 120.83,24.27 120.83,23.72 120.73,23.62 120.73,23.53 120.59,23.39 118.99,23.39 118.05,24.33 118.05,26.05 118.32,26.33 119.14,26.33
B+ on IN3 (solid shape): 32.82,59.95 32.91,59.77 33.1,59.67 33.11,59.66 33.36,59.66 33.63,59.4 33.63,58.44 33.63,58.44 32.41,58.44 32.39,58.46 32.39,58.47 32.33,58.53 32.33,60.01 32.45,60.13 32.64,60.13
B+ on IN3 (solid shape): 69.02,74.58 69.02,73.93 68.81,73.72 65.65,73.72 65.35,74.02 65.35,74.07 65.39,74.15 65.47,74.17 65.87,74.49 65.47,74.81 65.39,74.83 65.35,74.91 65.35,75.37 65.49,75.5 68.1,75.5
B+ on IN1: 39.4,36.18 41.85,36.18 42.74,35.3 42.81,35.3 42.88,35.23 45.57,35.23 46.04,34.75 46.04,34.75 46.59,34.2 46.59,30.93 46.21,30.55 43.51,30.55 42.49,31.58 42.4,31.58 41.41,32.56 39.57,32.56 39.08,33.04 39.08,35.87
B+ on IN1: 95.48,72.92 97,72.92 97.13,72.79 97.13,69.85 96.7,69.42 89,69.42 88.68,69.74 88.68,72.73 88.87,72.92 90.08,72.92 91.03,71.96 94.53,71.96
B+ on IN2: 39.78,30.63 36.68,33.72 36.68,42.36 38.81,44.5 38.81,48.03 39.88,49.09 39.88,51.66 40.17,51.95 40.17,51.96 40.54,52.33 40.54,53.31 41.27,54.04 41.27,54.26 42.25,55.24 42.25,56.65 43.22,57.61 43.22,63.32 44.72,64.81 44.96,64.81 46.81,66.67 46.81,68.24 48.82,70.25 50.77,70.25 50.77,70.25 51.28,70.25 52.65,71.62 58.49,71.62 59.01,71.1 62.42,71.1 65.26,73.95 65.26,75.06 65.38,75.18 87.57,75.18 88.04,75.65 89.56,75.65 90.15,75.05 93.18,73.14 95.74,75.65 131.16,75.65 131.36,75.46 131.36,70.19 129.7,68.54 129.7,65.17 128.69,64.15 102.02,64.15 101.76,64.41 101.76,69.36 100.37,70.76 98.08,70.76 96.68,69.36 89.32,69.36 87.92,70.76 84.75,70.76 83.07,69.08 82.55,69.08 82.26,68.79 82.26,64.27 81.32,63.33 79.51,63.33 79.49,63.35 76.78,63.35 74.95,61.53 50.96,61.53 49.61,60.18 49.61,56.67 51.14,55.14 51.14,36.35 46.77,31.98 46.77,31.51 45.88,30.63
B+ on IN2: 31.74,54.68 31.5,54.91 31.5,55.57 31.52,55.58 31.52,56.01 31.93,56.42 31.93,57.47 31.52,57.88 31.52,62.67 31.75,62.91 31.75,64.47 33.36,66.08 33.36,67.66 33.79,68.09 33.79,70.66 33.6,70.85 33.6,72.18 34.13,72.7 35.13,72.7 36.02,71.81 36.05,71.81 36.4,71.47 36.4,65.94 33.73,63.28 33.73,60.76 34.02,60.47 34.02,55.14 33.57,54.68
B+ on VCC: outline of 176 points within 31.79,9.38 301.47,75.71
B+ on VCC: 37.35,71.72 34.43,71.72 34.33,71.82 34.33,75.87 34.36,75.9 38.29,75.9 42.48,71.7 43.25,71.7 43.88,71.07 48.08,71.07 48.81,70.34 48.81,68.27 48.56,68.02 41.04,68.02
B+ on GND3: 88.72,69.36 88.49,69.59 88.49,72.81 88.85,73.17 97.02,73.17 97.13,73.07 97.13,69.72 96.77,69.36
B+ on IN3: 88.81,72.92 90.77,72.92 91.2,72.48 94.58,72.48 95.01,72.92 96.94,72.92 97.07,72.79 97.07,71.27 96.81,71.01 88.94,71.01 88.68,71.27 88.68,72.79
B+ on IN3: 40.8,36.98 41.06,36.98 42.46,35.58 45.38,35.58 46.27,34.69 46.27,30.75 45.88,30.37 43.34,30.37 42.96,30.75 42.96,32.15 42.71,32.4 41.69,32.4 41.57,32.53 41.57,33.93 40.93,34.56 39.66,34.56 39.03,35.2 39.03,35.83 39.66,36.47 40.3,36.47
B+ on IN3: 125.51,75.84 128.56,75.84 128.69,75.71 128.69,74.31 128.56,74.19 125.39,74.19 125.26,74.31 125.26,75.58
B+_1.0V on BOTTOM (solid shape): 126.5,54.04 126.5,53.63 126.62,53.5 127.59,53.5 127.67,53.42 127.67,52.01 127.65,51.99 125.32,51.99 125.22,52.09 125.22,52.76 125.02,52.96 124.45,52.96 124.45,52.96 123.07,52.96 122.98,53.05 122.98,54.66 123.01,54.69 125.84,54.69
B+_1.2V_DDR on TOP: 48.81,27.7 49.44,27.7 49.57,27.83 49.57,29.66 49.5,29.72 48.78,29.72 48.66,29.6 48.66,27.86
B+_1.2V_DDR on BOTTOM: 47.65,31.68 49.4,31.68 49.62,31.47 49.62,27.79 49.48,27.66 49.06,27.66 48.88,27.48 48.88,25.13 48.87,25.13 48.47,25.13 48.47,25.13 48.47,27.08 47.84,27.71 47.84,28.7 48.02,28.89 48.38,28.89 48.65,29.15 48.65,30 48.4,30.25 47.62,30.25 47.62,31.64
B+_1.2V_DDR on IN1: 49.51,29.69 49.64,29.56 49.64,27.95 49.5,27.8 48.83,27.8 48.69,27.95 48.69,29.5 48.88,29.69
B+_1.2V_DDR on IN3: 48.86,27.72 48.74,27.84 48.74,29.51 48.9,29.67 49.46,29.67 49.64,29.49 49.64,27.84 49.52,27.72
B+_1.8VPRIM on BOTTOM (solid shape): 119.28,24.74 119.28,22.84 119.21,22.77 116.06,22.77 115.54,23.29 114.31,23.29 114.25,23.35 114.25,23.58 114.3,23.63 115.46,23.63 116.64,24.81 119.21,24.81
BST_1.0V on BOTTOM (solid shape): 125.02,56.32 125.02,55.75 124.99,55.71 124.59,55.71 123.76,54.88 123.03,54.88 122.98,54.93 122.98,55.12 124.22,56.36 124.97,56.36
BST_1.2V_DDR on TOP (solid shape): 48.31,23.24 48.31,22.06 48.29,22.03 47.14,22.03 47.05,22.12 47.05,23.27 47.17,23.38 48.17,23.38
BST_1.2V_DDR on BOTTOM: 47.5,23.6 48.19,23.6 48.27,23.52 48.27,22.87 47.52,22.11 47.18,22.11 47.05,22.25 47.05,23.15
BST_CORE1 on BOTTOM (solid shape): 77.7,76.16 77.7,75.65 77.57,75.52 76.94,75.52 76.43,75.01 76.43,74.42 76.33,74.31 75.65,74.31 75.63,74.34 75.63,75.16 75.92,75.46 76.11,75.46 76.94,76.28 77.57,76.28
BST_CORE2 on BOTTOM (solid shape): 110.13,71.28 110.13,70.49 110.06,70.41 109.74,70.41 108.81,69.49 108.24,69.49 108.18,69.55 108.18,70.12 108.24,70.19 108.81,70.19 109.26,70.63 109.26,71.2 109.38,71.33 110.08,71.33
BST_GT on BOTTOM (solid shape): 46.16,52 46.16,51.41 46.05,51.3 45.35,51.3 45.15,51.1 44.59,51.1 44.35,50.86 44.35,50.54 44.39,50.5 44.78,50.5 44.8,50.48 44.8,50.3 44.77,50.26 44.11,50.26 44.08,50.29 44.08,51.25 44.41,51.59 44.67,51.59 45.15,52.08 46.08,52.08
BST_PRIM_CORE on BOTTOM (solid shape): 125.75,47.88 125.94,47.88 126.01,47.82 126.01,47.67 125.95,47.61 125.18,47.61 124.54,48.24 124.07,48.24 124.01,48.3 124.01,48.84 124.04,48.88 124.76,48.88
BST_SA on BOTTOM (solid shape): 130.83,65.47 131.73,65.47 131.76,65.43 131.76,64.83 131.71,64.78 130.7,64.78 130.4,65.09 129.48,65.09 129.42,65.14 129.42,65.77 129.45,65.79 130.5,65.79
BST_VCCIO on BOTTOM (solid shape): 106.05,21.91 106.05,20.65 105.49,20.1 104.9,20.1 104.82,20.02 104.82,20.01 104.74,19.93 104.74,19.45 104.66,19.37 104.54,19.37 104.45,19.46 104.45,20.46 104.63,20.63 105.16,20.63 105.37,20.85 105.37,21.89 105.48,22 105.96,22
CHG_ADP on TOP: 26.94,19.39 25.36,20.97 24.75,20.97 24.61,21.1 24.61,21.65 24.42,21.84 23.03,21.84 22.93,21.95 22.93,23.04 23,23.11 24.68,23.11 24.87,22.92 24.87,22.35 26.9,20.32 27.16,20.32 27.25,20.23 27.25,19.45 27.19,19.39
CHG_BST1 on TOP (solid shape): 29.56,22.75 29.56,21.58 28.9,20.92 28.9,19.33 28.87,19.3 28.62,19.3 28.58,19.34 28.58,21.71 28.59,21.71 28.59,22.73 28.74,22.88 29.44,22.88
CHG_BST2 on TOP: 30.27,17.61 31.93,17.61 32.71,18.39 32.91,18.39 33.16,18.64 33.16,18.78 33.22,18.83 33.81,18.83 33.86,18.78 33.86,17.83 33.78,17.74 32.75,17.74 32.39,17.39 30.3,17.39 30.24,17.45 30.24,17.58
CHG_DCIN on TOP (solid shape): 22.71,21.55 22.71,20.91 22.79,20.82 23.6,20.82 23.72,20.7 25.38,20.7 26.83,19.25 26.83,19.06 26.78,19 26.06,19 25.04,20.02 23.15,20.02 22.9,19.77 21.63,19.77 21.5,19.89 21.5,21.48 21.6,21.59 22.67,21.59
CHG_LG1 on IN3 (solid shape): 17.69,30.5 17.69,26.82 16.67,26.82 16.67,30.5 16.8,30.63 17.56,30.63
CHG_LG1 on IN3 (solid shape): 31.12,20.37 31.12,20 30.43,19.31 27.44,19.31 27.38,19.38 27.38,20.04 27.47,20.14 30.23,20.14 30.64,20.55 30.94,20.55
CHG_LG1 on TOP: 30.32,20.22 30.67,20.58 30.82,20.58 31.05,20.35 31.05,20.22 30.85,20.02 30.85,19.77 30.67,19.59 30.14,19.59 30.09,19.54 30.09,19.33 30.06,19.31 29.86,19.31 29.83,19.34 29.83,20.17 29.89,20.22
CHG_LG2 on IN3 (solid shape): 33,20.32 33,19.82 32.63,19.46 31.73,19.46 31.63,19.57 31.63,20.27 31.73,20.38 32.93,20.38
CHG_LG2 on IN3 (solid shape): 37.29,30.76 37.37,30.68 37.37,29.9 37.3,29.84 36.31,29.84 36.25,29.9 36.25,30.66 36.35,30.76 37.16,30.76
CHG_LG2 on TOP: 30.24,18.57 30.19,18.62 30.19,18.8 30.24,18.85 31.05,18.85 31.51,19.31 31.51,19.68 31.74,19.91 32.57,19.91 32.68,19.81 32.68,19.62 32.49,19.43 32.06,19.43 31.21,18.57
CHG_LX1 on TOP (solid shape): 25.82,32.59 25.82,30.86 25.75,30.79 23.73,30.79 23.66,30.86 23.66,32.51 23.79,32.65 25.77,32.65
CHG_LX1 on TOP (solid shape): 32.02,21.43 32.02,20.8 31.92,20.7 30.59,20.7 30.24,20.35 29.86,20.35 29.73,20.22 29.73,19.38 29.63,19.28 29.53,19.28 29.45,19.36 29.45,20.38 29.91,20.83 30.09,21.01 30.56,21.48 31.96,21.48
CHG_LX1 on BOTTOM (solid shape): 26.62,35.74 26.62,29.14 26.47,28.99 22.88,28.99 21.48,30.39 16.95,30.39 16.81,30.54 16.81,33.25 16.85,33.29 21.56,33.29 21.99,33.72 21.99,35.43 22.46,35.9 26.46,35.9
CHG_LX1 on IN1 (solid shape): 25.42,31.36 25.42,30.13 25.32,30.03 24.24,30.03 24.14,30.13 24.14,31.26 24.34,31.46 25.32,31.46
CHG_LX1 on IN1 (solid shape): 30.97,22.29 30.97,20.9 30.73,20.67 30.49,20.67 30.21,20.39 30.05,20.39 29.87,20.57 29.87,20.72 30.11,20.96 30.11,21.7 29.94,21.87 29.94,22.28 30,22.35 30.91,22.35
CHG_LX2 on TOP (solid shape): 35.97,32.84 35.97,32.12 35.7,31.86 33.5,31.86 33.19,32.17 33.19,33.14 33.55,33.5 35.31,33.5
CHG_LX2 on BOTTOM (solid shape): 36.1,36.09 36.1,34.35 36.5,33.95 40.77,33.95 40.93,33.79 40.93,31.27 40.87,31.21 36.25,31.21 36,30.96 36,28.98 35.92,28.9 31.5,28.9 31.34,29.06 31.34,36.27 31.79,36.72 35.47,36.72
CHG_LX2 on IN1 (solid shape): 36.04,32.94 36.04,32.07 35.87,31.9 34.36,31.9 34.17,32.09 34.17,33.01 34.36,33.2 35.79,33.2
CHG_LX2 on IN1 (solid shape): 33.71,19.2 33.71,18.7 33.59,18.59 32.72,18.59 32.45,18.86 32.19,18.86 32.06,18.99 32.06,19.24 32.16,19.34 33.57,19.34
CHG_LX2 on TOP: 30.21,18.44 31.28,18.44 32.12,19.28 32.72,19.28 32.84,19.41 32.84,19.86 33.06,20.08 33.81,20.08 33.88,20.01 33.88,19.15 33.82,19.09 33.16,19.09 33.04,18.97 33.04,18.72 32.9,18.59 32.72,18.59 32.46,18.85 32.15,18.85 31.46,18.17 30.24,18.17 30.16,18.24 30.16,18.39
CHG_UG1 on IN1 (solid shape): 29.95,21.22 29.95,21.06 29.36,20.46 28.94,20.46 28.01,21.4 28.01,22.29 28.07,22.35 28.83,22.35
CHG_UG1 on TOP: 29.58,21.37 29.81,21.37 29.96,21.21 29.96,21.06 29.33,20.43 29.3,20.4 29.3,19.33 29.28,19.3 29.04,19.3 29.01,19.33 29.01,20.8
CHG_UG1 on IN1: 15.63,32.64 15.53,32.75 15.53,33.52 15.73,33.72 16.27,33.72 16.68,34.14 16.68,34.35 16.85,34.51 17.37,34.51 17.56,34.32 17.56,33.74 16.47,32.64
CHG_UG2 on IN1 (solid shape): 32.7,18.3 33.42,18.3 33.57,18.15 33.57,17.4 33.52,17.35 31.64,17.35 31.55,17.45 31.55,18.14 32.06,18.65 32.35,18.65
CHG_UG2 on IN3 (solid shape): 37.1,36.79 37.1,35.95 37.01,35.87 35.99,35.87 35.92,35.93 35.92,36.78 35.99,36.84 37.04,36.84
CHG_UG2 on TOP: 32.12,18.65 32.37,18.65 32.5,18.52 32.5,18.37 31.89,17.76 30.24,17.76 30.19,17.81 30.19,18.01 30.21,18.04 31.51,18.04
CHG_VIN_20V on BOTTOM: 20.93,41.06 22.84,41.06 23.17,41.4 24.05,41.4 24.11,41.34 24.11,38.32 23.96,38.18 21.24,38.18 21.16,38.26 21.16,38.73 21.23,38.8 21.9,38.8 22.09,38.99 22.09,39.36 21.9,39.56 21.23,39.56 20.75,40.04 20.75,40.88
GT_B+ on BOTTOM (solid shape): outline of 93 points within 32.79,45.87 46.16,57.95
IA1_B+ on TOP (solid shape): 74.27,73.5 74.27,72.98 74.14,72.85 72.3,72.85 72.11,72.66 71.85,72.66 71.66,72.86 71.66,73.49 71.73,73.57 74.21,73.57
IA1_B+ on BOTTOM (solid shape): 68.28,74.96 68.28,74.62 68.46,74.44 72.05,74.44 72.43,74.06 76.55,74.06 76.75,74.25 77.57,74.25 77.63,74.19 77.63,73.81 77.44,73.62 74.52,73.62 74.14,73.23 72.68,73.23 72.36,72.92 72.36,72.67 72.24,72.55 71.24,72.55 71.12,72.42 69.81,72.42 69.81,72.41 69.65,72.24 69.65,67.73 68.2,66.29 65.49,66.29 65.44,66.34 65.44,69.3 66.17,70.04 66.17,72.65 67.06,73.54 67.06,75 67.07,75.01 68.22,75.01
IA1_B+ on IN1 (solid shape): 73.28,73.82 74.5,73.82 74.71,73.62 74.71,73.14 74.4,72.82 71.51,72.82 71.22,73.11 71.22,73.72 71.3,73.79 72.05,73.79 72.33,74.07 73.04,74.07
IA1_B+ on IN2 (solid shape): 72.14,73.63 72.14,73.36 71.96,73.18 71.39,73.18 70.69,73.88 70.69,74.07 70.88,74.26 71.51,74.26
IA1_B+ on IN3 (solid shape): 74.66,73.69 74.66,73.36 74.51,73.21 72.3,73.21 71.91,72.82 71.38,72.82 71.22,72.98 71.22,73.75 71.32,73.86 74.5,73.86
IA2_B+ on TOP (solid shape): 114.78,72.66 114.78,71.9 114.59,71.71 111.61,71.71 111.42,71.9 111.42,72.66 111.54,72.79 114.65,72.79
IA2_B+ on BOTTOM (solid shape): 126.1,74.5 126.1,70.83 125.13,69.87 122.27,69.87 122.05,70.09 116.47,70.09 115.85,70.71 113.91,70.71 113.09,71.52 109.26,71.52 109.07,71.33 108.24,71.33 108.18,71.39 108.18,71.86 108.22,71.9 111.04,71.9 111.48,72.35 113.13,72.35 113.58,72.79 115.73,72.79 115.99,73.04 115.99,73.3 116.12,73.42 118.08,73.42 118.53,73.87 122.45,73.87 122.62,74.04 122.62,74.62 122.67,74.67 125.93,74.67
IA2_B+ on IN1 (solid shape): 116.05,72.03 116.05,71.52 115.8,71.27 111.75,71.27 111.58,71.43 111.58,71.85 111.82,72.09 115.99,72.09
IA2_B+ on IN3 (solid shape): 113.17,72.14 113.17,71.66 113.03,71.52 111.52,71.52 111.38,71.65 111.38,72.14 111.48,72.23 113.08,72.23
LDO_1.0V on BOTTOM (solid shape): 121.61,56.58 121.61,56.17 121.54,56.1 121.54,55.3 121.46,55.21 120.96,55.21 120.9,55.21 120.07,56.05 120.07,57.38 120.14,57.46 120.74,57.46
LX_1.0V on BOTTOM (solid shape): 125.13,58.17 125.13,56.54 125.1,56.5 123.88,56.5 122.94,55.56 122.94,55.33 122.83,55.21 122.83,53.02 122.91,52.94 122.91,52.16 122.86,52.11 122.7,52.11 122.63,52.19 122.63,52.96 122.55,53.04 122.55,54.92 122.18,55.29 122.18,56.19 121.77,56.6 121.77,58.25 121.85,58.34 124.97,58.34
LX_1.0V on TOP: 123.48,56.66 123.54,56.6 124.81,56.6 124.99,56.78 124.99,57.82 124.78,58.03 123.58,58.03 123.48,57.93
LX_1.2V_DDR on TOP (solid shape): 48.42,21.7 48.42,19.77 48.28,19.62 47.18,19.62 47,19.8 47,21.66 47.13,21.79 48.33,21.79
LX_1.2V_DDR on BOTTOM (solid shape): 50.07,21.87 50.36,21.58 50.36,19.59 50.29,19.51 46.49,19.51 46.4,19.61 46.4,21.6 46.47,21.67 47.29,21.67 48.72,23.09 48.72,24.8 48.76,24.85 50.07,24.85
LX_1.8VPRIM on BOTTOM (solid shape): 113.17,25.75 113.17,24.09 112.81,23.73 112.81,23.38 113.05,23.14 114.56,23.14 114.67,23.03 114.67,22.9 114.59,22.83 113.17,22.83 112.92,22.57 111.84,22.57 111.68,22.41 111.68,21.52 111.47,21.31 110.82,21.31 110.46,20.94 109.43,20.94 109.4,20.98 109.4,21.75 108.84,22.31 108.84,23.65 108.96,23.76 112.05,23.76 112.48,24.2 112.48,25.72 112.56,25.8 113.12,25.8
LX_CORE1 on TOP (solid shape): 81.35,74.7 81.35,73.34 81.03,73.01 79.43,73.01 79.43,73.01 79.19,73.24 79.19,74.91 79.39,75.12 80.94,75.12
LX_CORE1 on BOTTOM (solid shape): 81.34,76.13 81.34,70.32 81.04,70.02 78.92,70.02 78.54,70.4 78.3,70.4 77.15,71.56 74.9,71.56 74.71,71.75 74.71,73.36 74.84,73.49 77.57,73.49 77.95,73.87 77.95,76.17 78.08,76.3 81.17,76.3
LX_CORE1 on IN1 (solid shape): 81.1,75.51 81.1,74.44 80.93,74.27 79.09,74.27 78.91,74.45 78.91,75.41 79.16,75.67 80.95,75.67
LX_CORE2 on TOP (solid shape): 107.33,70.81 107.33,69.08 107.1,68.85 106.82,68.85 106.39,68.42 105.52,68.42 105.45,68.5 105.45,70.86 105.6,71.01 107.12,71.01
LX_CORE2 on BOTTOM (solid shape): 107.8,75.09 107.8,74.06 107.99,73.87 109.26,73.87 109.45,74.06 110.91,74.06 111.01,73.96 111.01,72.26 110.91,72.15 108.24,72.15 107.9,71.81 107.9,69.55 107.86,69.51 107.05,69.51 106.72,69.84 103.83,69.84 103.59,70.08 103.59,75.38 103.69,75.48 107.4,75.48
LX_GT on TOP (solid shape): 45.83,49.19 45.83,48.58 45.6,48.35 45.22,48.35 44.88,48.01 44.88,46.69 44.61,46.42 43.28,46.42 43.15,46.55 43.15,48.88 43.15,48.88 43.15,49.11 43.26,49.23 43.27,49.23 43.46,49.42 45.6,49.42
LX_GT on BOTTOM (solid shape): 47.48,51.92 47.48,49.58 47.75,49.31 48.04,49.31 48.38,48.97 48.38,45.08 48.23,44.93 45.42,44.93 45.34,45.02 45.34,47.07 44.82,47.59 43.25,47.59 43.16,47.68 43.16,49.4 43.24,49.48 46.35,49.48 46.52,49.65 46.52,52.03 46.57,52.08 47.32,52.08
LX_PRIM_CORE on BOTTOM (solid shape): 123.04,49.27 123.04,49.02 123.17,48.89 123.75,48.89 123.82,48.83 123.82,48.26 124.02,48.06 124.37,48.06 125.04,47.39 126.77,47.39 126.82,47.35 126.82,47.15 126.77,47.11 125.06,47.11 124.65,46.69 121.73,46.69 121.66,46.76 121.66,49.23 121.85,49.42 122.89,49.42
LX_SA on TOP (solid shape): 129.33,64.17 129.33,62.89 129.23,62.79 127.81,62.79 127.71,62.88 127.71,64.21 127.78,64.28 129.22,64.28
LX_SA on BOTTOM (solid shape): 128.63,66.6 128.63,63.92 128.89,63.67 130.4,63.67 130.84,64.1 131.7,64.1 131.76,64.04 131.76,61.29 131.57,61.1 127.09,61.1 126.94,61.25 126.94,63.11 127.29,63.46 127.29,66.57 127.4,66.68 128.55,66.68
LX_VCCIO on BOTTOM (solid shape): 106.08,22.77 106.08,22.27 105.99,22.17 105.28,22.17 105.17,22.07 105.17,20.94 105.06,20.83 104.49,20.83 104.23,20.57 104.23,18.64 104.16,18.57 104.04,18.57 103.95,18.66 103.95,20.64 103.75,20.85 102.3,20.85 102.23,20.91 102.23,21.51 101.89,21.86 101.18,21.86 101.13,21.91 101.13,21.96 101.01,22.08 101.01,22.78 101.05,22.82 106.03,22.82
Net_137 on BOTTOM (solid shape): 281.9,49.29 271.9,49.29 271.9,64.29 281.9,64.29
Net_148 on BOTTOM (solid shape): 260.58,45.17 252.58,45.17 252.58,53.17 260.58,53.17
Net_149 on BOTTOM (solid shape): 270.23,54.82 262.23,54.82 262.23,62.82 270.23,62.82
PD1_LPS2 on BOTTOM (solid shape): 14.08,48.72 14.08,43.13 13.93,42.98 11.76,42.98 11.63,43.1 11.63,45.51 11.26,45.88 11.26,48.69 11.38,48.81 13.99,48.81
PD2_LPS2 on BOTTOM (solid shape): 13.15,61.61 13.6,61.61 13.81,61.4 13.81,59.41 13.71,59.31 12.59,59.31 12.36,59.07 12.36,55.77 12.1,55.52 9.94,55.52 9.69,55.77 9.69,58.95 10.83,60.09 10.83,61.68 10.95,61.8 12.97,61.8
PWM_CORE2 on BOTTOM (solid shape): 113,71.27 113,69.93 112.94,69.87 112.43,69.87 112.31,70 112.31,71.33 112.94,71.33
RING2 on TOP (solid shape): 288.09,23.47 288.09,23.23 288,23.13 287.72,23.13 287.13,23.72 286.17,23.72 286.1,23.79 286.1,23.88 286.15,23.93 287.01,23.93 287.03,23.96 287.61,23.96
RING2 on TOP (solid shape): 292.98,21.79 292.98,21.15 292.89,21.06 292.49,21.06 292.2,21.35 291.72,21.35 291.62,21.25 291.62,21.08 291.26,20.72 289.39,20.72 289.26,20.85 289.26,21.12 289.26,21.12 289.26,21.21 289.91,21.86 292.9,21.86
RING2 on BOTTOM (solid shape): 291.57,21.74 291.57,20.72 291.44,20.59 290.55,20.59 290.42,20.72 290.42,21.74 290.55,21.86 291.44,21.86
RING2 on IN2 (solid shape): 291.64,21.77 291.64,20.73 291.51,20.61 289.91,20.61 289.77,20.74 289.77,21.79 289.85,21.86 291.54,21.86
RING2 on IN2 (solid shape): 289.24,23.89 289.24,22.99 289.12,22.87 287.33,22.87 287.18,23.02 287.18,23.86 287.35,24.03 289.09,24.03
RING2_CONN on TOP (solid shape): 311.96,22.52 311.96,21.98 311.96,21.98 311.69,21.71 310.43,21.71 310.16,21.98 310.16,22.09 308.23,24.02 305.87,24.02 305.6,24.29 305.6,24.78 309.7,24.78
RING2_CONN on IN1 (solid shape): 294.23,22.12 294.23,20.85 294.11,20.72 293.34,20.72 293.09,20.97 293.09,22.12 293.22,22.24 294.11,22.24
RING2_CONN on IN1 (solid shape): 307.19,24.66 307.19,23.77 307.06,23.64 305.79,23.64 305.54,23.89 305.54,24.53 305.79,24.78 307.06,24.78
RING2_CONN on TOP: 293.31,20.5 293.42,20.39 294.61,20.39 294.74,20.52 294.74,21.76 294.64,21.86 293.38,21.86 293.31,21.79
RING2_CONN on IN3: 294.36,24.78 306.68,24.78 306.93,24.53 306.93,23.51 306.55,23.13 302.49,23.13 301.98,23.64 295.12,23.64 294.23,22.75 294.23,21.1 293.85,20.72 293.22,20.72 292.96,20.97 292.96,23.39
SA_B+ on BOTTOM (solid shape): 131.61,71.65 131.61,70.76 131.48,70.62 131.23,70.62 130.82,70.21 130.82,69.25 130.7,69.12 129.48,69.12 129.19,68.83 129.19,64.75 129.34,64.6 129.53,64.6 129.62,64.52 129.62,63.91 129.6,63.9 128.83,63.9 128.8,63.92 128.8,66.83 128.67,66.97 128.67,68.87 128.56,68.98 128.56,71.65 128.69,71.77 131.48,71.77
SA_B+ on IN1 (solid shape): 129.2,68.52 129.2,67.03 129.12,66.95 128.55,66.95 128.45,67.05 128.45,68.52 128.54,68.6 129.12,68.6
SA_B+ on IN3 (solid shape): 129.28,68.63 129.28,67.03 129.22,66.97 128.74,66.97 128.59,67.12 128.59,68.6 128.67,68.68 129.23,68.68
SD_REG2 on TOP: 295.55,37.66 295.56,37.66 295.84,37.94 296.88,37.94 297.24,37.58 297.24,36.7 297.17,36.63 296.77,36.63 296.68,36.72 296.68,37.07 296.53,37.23 296.35,37.23 295.92,36.79 295.92,36.79 295.69,36.56 294.77,36.56 294.69,36.64 294.69,36.79
SLEEVE on TOP: 288.94,21.98 288.94,22 288.83,22.11 288.83,22.56 288.24,23.15 288.24,23.51 287.64,24.11 286.18,24.11 286.1,24.19 286.1,24.27 286.17,24.34 288.18,24.34 289.26,23.26 292.84,23.26 292.96,23.13 292.96,22.5 292.92,22.46 292.42,22.46 292.25,22.62 290.17,22.62 289.52,21.98
SLEEVE_CONN on TOP: 293.4,22.12 294.75,22.12 294.87,22.23 294.87,23.12 294.73,23.26 293.42,23.26 293.31,23.15 293.31,22.21
SLEEVE_CONN on TOP: 303.48,24.99 304.95,24.99 305.18,24.76 305.18,24.35 305.79,23.74 306.46,23.74 306.46,22.73 305.35,22.73 304.35,23.72 303.66,23.72 303.44,23.93 303.44,24.95
SLEEVE_CONN on IN1: 294.36,24.78 304.01,24.78 304.27,24.53 304.27,23.89 304.01,23.64 295.12,23.64 293.98,22.5 293.34,22.5 293.22,22.62 293.22,23.64
SNUB_1.0V on TOP: 123.41,59.58 121.96,59.58 121.75,59.38 121.75,56.64 121.82,56.57 123.08,56.57 123.23,56.72 123.23,58.04 123.53,58.35 123.53,59.46
SNUB_GT on TOP (solid shape): 46.51,47.98 46.51,46.34 46.4,46.23 46.4,45.12 46.28,45 45.57,45 45.4,45.17 45.4,48.03 45.55,48.18 46.31,48.18
SNUB_SA on TOP (solid shape): 127,64.24 127,61.8 126.84,61.64 126.11,61.64 125.96,61.78 125.96,64.24 126.12,64.4 126.84,64.4
SPK-L+ on TOP (solid shape): 283.81,29.52 283.81,26.68 283.75,26.62 283.63,26.62 283.58,26.67 283.58,28.13 283.34,28.37 283.34,29.51 283.46,29.62 283.71,29.62
SPK-L+ on IN1 (solid shape): 283.84,29.53 283.84,29 283.84,28.45 284.13,28.17 284.13,27.17 283.35,26.39 283.09,26.39 282.88,26.6 282.88,27.43 282.88,27.43 283.34,27.89 283.34,29.53 283.43,29.61 283.76,29.61
SPK-L+ on TOP: 296.35,11.21 296.31,11.25 296.31,12.49 296.48,12.66 297.41,12.66 297.53,12.53 297.53,12.52 297.58,12.47 297.58,11.32 297.47,11.21
SPK-L+ on IN1: 296.26,12.82 297.47,12.82 297.66,12.63 297.66,11.55 297.48,11.37 296.43,11.37 296.26,11.54
SPK-L- on TOP (solid shape): 283.23,29.54 283.23,28.33 283.4,28.16 283.4,26.69 283.34,26.62 283.25,26.62 283.2,26.67 283.2,26.76 283.2,26.76 283.2,28.01 282.71,28.51 282.71,29.54 282.81,29.64 283.12,29.64
SPK-L- on IN1 (solid shape): 283.23,29.56 283.23,27.99 282.79,27.55 282.03,27.55 281.87,27.72 281.87,28.4 282.04,28.58 282.58,28.58 282.71,28.7 282.71,29.56 282.8,29.65 283.14,29.65
SPK-L- on TOP: 294.49,12.66 295.5,12.66 295.63,12.53 295.63,11.3 295.52,11.2 294.56,11.2 294.36,11.39 294.36,12.53
SPK-L- on IN1: 294.35,11.5 294.35,13.15 295.03,13.15 295.65,12.54 295.65,11.55 295.24,11.15 294.69,11.15
SPK-R+ on TOP (solid shape): 281.97,29.65 281.97,28.44 282.61,27.8 282.61,26.68 282.56,26.63 282.46,26.63 282.39,26.69 282.39,27.6 281.48,28.52 281.48,29.65 281.58,29.74 281.87,29.74
SPK-R+ on IN2 (solid shape): 292.01,12.51 292.01,11.58 291.78,11.35 290.84,11.35 290.71,11.47 290.71,12.49 290.87,12.65 291.87,12.65
SPK-R+ on IN2 (solid shape): 281.97,29.66 281.97,28.41 281.82,28.26 280.77,28.26 280.46,28.57 280.46,29.14 281.12,29.79 281.83,29.79
