# Allegro board LAG441PR10-1221_GCR.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PRX_DTX_P10: length 99.3
  IN1 w0.074: v4(24.86,44.99) 24.8,44.99 24.63,45.16 24.63,45.29 24.75,45.41 24.94,45.41 25.31,45.03 25.31,44.74 25.65,44.41 27.26,44.41 27.69,44.83 29.14,44.83 29.65,45.34 29.65,55.72 29.52,55.85 29.52,58.16 32.03,60.66 32.31,60.66 34.31,62.67 34.31,62.95 39.3,67.93 45.41,67.93 45.53,67.88 47.44,66.46 48.18,66.04 49.07,65.68 49.69,65.47 49.72,65.46 50.25,65.43 50.83,65.42 51.48,65.33 51.87,65.24 53.07,64.81 53.71,64.49 54.16,64.19 54.65,63.71 55.24,63.48 56.12,63.3 57.44,62.83 58.41,62.52 58.41,62.52 59.37,62.18 59.78,62.01 60.32,61.77 60.35,61.75 60.64,61.63 61.01,61.53 61.87,61.37 65.25,61.37 65.36,61.47 66.99,61.47 67.09,61.37 72.16,61.37 72.56,61.77 73.66,61.77 73.86,61.58 75.11,61.58 75.59,62.06 79.86,62.06 84.04,57.88 84.77,57.88 86.51,56.15 94.2,56.15 96.9,53.45 96.9,53.33 96.82,53.26 96.51,53.26 96.42,53.16 96.42,52.68 96.51,52.59 96.78,52.59 96.85,52.66 v4(96.85,52.91)
  IN3 w0.074: v4(96.85,52.91) v5(96.61,52.68) ; v5(24.86,45.45) v4(24.86,44.99)
PCIE_PRX_DTX_P11: length 101.4
  IN1 w0.074: v4(22.63,45.12) 22.45,44.94 22.45,44.41 22.79,44.06 27.31,44.06 27.8,44.55 29.26,44.55 29.92,45.22 29.92,55.84 29.8,55.96 29.8,58.04 32.13,60.37 32.4,60.37 34.62,62.58 34.62,62.86 38.82,67.06 43.42,67.06 46.87,66.25 47.05,66.17 47.05,66.17 47.21,66.1 49.38,65.23 49.75,65.17 50.9,65.12 51.5,65.04 52.17,64.83 52.33,64.77 53.02,64.5 53.04,64.49 53.53,64.27 54.09,63.84 54.56,63.39 54.95,63.26 56,63.04 56.79,62.75 58.51,62.19 58.92,62.02 59.48,61.82 59.79,61.7 60.12,61.55 60.15,61.53 60.49,61.39 60.89,61.27 62.01,61.05 64.82,61.05 65.25,60.62 65.83,60.62 66.18,60.98 74.93,60.98 75.61,61.66 79.57,61.66 83.66,57.57 84.65,57.57 86.36,55.86 92.65,55.86 94.37,54.14 94.94,54.14 96.02,53.06 96.02,52.34 96.47,51.89 96.47,50.61 96.61,50.46 96.77,50.46 96.85,50.54 v4(96.85,50.96)
  IN3 w0.074: v5(96.61,50.73) v4(96.85,50.96) ; v5(22.63,45.45) v4(22.63,45.12)
PCIE_PRX_DTX_P12: length 101.1
  IN1 w0.074: v4(95.39,52.83) 95.21,52.83 95.14,52.75 95.14,52.46 95.05,52.38 94.89,52.38 94.72,52.55 94.72,53.08 92.42,55.38 85.45,55.38 83.97,56.87 83.68,56.87 79.46,61.08 75.73,61.08 75.15,60.5 66.42,60.5 66.04,60.12 65.05,60.12 64.63,60.53 61.97,60.53 61.14,60.69 60.33,60.94 59.86,61.13 58.66,61.59 57.65,61.94 56.73,62.23 55.84,62.57 54.45,62.86 54.14,63.11 54.13,63.12 53.91,63.3 53.9,63.31 53.4,63.72 53.23,63.88 52.7,64.1 51.65,64.48 51.39,64.57 50.89,64.62 49.51,64.69 49.15,64.79 47.31,65.52 46.82,65.73 42.94,66.58 40.38,66.58 38.92,65.13 38.09,65.13 36.62,63.65 36.62,62.19 34.65,60.22 34.65,57.5 33.49,56.34 32.59,56.34 32.45,56.49 31.46,56.49 30.42,55.45 30.42,45.04 29.46,44.08 28,44.08 27.5,43.58 21.13,43.58 20.22,44.49 20.22,44.94 v4(20.39,45.12)
  IN3 w0.074: v5(95.69,52.68) 95.53,52.68 v4(95.39,52.83) ; v5(20.39,45.45) v4(20.39,45.12)
PCIE_PRX_DTX_P13: length 175.3
  TOP w0.112: RN58.1 205.75,63.26 206.29,63.26 v6(206.48,63.07)
  IN3 w0.074: v6(206.48,63.07) 206.71,63.29 206.81,63.29 207.17,62.85 208.07,61.37 208.59,60.43 209.42,58.38 210.35,55.3 210.35,49.82 210.34,49.13 209.17,45.27 209.03,43.91 207.51,38.41 206.1,36.39 206.07,36.36 204.86,35.62 204.51,35.07 203.8,33.76 203.2,33.36 202.05,33.22 200.91,33.08 200.08,32.68 199.43,32.25 198.74,31.62 197.77,30.89 195.16,29.21 191.75,29.21 191.26,29.07 189.45,28.09 189.45,28.09 189.13,27.92 189.12,27.92 188.33,27.28 188.26,27.21 187.33,26.45 185.1,24.24 183.43,22.92 183.24,22.77 183.23,22.77 181.91,21.86 181.91,21.86 180.24,20.79 177.68,19.3 176.57,18.8 175.28,18.29 174.36,17.87 171.79,16.96 171.78,16.96 171.5,16.85 170.39,16.58 169.14,16.22 168.62,16.1 167.15,15.99 155.47,15.99 150.48,17.53 149.18,17.97 147.57,18.61 147,18.86 145.1,19.84 143.92,20.51 143.63,20.74 143.45,20.88 143.41,20.91 143.39,20.93 141.5,22.36 141.4,22.44 141.32,22.51 141.26,22.55 140.93,22.82 140.82,22.91 140.81,22.92 139.05,24.45 137.01,26.49 137,26.5 136.95,26.54 136.96,26.54 136.67,26.83 136.67,26.83 136.61,26.89 136.6,26.9 136.13,27.32 134.35,29.16 134.33,29.17 133.46,30.05 132.99,30.52 132.05,31.47 132.04,31.47 131.36,32 125.59,34.37 124.47,34.37 123.63,34.63 122.18,34.83 120.14,34.83 119.61,34.7 119,34.7 118.4,34.89 118.14,35.06 117.87,35.22 117.53,35.56 117.23,36.07 117.16,36.31 116.78,39.49 116.46,40.36 116.22,41.92 115.9,42.51 115.9,47.72 113.89,49.73 113.89,50.33 113.3,50.92 113.3,52.19 112.9,52.59 112.9,54.12 110.29,56.74 109.18,56.74 108.76,57.16 104.7,57.16 104.34,56.8 102.41,56.8 101.86,56.88 101.7,56.99 101.64,57.33 101.48,57.49 101.38,57.56 101.2,57.61 100.28,57.61 100.13,57.55 100.04,57.47 99.68,57.17 99.45,57.02 98.76,56.68 98.56,56.52 98.45,56.37 98.41,56.27 98.4,56.24 98.4,54.35 98.31,54.26 98.24,54.2 97.29,53.91 96.16,53.71 94.98,53.32 94.83,53.16 94.83,53.03 94.76,52.95 94.55,52.95 94.47,52.88 94.47,52.54 94.56,52.46 94.7,52.46 94.77,52.52 v5(94.77,52.68)
PCIE_PRX_DTX_P14: length 171.8
  TOP w0.112: v6(207.53,60.07) 207.33,60.27 205.74,60.27 RN60.1
  IN3 w0.074: v5(93.84,52.68) 93.72,52.68 93.64,52.61 93.64,52.41 93.72,52.33 94.02,52.33 94.11,52.42 94.11,53.35 94.45,53.83 95.99,54.59 96.94,55.54 96.94,56.64 97.7,57.39 99.09,57.39 99.31,57.5 99.31,57.51 99.49,57.65 99.75,57.9 100.05,58.09 101.77,58.09 102.15,58.47 104.15,58.47 104.89,57.73 108.98,57.73 109.4,57.31 110.45,57.31 113.52,54.23 113.52,52.79 113.8,52.51 113.8,51.09 114.37,50.52 114.37,49.93 116.38,47.92 116.38,42.95 116.93,42.4 116.93,40.92 118.51,39.34 120.34,39.34 120.81,39.18 122.78,37.21 124.94,37.21 127.52,34.62 128.07,34.62 128.38,34.31 129.07,34.31 130.09,33.29 130.4,33.29 131.4,32.68 131.52,32.6 131.91,32.28 132.99,31.2 133,31.19 139.37,24.8 141.13,23.28 141.56,22.93 143.67,21.31 143.73,21.27 143.74,21.26 143.9,21.14 144.15,20.98 144.27,20.9 145.22,20.33 145.22,20.33 146.34,19.76 147.11,19.34 148.67,18.7 149.95,18.23 150.78,17.97 151.17,17.82 151.81,17.62 152.46,17.42 152.46,17.42 154.58,16.77 157.14,16.47 166.93,16.47 169.44,16.87 171.76,17.45 173.24,17.98 173.95,18.28 174,18.3 174.03,18.31 174.08,18.33 174.1,18.34 175.97,19.15 176.63,19.41 177,19.57 178.2,20.18 179.37,20.84 181.24,22.01 182.62,22.93 183.49,23.64 185.81,25.8 187.27,27.24 189.38,28.67 191.14,29.54 191.84,29.73 195.04,29.73 197.68,31.51 198.34,32.05 199.11,33.82 200.61,35.32 200.67,35.38 201.32,35.38 204.41,38.47 205.16,38.47 205.9,39.22 205.9,39.93 207.75,41.78 207.75,47.14 209.83,49.22 209.83,55.36 208.23,59.98 207.92,60.29 207.75,60.29 v6(207.53,60.07)
PCIE_PRX_DTX_P15: length 171.5
  TOP w0.112: RN62.1 205.73,57.28 206.69,57.28 207.17,57.76 208.26,57.76 v6(208.44,57.57)
  IN3 w0.074: v5(92.92,52.03) 92.92,52.18 92.99,52.25 93.21,52.25 93.41,52.46 93.41,52.71 93.63,52.93 93.63,54.47 94.48,55.31 96.11,55.31 96.66,55.86 96.66,56.77 97.52,57.63 97.52,58.2 98.68,59.36 101.59,59.36 102.15,58.81 104.21,58.81 105.02,58.01 109.1,58.01 109.52,57.59 110.56,57.59 113.83,54.32 113.83,53.1 114.6,52.33 114.6,50.81 114.67,50.75 114.67,50.02 116.65,48.04 116.65,43.07 117.24,42.48 117.24,41 118.63,39.62 120.5,39.62 120.97,39.41 122.89,37.49 126.29,37.49 130.18,33.6 130.94,33.6 131.9,32.65 132.09,32.49 133.2,31.38 139.11,25.45 139.61,25.01 139.71,24.91 139.99,24.66 140.82,23.94 140.85,23.91 141.31,23.51 141.79,23.12 143.73,21.62 143.84,21.53 143.85,21.53 143.9,21.48 144.06,21.36 145.27,20.62 146.65,19.93 147.28,19.57 148,19.32 151.66,17.97 152.32,17.78 154.68,17.03 157.23,16.74 166.7,16.74 167.48,16.89 168.91,17.11 173.19,18.27 175.1,19.18 176.12,19.55 177.59,20.2 178.98,20.99 180.28,21.78 181.2,22.36 181.78,22.77 182.07,22.98 182.12,23.03 182.15,23.05 183.6,24.13 185.62,26 187.09,27.46 187.83,27.95 188.14,28.27 188.62,28.58 189.31,28.96 189.32,28.96 189.32,28.96 189.38,29 189.65,29.15 190.96,29.79 191.78,30 191.87,30.02 194.89,30.02 200.53,35.66 201.19,35.66 207.3,41.77 207.3,47.16 209.55,49.4 209.55,54.99 209,55.53 209,56.23 208.04,57.2 208.04,57.67 208.13,57.76 208.25,57.76 v6(208.44,57.57)
PCIE_PRX_DTX_P16: length 171.2
  TOP w0.112: RN63.1 205.74,54.45 207.22,54.45 207.77,55 208.23,55 v6(208.42,55.19)
  IN3 w0.074: v6(208.42,55.19) 208.6,55.01 208.84,55.01 209.07,54.78 209.07,49.62 206.78,47.33 206.78,41.93 201,36.15 200.35,36.15 194.7,30.51 191.82,30.51 190.77,30.24 190.3,30.05 187.9,28.74 186.98,28.11 184.01,25.17 182.39,23.83 181.87,23.44 180.88,22.75 178.9,21.56 177.85,21.01 176.44,20.24 174.35,19.39 173.75,19.11 173.13,18.82 167.98,17.47 166.47,17.22 158.01,17.22 154.74,17.52 152.61,18.2 152.27,18.29 151.92,18.39 150.78,18.82 148.65,19.61 147.64,19.96 147.63,19.97 145.43,21.11 145.43,21.11 145.18,21.25 145.17,21.25 145.05,21.33 144.76,21.5 141.53,23.98 140.95,24.46 140.93,24.49 139.9,25.43 139.84,25.48 138.86,26.38 133.54,31.72 133.53,31.73 132.42,32.84 132.36,32.89 131.16,34.09 131.08,34.09 130.38,34.09 126.49,37.98 123.07,37.98 121.24,39.81 120.6,40.1 118.85,40.1 117.74,41.21 117.74,42.68 117.13,43.28 117.13,48.35 115.46,50.02 115.46,51.74 115.7,51.98 115.7,57.24 114.21,58.72 106.67,58.72 106.44,58.48 105.22,58.48 104.37,59.33 102.34,59.33 101.83,59.85 98.49,59.85 97.04,58.4 97.04,57.83 96.18,56.96 96.18,56.1 95.83,55.76 94.34,55.76 93.1,54.52 93.1,53.46 92.61,52.96 92.61,52.36 92.34,52.09 92.05,52.09 v5(91.99,52.03)
PCIE_PRX_R_DTX_N8: length 2.7
  TOP w0.112: RN101.2 267.79,26.23 267.79,25.78 v6(267.61,25.6)
  BOTTOM w0.112: v6(267.61,25.6) 267.8,25.41 267.8,24.89 267.65,24.74 JNGFF1.41
PCIE_PRX_R_DTX_P8: length 2.7
  TOP w0.112: RN102.2 267.99,26.26 267.99,25.8 v6(268.19,25.6)
  BOTTOM w0.112: v6(268.19,25.6) 268,25.41 268,24.92 268.15,24.77 JNGFF1.43
PCIE_PTX_C_DRX_N1: length 1.9
  TOP w0.112: CR22.2 289.85,36.32 289.95,36.32 290.07,36.21 290.07,35.93 290.35,35.65 290.53,35.65 290.66,35.52 UR1.4
PCIE_PTX_C_DRX_N6: length 2.7
  BOTTOM w0.112: JNGFF3.37 209.42,31.3 209.27,31.45 207.84,31.45 CN40.2
PCIE_PTX_C_DRX_N7: length 2.4
  TOP w0.112: UN1.14 248.54,26.55 248.38,26.39 v7(247.65,26.39) 246.88,26.39 CN16.2
PCIE_PTX_C_DRX_N8: length 1.3
  TOP w0.112: CN19.2 269.3,27.9 269.3,27.2 269.15,27.04 RN103.1
PCIE_PTX_C_DRX_N9: length 2
  BOTTOM w0.076: UT2.Y22 27.47,47.37 27.47,47.03 28.02,46.49 28.02,46.23 28.02,46.23 CT3.1
PCIE_PTX_C_DRX_N10: length 1.8
  BOTTOM w0.076: CT20.1 25.8,46.21 25.8,46.55 25.64,46.71 25.64,47.36 UT2.T22
PCIE_PTX_C_DRX_N11: length 1.9
  BOTTOM w0.076: CT7.1 23.56,46.22 23.56,46.42 23.79,46.65 23.79,46.92 23.79,46.93 23.79,47.35 UT2.M22
PCIE_PTX_C_DRX_N12: length 1.9
  BOTTOM w0.076: CT11.1 21.13,46.21 21.13,46.53 21.54,46.94 21.54,47.36 UT2.H22
PCIE_PTX_C_DRX_N13: length 3.1
  TOP w0.112: CN49.2 204.8,62.01 204,62.01 v6(203.76,62.25)
  BOTTOM w0.112: v6(203.76,62.25) 204.02,61.99 204.38,61.99 204.51,62.11 JNGFF2.11
PCIE_PTX_C_DRX_N14: length 2.4
  TOP w0.112: v6(204.08,59.15) 204.23,59 204.77,59 CN51.2
  BOTTOM w0.112: JNGFF2.23 204.59,59.11 204.44,58.97 204.26,58.97 v6(204.08,59.15)
PCIE_PTX_C_DRX_N15: length 2.5
  TOP w0.112: CN53.2 204.78,55.96 204.26,55.96 v6(204.06,56.15)
  BOTTOM w0.112: v6(204.06,56.15) 204.29,55.92 204.47,55.92 204.66,56.11 JNGFF2.35
PCIE_PTX_C_DRX_N16: length 1.1
  IN1 w0.074: v4(204.37,52.99) 204.39,53.01 204.82,53.01 v2(204.98,53.17)
  IN3 w0.074: v4(204.37,52.99) 204.39,53.01 204.59,53.01 v5(204.69,53.11)
PCIE_PTX_C_DRX_P1: length 1.9
  TOP w0.112: CR21.2 289.89,36.53 290.04,36.53 290.27,36.3 290.27,36.02 290.43,35.86 290.6,35.86 290.67,35.92 UR1.3
PCIE_PTX_C_DRX_P6: length 2.7
  BOTTOM w0.112: CN39.2 207.84,31.65 209.27,31.65 209.42,31.8 JNGFF3.35
PCIE_PTX_C_DRX_P7: length 2.4
  TOP w0.112: CN17.2 246.91,26.19 247.33,26.19 247.36,26.16 247.94,26.16 247.97,26.19 248.38,26.19 248.52,26.05 UN1.15
PCIE_PTX_C_DRX_P8: length 1.3
  TOP w0.112: CN20.2 269.51,27.9 269.51,27.2 269.66,27.04 RN104.1
PCIE_PTX_C_DRX_P9: length 2
  BOTTOM w0.076: CT1.1 27.85,46.23 27.85,46.42 27.39,46.88 27.14,46.88 27.05,46.97 27.05,47.21 27.11,47.28 27.2,47.28 UT2.Y23
PCIE_PTX_C_DRX_P10: length 1.8
  BOTTOM w0.076: UT2.T23 25.42,47.27 25.38,47.32 25.28,47.32 25.22,47.27 25.22,47 25.31,46.92 25.39,46.92 25.48,46.83 25.48,46.64 25.64,46.48 25.64,46.25 CT5.1
PCIE_PTX_C_DRX_P11: length 1.9
  BOTTOM w0.076: CT22.1 23.39,46.23 23.39,46.49 23.62,46.72 23.62,46.85 23.54,46.93 23.48,46.93 23.39,47.03 23.39,47.27 23.45,47.33 23.54,47.33 23.58,47.28 UT2.M23
PCIE_PTX_C_DRX_P12: length 1.9
  BOTTOM w0.076: UT2.H23 21.74,47.22 21.82,47.3 21.89,47.3 21.96,47.23 21.96,46.99 21.89,46.91 21.75,46.91 21.71,46.87 21.3,46.46 21.3,46.24 CT9.1
PCIE_PTX_C_DRX_P13: length 3.1
  TOP w0.112: v6(203.76,61.61) 203.95,61.81 204.79,61.81 CN50.2
  BOTTOM w0.112: JNGFF2.13 204.52,61.61 204.35,61.78 203.92,61.78 v6(203.76,61.61)
PCIE_PTX_C_DRX_P14: length 2.4
  TOP w0.112: v6(204.08,58.57) 204.3,58.79 204.81,58.79 CN52.2
  BOTTOM w0.112: v6(204.08,58.57) 204.27,58.76 204.42,58.76 204.57,58.61 JNGFF2.25
PCIE_PTX_C_DRX_P15: length 2.4
  TOP w0.112: CN54.2 204.8,55.76 204.3,55.76 v6(204.06,55.52)
  BOTTOM w0.112: v6(204.06,55.52) 204.26,55.72 204.42,55.72 204.52,55.61 JNGFF2.37
PCIE_PTX_C_DRX_P16: length 1
  IN1 w0.074: v2(204.98,52.6) 204.47,52.6 204.38,52.5 v4(204.38,52.48)
  IN3 w0.074: v4(204.38,52.48) 204.38,52.5 204.48,52.61 v5(204.7,52.61)
PCIE_PTX_DRX_N1: length 220.9
  TOP w0.112: v2(281.98,36.49) 282.08,36.59 282.24,36.59 283.01,35.82 v7(284.34,35.82) 287.6,35.82 288.12,36.33 288.93,36.33 CR22.1
  IN1 w0.074: v4(101.6,53.66) 101.83,53.9 102.03,53.9 102.25,54.12 104.16,54.12 104.48,54.44 104.48,54.8 104.88,55.2 107.3,55.2 107.33,55.17 110.59,55.17 111.96,53.8 111.96,51.59 114.56,49 114.56,45.43 115.87,44.12 115.87,43.06 118.34,40.59 121.11,40.59 125.91,35.79 125.91,35.1 126.56,34.45 126.56,34.09 127.48,33.16 128.8,33.16 132.36,29.61 133.56,28.15 134.39,27.25 137.58,24.16 138.05,23.77 140.27,22.04 142.27,20.63 142.28,20.62 142.29,20.61 142.29,20.61 142.34,20.58 142.71,20.32 143.52,19.8 143.52,19.78 143.59,19.74 143.6,19.74 143.82,19.61 143.82,19.6 143.91,19.55 144.08,19.44 144.16,19.4 144.65,19.11 146.03,18.38 146.07,18.36 146.14,18.33 148.67,17.22 149.24,17.01 150.45,16.6 152.29,16.1 152.55,16.02 153.15,15.85 153.15,15.85 154.22,15.58 154.23,15.58 154.22,15.58 154.21,15.58 154.27,15.57 154.44,15.52 154.44,15.52 155.43,15.29 157.52,14.8 157.6,14.78 176.66,14.78 181.64,19.77 195.79,19.77 202.83,26.81 204.69,26.81 213.73,35.85 214.46,35.85 215.34,36.72 217.66,36.72 219.15,38.22 225.41,38.22 225.95,37.68 248.25,37.68 249.79,36.14 258.7,36.14 259.67,35.16 263.08,35.16 264.08,36.17 268.34,36.17 268.78,36.6 281.35,36.6 281.35,36.6 281.88,36.6 v2(281.98,36.49)
  IN3 w0.074: v5(101.36,53.43) v4(101.6,53.66)
PCIE_PTX_DRX_N6: length 158.4
  IN1 w0.074: v4(98.96,58.07) 98.82,58.2 98.82,58.33 98.91,58.41 99.12,58.41 99.32,58.21 99.82,58.21 101.77,58.21 103.37,59.82 104.81,59.82 105.89,60.89 105.89,63.1 106.03,63.24 108.14,63.24 108.37,63.24 110.15,63.24 110.36,63.03 110.36,61.85 110.85,61.36 114.51,61.36 118.33,57.54 118.33,54.64 118.98,53.99 118.98,52.77 120.48,51.28 121.56,51.28 122.95,49.89 126.66,49.89 127.05,49.49 127.05,48.68 128.27,47.46 128.27,44.82 129.47,43.63 129.47,42.02 129.93,41.56 130.42,41.56 132.23,39.75 134.84,35.26 136.08,33.2 136.57,32.5 137.32,31.55 137.39,31.45 138.23,30.38 138.79,29.72 139.19,29.28 141.04,27.48 141.33,27.23 142.61,26.23 143.03,25.92 143.45,25.61 145.52,24.2 146.09,23.85 146.09,23.85 146.89,23.37 147.47,23.05 148.66,22.43 149.24,22.15 150.02,21.83 151.52,21.26 151.53,21.26 151.9,21.14 151.9,21.14 153.74,20.56 153.77,20.55 154.15,20.45 154.92,20.27 157.74,19.5 158.2,19.39 158.67,19.35 174.68,19.35 180.3,24.96 188.49,24.96 188.49,24.97 188.5,24.97 189.05,25.52 193.8,25.52 201.29,33.02 202.55,33.02 203.99,34.46 203.99,35.43 205.09,36.53 205.09,37.43 206.05,38.39 206.17,38.39 206.35,38.21 v4(206.35,38.13)
  IN3 w0.074: v5(206.75,37.96) 206.58,38.13 v4(206.35,38.13) ; v5(98.88,57.69) 98.78,57.79 98.78,57.89 v4(98.96,58.07)
  BOTTOM w0.076: UCPU1.BU4 99.27,54.09 99.27,54.44 99.38,54.61 99.38,54.84 99.36,54.88 99.36,54.87 99.32,54.93 99.31,55.14 99.62,55.96 99.62,56.55 99.37,56.8 98.95,56.8 98.74,57.01 98.74,57.55 v5(98.88,57.69)
  BOTTOM w0.112: v5(206.75,37.96) 206.89,37.96 207.01,37.84 207.01,34.5 206.98,34.47 206.98,33.87 207.01,33.84 207.01,32.83 206.39,32.21 206.39,31.66 206.6,31.44 206.89,31.44 CN40.1
PCIE_PTX_DRX_N7: length 185.3
  TOP w0.112: CN16.1 245.94,26.38 v7(244.5,26.38) 242.67,26.38 238.9,30.14 238.9,35 239.01,35.11 239.26,35.11 239.38,35.23 239.38,35.47 v6(239.26,35.59)
  IN3 w0.074: v5(98.92,54.73) 98.92,55.02 99,55.1 99.56,55.1 100.17,55.71 100.93,55.71 101.28,55.37 105.25,55.37 105.48,55.6 107.85,55.6 111.34,52.11 112.34,48.39 114.39,44.71 114.39,41.34 114.99,39.97 115.31,38.62 115.31,37.9 115.6,36.07 115.86,35.27 116.37,34.55 116.99,33.94 117.16,33.84 118.03,33.55 121.01,33.55 123.78,32.8 125.2,32.8 125.34,32.77 127.11,32.06 130.22,30.71 131.11,30.21 131.62,29.69 134.45,26.86 137.02,24.28 137.99,23.36 138.2,23.16 138.44,22.94 138.45,22.94 138.75,22.68 138.85,22.59 140.78,20.93 141.71,20.18 142.33,19.71 142.34,19.7 142.96,19.25 143.25,19.08 144.55,18.33 144.77,18.22 146.36,17.48 146.6,17.36 147.47,16.93 149.55,16.19 149.72,16.14 149.72,16.14 152.11,15.42 152.63,15.24 155.26,14.47 164.65,14.47 165.29,14.47 165.3,14.46 165.94,14.46 166.58,14.46 168.63,14.45 170.29,14.83 170.93,14.97 171.93,15.2 171.95,15.2 172.79,15.46 173.22,15.59 174.46,16.07 175.7,16.54 178.55,17.9 182.7,20.25 183.03,20.45 183.04,20.46 183.87,21.14 186.99,23.86 188.05,24.92 189.88,26.56 189.98,26.64 190.17,26.76 192.15,27.67 197.18,27.67 200.24,29.15 201.31,29.51 201.72,29.59 205.41,29.59 210.98,35.16 217.65,35.16 218.33,35.84 233.76,35.84 234.89,34.7 239.07,34.7 239.26,34.89 v6(239.26,35.59)
PCIE_PTX_DRX_N8: length 222.5
  TOP w0.112: v2(263.25,33.72) 263.41,33.72 263.47,33.66 263.47,33.41 263.68,33.2 264.32,33.2 v7(266.9,30.62) 268.26,29.26 269.06,29.26 269.28,29.04 269.28,28.88 CN19.1
  IN1 w0.074: v2(263.25,33.72) 263.23,33.75 v4(263.23,34.07)
  IN3 w0.074: v5(98.91,55.78) 98.98,55.85 99.52,55.85 99.85,56.18 101.29,56.18 101.54,55.93 104.81,55.93 105.15,56.27 108.27,56.27 108.7,55.84 109.9,55.84 112.04,53.7 112.04,52.17 112.43,51.78 112.43,50.57 113.03,49.97 113.03,49.35 114.08,48.3 115.04,44.82 115.04,41.95 115.31,41.46 115.31,41.45 115.97,38.69 115.97,38.06 116.27,36.12 116.44,35.58 116.82,35.06 117.34,34.54 117.46,34.46 118.82,34.03 121.31,34.03 123.11,33.76 124.29,33.46 125.52,33.46 130.35,31.43 131.44,30.8 131.45,30.79 131.56,30.69 131.57,30.67 131.57,30.67 131.9,30.34 132.07,30.18 135.24,27 135.7,26.53 135.75,26.48 136.42,25.87 138.61,23.67 138.88,23.43 139.19,23.17 139.46,22.92 139.47,22.92 140.12,22.37 141.19,21.45 142.11,20.7 142.58,20.35 143.36,19.85 143.38,19.84 143.43,19.8 144.69,19.09 144.69,19.08 144.91,18.96 144.93,18.96 145.23,18.81 145.71,18.52 146.7,18.05 146.86,17.97 146.87,17.97 147.1,17.86 148.61,17.26 148.77,17.21 148.89,17.17 150.22,16.72 155.34,15.13 167.18,15.13 168.75,15.25 168.75,15.25 168.97,15.27 169.01,15.31 171.19,15.82 171.3,15.85 172.32,16.1 175.36,17.21 177.98,18.48 181.53,20.56 181.54,20.56 182.59,21.25 183.76,22.09 185.67,23.6 187.91,25.82 189.64,27.22 189.88,27.35 189.89,27.35 191.73,28.31 191.83,28.33 197.03,28.33 200.85,30.17 201.61,30.32 205.1,30.32 211.28,36.51 219.93,36.51 220.36,36.94 220.36,37.56 220.47,37.67 220.62,37.67 220.73,37.56 220.73,36.96 220.97,36.72 221.28,36.72 221.5,36.94 221.5,37.56 221.61,37.67 221.76,37.67 221.87,37.56 221.87,36.96 222.1,36.72 222.42,36.72 222.64,36.94 222.64,37.56 222.75,37.67 222.9,37.67 223.01,37.56 223.01,36.96 223.24,36.72 223.56,36.72 223.78,36.94 223.78,37.56 223.88,37.67 224.04,37.67 224.14,37.56 224.14,36.96 224.38,36.72 224.7,36.72 224.91,36.94 224.91,37.56 225.02,37.67 225.17,37.67 225.28,37.56 225.28,36.96 225.52,36.72 225.84,36.72 226.05,36.94 226.05,37.56 226.16,37.67 226.31,37.67 226.42,37.56 226.42,36.96 226.65,36.72 226.97,36.72 227.19,36.94 227.19,37.56 227.3,37.67 227.45,37.67 227.56,37.56 227.56,36.96 227.79,36.72 228.11,36.72 228.33,36.94 228.33,37.56 228.44,37.67 228.59,37.67 228.7,37.56 228.7,36.96 228.93,36.72 229.25,36.72 229.47,36.94 229.47,37.54 229.57,37.65 229.73,37.65 229.83,37.54 229.83,36.96 230.07,36.72 230.39,36.72 230.6,36.94 230.6,37.54 230.71,37.65 230.86,37.65 230.97,37.54 230.97,36.96 231.21,36.72 240.78,36.72 242.13,35.38 259.71,35.38 260.12,34.97 263.26,34.97 263.58,34.66 263.58,34.39 263.54,34.35 263.3,34.35 263.23,34.28 v4(263.23,34.07)
  BOTTOM w0.076: v5(98.91,55.78) 98.91,55.79 98.81,55.89 98.7,55.89 98.56,55.75 98.56,54.61 98.61,54.56 98.61,54.22 UCPU1.BT4
PCIE_PTX_DRX_N9: length 94
  IN1 w0.074: v4(98.03,54.49) 98.03,54.71 97.97,54.77 97.87,54.77 97.74,54.89 97.66,54.89 97.19,55.36 96.34,55.36 94.6,57.11 86.91,57.11 85.17,58.85 84.43,58.85 80.15,63.12 73.69,63.12 73.3,62.74 72.14,62.74 71.73,62.33 67.51,62.33 67.41,62.43 64.94,62.43 64.84,62.33 61.92,62.33 60.8,62.62 60.37,62.9 59.41,63.68 59.04,64.07 58.89,64.2 58.81,64.24 58.63,64.31 58.29,64.41 57.95,64.42 57.57,64.52 57.55,64.53 57.52,64.54 57.47,64.57 57.1,64.81 56.84,64.89 55.84,65.09 55.48,65.3 55.37,65.34 54.63,65.78 53.93,66.45 53.34,66.79 52.66,66.9 51.54,67.29 49.03,68.76 48.81,68.98 47.25,68.98 47.01,69.22 46.32,69.22 46.01,68.91 39.15,68.91 39.12,68.89 38.9,68.89 33.36,63.35 33.36,63.07 31.93,61.64 31.64,61.64 28.57,58.56 28.57,55.45 28.69,55.32 28.69,47.1 28.46,46.86 28.46,46.84 27.98,46.37 27.98,46.01 v4(28.11,45.88)
  IN3 w0.074: v5(97.8,54.73) v4(98.03,54.49) ; v4(28.11,45.88) 28.22,45.78 v5(28.22,45.45)
PCIE_PTX_DRX_N10: length 100.1
  IN1 w0.074: v4(98.03,55.91) 97.76,56.18 96.23,56.18 94.83,57.58 87.12,57.58 85.37,59.33 84.63,59.33 80.34,63.62 73.49,63.62 73.09,63.22 71.92,63.22 71.5,62.81 67.71,62.81 67.61,62.91 64.74,62.91 64.64,62.81 61.98,62.81 61.12,63.04 60.65,63.29 59.46,64.32 59.41,64.39 59.18,64.59 58.85,64.77 58.49,64.87 57.95,64.93 57.14,65.32 56.15,65.52 55.68,65.75 55.56,65.79 54.96,66.16 54.94,66.18 54.27,66.82 53.54,67.26 53.14,67.32 52.99,67.34 52.84,67.37 51.86,67.72 49.35,69.13 48.99,69.49 47.43,69.49 47.21,69.71 46.08,69.71 45.77,69.39 38.7,69.39 32.88,63.57 32.88,63.27 31.73,62.12 31.43,62.12 28.09,58.78 28.09,55.25 28.21,55.13 28.21,47.3 27.22,46.3 27.03,46.3 26.95,46.22 25.94,46.22 25.8,46.09 25.8,45.95 v4(25.98,45.78)
  IN3 w0.074: v4(98.03,55.91) 97.8,56.14 v5(97.8,56.17) ; v5(25.98,45.45) v4(25.98,45.78)
  BOTTOM w0.076: UCPU1.BR4 97.8,53.59 97.68,53.71 97.51,53.71 97.35,53.87 97.35,54.13 97.44,54.32 97.44,54.46 97.36,54.59 97.36,54.79 97.42,54.99 97.37,55.26 97.37,55.6 97.56,55.78 97.68,55.83 97.83,55.87 97.95,55.91 98.07,56.03 98.07,56.41 97.95,56.53 97.87,56.53 97.8,56.45 v5(97.8,56.17)
PCIE_PTX_DRX_N11: length 101.4
  IN1 w0.074: v4(23.74,45.78) 23.62,45.9 23.62,46.27 24.04,46.7 26.74,46.7 26.83,46.78 27.01,46.78 27.73,47.5 27.73,54.93 27.61,55.05 27.61,58.98 31.23,62.59 31.53,62.59 32.4,63.47 32.4,63.77 38.53,69.9 45.56,69.9 45.85,70.19 47.47,70.19 47.68,69.97 49.2,69.97 49.66,69.52 51.29,69.52 52.12,68.68 53.44,67.77 53.76,67.72 54.55,67.24 55.16,66.64 55.62,66.32 56.39,65.98 57.3,65.77 58.12,65.4 58.68,65.34 59.18,65.16 59.6,64.89 59.84,64.64 59.86,64.62 59.93,64.55 61.11,63.61 61.29,63.49 62.07,63.29 64.42,63.29 64.53,63.39 67.81,63.39 67.92,63.29 71.28,63.29 71.7,63.7 72.89,63.7 73.29,64.1 80.55,64.1 84.83,59.81 85.6,59.81 87.35,58.06 95.03,58.06 95.4,57.69 95.85,57.69 96.09,57.93 96.34,57.93 v4(96.47,58.06)
  IN3 w0.074: v4(96.47,58.06) 96.25,57.92 v5(96.22,57.82) ; v5(23.74,45.45) v4(23.74,45.78)
  BOTTOM w0.076: v5(96.22,57.82) 96.11,57.71 96.11,57.59 96.79,56.92 96.79,55.95 96.91,55.83 96.91,55.23 96.87,55.13 96.88,54.93 96.94,54.84 96.94,54.61 96.83,54.44 96.83,54.09 UCPU1.BN4
PCIE_PTX_DRX_N12: length 103
  IN1 w0.074: v4(20.95,45.78) 21.13,45.96 21.13,46.26 21.66,46.79 21.96,46.79 22.25,47.08 22.25,47.44 22.62,47.81 25.44,47.81 25.63,48.01 25.63,48.28 26.21,48.86 26.56,48.86 27.04,49.34 27.04,54.66 26.93,54.77 26.93,59.32 30.45,62.84 30.45,63.18 31.66,64.38 32,64.38 38.19,70.58 45.23,70.58 46.21,71.56 47.12,71.56 47.2,71.47 48.67,71.47 49.94,70.2 51.59,70.2 52.26,69.52 53.73,68.43 53.98,68.38 54.17,68.29 55,67.77 55.56,67.19 55.93,66.93 56.46,66.7 56.95,66.56 57.46,66.48 58.17,66.15 58.77,66.03 59.48,65.8 60.13,65.35 60.38,65.06 61.51,64.16 62.18,63.97 64.13,63.97 64.24,64.07 68.1,64.07 68.21,63.96 70.98,63.96 71.4,64.39 72.62,64.39 73.01,64.77 80.92,64.77 85.21,60.49 85.92,60.49 87.66,58.75 95.16,58.75 95.39,58.98 v4(95.39,59.12)
  IN3 w0.074: v4(95.39,59.12) 95.39,58.94 v5(95.24,58.79) ; v5(20.95,45.45) v4(20.95,45.78)
  BOTTOM w0.076: UCPU1.BN2 96.21,55.22 96.21,56.63 94.94,57.9 94.94,58.31 95.24,58.62 v5(95.24,58.79)
PCIE_PTX_DRX_N13: length 174.7
  TOP w0.112: v6(206.48,62.18) 206.3,62 205.75,62 CN49.1
  IN3 w0.074: v6(206.48,62.18) 206.71,62.18 206.79,62.11 206.79,61.95 206.86,61.87 206.91,61.87 207.13,61.66 207.13,59.33 207.55,58.9 207.55,56.98 207.98,56.55 207.98,53.89 208.51,53.36 208.51,49.77 206.3,47.56 206.3,42.16 200.78,36.64 200.15,36.64 194.51,30.99 191.83,30.99 191.74,30.98 190.65,30.71 190.27,30.57 189.71,30.34 188.89,29.88 187.67,29.16 187.65,29.15 187.65,29.14 186.54,28.48 183.04,24.98 182.1,24.2 181.59,23.83 181.39,23.69 180.87,23.36 180.74,23.27 180.73,23.27 180.12,22.89 178.95,22.15 177.63,21.46 176.88,21.04 175.64,20.45 173.82,19.74 172.76,19.26 170.16,18.54 168.26,18.07 166.43,17.7 158.16,17.7 155.01,17.98 153.19,18.53 150.85,19.31 149.4,19.86 148.92,20.02 148.13,20.33 148.11,20.34 147.98,20.41 147.84,20.47 147.82,20.47 147.79,20.49 147.73,20.51 147.34,20.68 145.91,21.42 145.69,21.6 144.77,22.09 141.51,24.62 141.49,24.64 140.78,25.29 140.78,25.29 138.72,27.2 138.03,27.9 137.81,28.13 137.59,28.37 135.36,30.6 135.24,30.73 131.4,34.57 131.31,34.57 131.3,34.58 130.58,34.58 126.68,38.47 123.26,38.47 121.43,40.3 120.68,40.58 119.07,40.58 118.24,41.42 118.24,42.89 117.61,43.51 117.61,48.61 115.95,50.27 115.95,51.53 116.2,51.78 116.2,57.41 114.41,59.2 105.91,59.2 105,60.11 103.33,60.11 102.99,60.46 95.89,60.46 94.58,59.15 94.58,58.35 95.51,57.42 95.51,56.91 v5(95.61,56.81)
  BOTTOM w0.076: UCPU1.BM4 96.17,54.27 96.17,54.51 96.07,54.69 96.02,54.75 96.02,56.48 95.86,56.64 95.78,56.64 v5(95.61,56.81)
PCIE_PTX_DRX_N14: length 170.7
  TOP w0.112: CN51.1 205.75,59.02 206.26,59.02 v6(206.46,59.21)
  IN3 w0.074: v5(95.01,57.03) 94.87,57.03 94.68,57.22 94.68,57.38 94.09,57.97 94.09,59.36 95.66,60.94 103.19,60.94 103.52,60.61 105.18,60.61 106.1,59.69 114.6,59.69 116.7,57.58 116.7,52.41 117.5,51.61 117.5,50.35 118.09,49.77 118.09,48.77 119.18,47.67 119.18,43.89 118.72,43.43 118.72,41.71 119.36,41.06 120.86,41.06 121.7,40.71 123.45,38.95 126.89,38.95 130.74,35.1 131.73,35.1 132.5,34.32 135.36,31.29 135.58,31.07 135.71,30.94 137.93,28.71 138.38,28.24 139.09,27.51 139.41,27.21 140.08,26.59 140.16,26.52 140.17,26.51 141.1,25.65 141.12,25.63 141.12,25.63 141.16,25.6 141.83,25.03 145.26,22.37 147.03,21.41 147.56,21.14 150.18,20.09 150.19,20.09 150.52,19.97 151.98,19.52 151.99,19.51 154.96,18.53 158.18,18.18 166.34,18.18 166.92,18.29 170.04,19.02 171.35,19.41 172.53,19.71 173.53,20.15 175.39,20.88 178.1,22.27 180.62,23.77 181.88,24.71 182.3,25.03 183.55,26.17 186.29,28.92 186.32,28.94 189.51,30.8 189.83,30.91 190.04,31 190.49,31.16 191.71,31.47 194.31,31.47 199.98,37.14 200.59,37.14 205.81,42.36 205.81,47.78 208.03,50 208.03,53.16 207.48,53.7 207.48,56.32 207.05,56.76 207.05,58.72 206.81,58.96 206.64,58.96 206.46,59.15 v6(206.46,59.21)
  BOTTOM w0.076: UCPU1.BL2 95.58,55.19 95.65,55.49 95.65,56.03 95.37,56.31 95.37,56.67 v5(95.01,57.03)
PCIE_PTX_DRX_N15: length 171.1
  TOP w0.112: CN53.1 205.72,56 206.54,56 v6(206.74,56.19)
  IN3 w0.074: v5(94.35,56.4) 94.25,56.4 94.05,56.6 94.05,56.71 93.39,57.37 93.39,59.65 95.37,61.62 101.79,61.62 103.76,63.59 105.1,63.59 105.74,62.96 112.39,62.96 117.4,57.95 117.4,52.77 118.23,51.94 118.23,50.72 118.77,50.18 118.77,49.13 119.86,48.04 119.86,43.47 120.84,42.49 121.11,42.49 121.49,42.11 121.49,41.76 121.6,41.5 122.09,41.27 123.68,39.69 127.13,39.69 128.31,38.51 129.41,38.51 130.53,37.39 131.44,37.39 131.98,36.86 134.3,34 135.26,32.55 135.55,32.21 137.85,29.77 138.43,29.19 138.88,28.72 139.54,28.04 139.67,27.92 139.88,27.71 140.61,27.02 140.81,26.86 140.82,26.85 141.98,25.79 142.17,25.63 142.43,25.43 142.67,25.24 144.13,24.14 145.32,23.23 145.75,22.93 147.77,21.79 151.5,20.38 153.55,19.75 155.19,19.2 158.22,18.86 165.96,18.86 169.12,19.5 172.39,20.42 173.65,20.97 175.07,21.53 176.49,22.23 179.14,23.7 179.85,24.18 179.86,24.18 181.18,25.03 181.47,25.24 181.85,25.55 183.18,26.87 183.44,27.11 183.45,27.12 183.95,27.58 183.96,27.59 184.92,28.51 185.84,29.43 186.19,29.67 186.2,29.67 189.28,31.47 190.8,31.98 191.7,32.16 194.04,32.16 199.71,37.83 200.32,37.83 205.13,42.64 205.13,48.07 207.35,50.3 207.35,52.83 206.8,53.38 206.8,54.08 205.75,55.13 205.75,55.94 206,56.19 v6(206.74,56.19)
  BOTTOM w0.076: v5(94.35,56.4) 94.48,56.4 94.56,56.32 94.56,55.88 94.73,55.71 94.73,55.45 94.93,55.24 94.97,55.05 94.92,54.77 94.92,54.59 95,54.46 95,54.33 94.91,54.19 94.91,53.9 95.09,53.73 95.27,53.73 95.35,53.64 UCPU1.BL4
PCIE_PTX_DRX_N16: length 166.3
  TOP w0.112: CN55.1 205.77,52.96 206.21,52.96 v6(206.43,53.18)
  IN3 w0.074: v6(206.43,53.18) 206.43,53.06 206.56,52.92 206.8,52.92 207.08,52.65 207.08,50.41 204.82,48.16 204.82,42.73 200.23,38.14 199.62,38.14 193.92,32.44 191.68,32.44 191.53,32.42 191.37,32.39 191.35,32.39 190.6,32.29 189.74,31.94 188.99,31.69 185.92,29.9 184.72,28.71 183.77,27.79 183.76,27.78 183.26,27.32 183.25,27.31 182.45,26.59 181.76,25.89 181.14,25.43 178.05,23.42 176.3,22.45 174.75,21.72 171.45,20.45 170.62,20.21 168.38,19.65 167.39,19.48 167.39,19.48 167.39,19.48 166.32,19.3 165.66,19.22 164.98,19.13 158.23,19.13 154.96,19.59 150.67,21.01 150.14,21.23 148.26,21.93 148.25,21.93 146.66,22.74 145.27,23.68 144.42,24.3 144.42,24.3 143.58,24.92 143.57,24.92 143.57,24.93 143.02,25.34 142.7,25.59 141.57,26.55 140.91,27.15 138.99,29 138.63,29.41 137.9,30.18 136.95,31.14 136.21,31.97 134.99,33.67 133.43,35.58 131.6,37.73 130.62,38.71 127.87,41.46 123.32,41.46 121.94,42.84 120.96,42.84 120.14,43.66 120.14,48.61 119.59,49.16 119.59,49.38 119.19,49.78 119.19,50.18 118.54,50.83 118.54,52.12 117.7,52.96 117.7,58.04 112.51,63.24 105.88,63.24 105.23,63.89 103.66,63.89 101.68,61.91 95.23,61.91 93.1,59.78 93.1,56.98 93.69,56.39 v5(93.85,56.39)
  BOTTOM w0.076: UCPU1.BJ4 94.39,54.08 94.39,54.44 94.5,54.61 94.5,54.84 94.44,54.92 94.43,55.13 94.51,55.34 94.51,55.58 94.3,55.79 94.3,56.09 94.08,56.31 93.93,56.31 v5(93.85,56.39)
PCIE_PTX_DRX_P1: length 220.9
  TOP w0.112: CR21.1 288.91,36.54 288.03,36.54 287.51,36.02 284.66,36.02 284.63,36.05 284.05,36.05 284.02,36.02 283.1,36.02 282.32,36.8 282.08,36.8 v2(281.98,36.9)
  IN1 w0.074: v4(101.6,54.31) 101.81,54.1 101.95,54.1 102.17,54.32 104.08,54.32 104.28,54.52 104.28,54.89 104.8,55.4 107.38,55.4 107.42,55.37 110.67,55.37 112.17,53.88 112.17,51.67 114.76,49.08 114.76,45.51 116.07,44.2 116.07,43.15 118.42,40.79 121.19,40.79 126.11,35.87 126.11,35.18 126.76,34.54 126.76,34.17 127.56,33.37 128.89,33.37 132.51,29.75 133.11,29.01 133.71,28.28 134.53,27.39 137.72,24.31 138.17,23.92 140.39,22.2 142.38,20.79 142.4,20.78 142.41,20.77 142.46,20.74 142.82,20.49 143.69,19.92 143.7,19.91 143.92,19.78 143.93,19.78 144.01,19.72 144.18,19.62 144.26,19.58 144.75,19.28 146.12,18.56 146.15,18.55 146.22,18.52 148.75,17.41 149.3,17.2 150.51,16.8 152.34,16.29 152.35,16.29 152.6,16.21 153.2,16.05 153.2,16.05 154.26,15.78 154.31,15.77 154.43,15.73 154.49,15.72 154.5,15.72 157.62,14.98 176.58,14.98 181.56,19.97 195.7,19.97 202.74,27.01 204.61,27.01 213.65,36.05 214.38,36.05 215.26,36.92 217.58,36.92 219.07,38.42 225.49,38.42 226.03,37.88 248.33,37.88 249.87,36.34 258.78,36.34 259.76,35.36 262.99,35.36 264,36.37 268.26,36.37 268.69,36.8 281.43,36.8 281.43,36.8 281.88,36.8 v2(281.98,36.9)
  IN3 w0.074: v5(101.36,54.08) v4(101.6,54.31)
PCIE_PTX_DRX_P6: length 158.3
  IN1 w0.074: v4(98.45,58.06) 98.62,58.23 98.62,58.41 98.82,58.61 99.2,58.61 99.4,58.41 99.82,58.41 101.68,58.41 103.29,60.02 104.73,60.02 105.69,60.98 105.69,63.18 105.95,63.44 108.14,63.44 108.37,63.44 110.24,63.44 110.56,63.12 110.56,61.94 110.94,61.56 114.59,61.56 118.53,57.62 118.53,54.72 119.18,54.07 119.18,52.86 120.56,51.48 121.64,51.48 123.03,50.09 126.74,50.09 127.25,49.57 127.25,48.76 128.47,47.54 128.47,44.91 129.67,43.71 129.67,42.11 130.01,41.76 130.5,41.76 131.47,40.8 132.39,39.88 135.01,35.36 136.25,33.31 136.73,32.62 137.48,31.67 137.55,31.57 138.39,30.51 138.94,29.86 139.33,29.42 141.18,27.62 141.45,27.39 141.45,27.38 142.73,26.39 143.57,25.77 145.63,24.37 146.19,24.02 146.19,24.02 146.99,23.55 147.28,23.39 147.56,23.23 148.75,22.61 149.32,22.34 150.1,22.02 151.59,21.45 151.96,21.33 153.8,20.75 154.2,20.65 154.97,20.46 157.79,19.7 158.24,19.59 158.68,19.55 174.6,19.55 180.21,25.16 188.4,25.16 188.41,25.17 188.41,25.17 188.97,25.72 193.71,25.72 201.21,33.22 202.46,33.22 203.79,34.54 203.79,35.52 204.89,36.61 204.89,37.52 205.97,38.59 206.26,38.59 206.34,38.51 v4(206.7,38.51)
  IN3 w0.074: v4(98.45,58.06) 98.58,57.93 98.58,57.79 v5(98.47,57.69) ; v5(207.01,38.25) 206.95,38.25 v4(206.7,38.51)
  BOTTOM w0.076: UCPU1.BU3 98.86,54.08 98.78,54.15 98.78,54.31 98.83,54.36 99.05,54.36 99.1,54.42 99.1,54.49 99.21,54.66 99.21,54.79 99.16,54.88 99.14,55.16 99.45,55.99 99.45,56.48 99.3,56.64 98.88,56.64 98.56,56.95 98.56,57.6 v5(98.47,57.69)
  BOTTOM w0.112: v5(207.01,38.25) 207.01,38.13 207.21,37.92 v7(207.21,34.18) 207.21,32.74 206.6,32.12 206.6,31.77 206.72,31.65 206.89,31.65 CN39.1
PCIE_PTX_DRX_P7: length 185.2
  TOP w0.112: CN17.1 245.94,26.17 244.91,26.17 244.88,26.14 244.16,26.14 244.12,26.17 242.58,26.17 238.7,30.06 238.7,35.51 v6(238.61,35.59)
  IN3 w0.074: v5(98.92,55.38) 99,55.3 99.47,55.3 100.09,55.91 101.02,55.91 101.36,55.57 105.17,55.57 105.4,55.8 107.94,55.8 111.52,52.21 112.53,48.47 114.59,44.76 114.59,41.38 115.18,40.03 115.51,38.64 115.51,37.92 115.79,36.12 116.04,35.36 116.52,34.68 117.11,34.1 117.24,34.03 118.06,33.75 121.03,33.75 123.81,33 125.22,33 125.4,32.96 127.18,32.25 130.31,30.89 131.23,30.37 131.77,29.83 137.16,24.42 138.13,23.51 138.33,23.3 138.57,23.1 138.58,23.09 138.89,22.83 138.98,22.74 140.91,21.09 141.83,20.34 142.45,19.87 143.07,19.42 143.36,19.25 144.65,18.51 144.86,18.4 146.45,17.66 146.69,17.54 147.55,17.12 149.61,16.38 149.69,16.35 149.78,16.33 152.17,15.61 152.69,15.44 155.29,14.67 164.65,14.67 165.3,14.67 165.94,14.67 168.61,14.65 170.25,15.02 170.88,15.17 171.88,15.39 171.89,15.39 172.73,15.66 173.15,15.78 174.39,16.26 175.62,16.73 178.46,18.08 182.6,20.43 182.92,20.62 183.74,21.29 186.85,24.01 187.92,25.07 189.75,26.71 189.86,26.81 190.08,26.94 192.1,27.87 197.14,27.87 200.17,29.33 201.25,29.7 201.27,29.71 201.7,29.79 205.32,29.79 210.89,35.36 217.57,35.36 218.25,36.04 233.84,36.04 234.97,34.91 238.99,34.91 239.06,34.98 239.06,35.14 238.99,35.21 238.55,35.21 238.47,35.3 238.47,35.45 v6(238.61,35.59)
PCIE_PTX_DRX_P8: length 222.6
  TOP w0.112: v2(263.78,33.72) 263.68,33.62 263.68,33.49 263.76,33.41 264.4,33.41 266.81,30.99 266.86,30.99 267.29,30.56 267.29,30.52 268.34,29.46 269.14,29.46 269.48,29.13 269.48,28.94 CN20.1
  IN1 w0.074: v4(263.78,34.07) v2(263.78,33.72)
  IN3 w0.074: v5(98.89,56.17) 99.01,56.05 99.43,56.05 99.77,56.38 101.37,56.38 101.62,56.13 104.73,56.13 105.07,56.47 108.36,56.47 108.78,56.04 109.98,56.04 112.24,53.78 112.24,52.25 112.64,51.86 112.64,50.65 113.23,50.05 113.23,49.43 114.26,48.41 115.24,44.85 115.24,42 115.5,41.53 116.17,38.72 116.17,38.07 116.46,36.17 116.62,35.67 116.98,35.19 117.47,34.69 117.55,34.64 118.85,34.23 121.32,34.23 123.15,33.96 124.31,33.66 125.56,33.66 130.44,31.61 131.55,30.97 131.57,30.96 131.57,30.96 131.59,30.93 131.7,30.83 131.78,30.76 131.78,30.75 132.05,30.48 132.21,30.32 132.27,30.26 132.27,30.26 135.38,27.14 135.85,26.67 135.89,26.63 136.56,26.01 138.75,23.81 139.01,23.58 139.32,23.32 139.6,23.07 139.6,23.07 140.25,22.52 141.32,21.6 142.24,20.86 142.69,20.51 143.47,20.02 143.5,20 143.55,19.96 144.78,19.26 144.79,19.26 144.93,19.18 144.94,19.17 144.95,19.18 145.32,18.98 145.81,18.7 146.79,18.23 146.88,18.18 146.88,18.19 147.18,18.04 148.67,17.45 148.84,17.4 148.96,17.35 150.28,16.91 155.37,15.33 167.18,15.33 168.72,15.45 168.72,15.45 168.88,15.46 168.9,15.49 171.14,16.01 171.25,16.04 172.26,16.29 175.28,17.39 177.89,18.65 181.43,20.73 182.48,21.42 183.64,22.25 185.53,23.75 187.77,25.97 189.53,27.39 189.79,27.53 189.8,27.53 191.66,28.49 191.8,28.53 196.99,28.53 200.78,30.36 201.19,30.44 201.59,30.52 205.01,30.52 211.2,36.71 219.84,36.71 220.16,37.02 220.16,37.65 220.39,37.87 220.71,37.87 220.93,37.65 220.93,37.04 221.05,36.92 221.2,36.92 221.3,37.02 221.3,37.65 221.52,37.87 221.84,37.87 222.07,37.65 222.07,37.04 222.19,36.92 222.34,36.92 222.44,37.02 222.44,37.65 222.66,37.87 222.98,37.87 223.21,37.65 223.21,37.04 223.32,36.92 223.48,36.92 223.57,37.02 223.57,37.65 223.8,37.87 224.12,37.87 224.34,37.65 224.34,37.04 224.46,36.92 224.61,36.92 224.71,37.02 224.71,37.65 224.94,37.87 225.26,37.87 225.48,37.65 225.48,37.04 225.6,36.92 225.75,36.92 225.85,37.02 225.85,37.65 226.08,37.87 226.4,37.87 226.62,37.65 226.62,37.04 226.74,36.92 226.89,36.92 226.99,37.02 226.99,37.65 227.21,37.87 227.53,37.87 227.76,37.65 227.76,37.04 227.88,36.92 228.03,36.92 228.13,37.02 228.13,37.65 228.35,37.87 228.67,37.87 228.9,37.65 228.9,37.04 229.01,36.92 229.17,36.92 229.26,37.02 229.26,37.62 229.49,37.85 229.81,37.85 230.03,37.62 230.03,37.04 230.15,36.92 230.3,36.92 230.4,37.02 230.4,37.62 230.63,37.85 230.95,37.85 231.17,37.62 231.17,37.04 231.29,36.92 240.87,36.92 242.21,35.58 259.79,35.58 260.2,35.17 263.35,35.17 263.78,34.74 v4(263.78,34.07)
  BOTTOM w0.076: UCPU1.BT3 98.3,54.34 98.18,54.34 98.1,54.42 98.1,54.64 98.19,54.73 98.31,54.73 98.4,54.83 98.4,55.82 98.63,56.05 98.77,56.05 v5(98.89,56.17)
PCIE_PTX_DRX_P9: length 94.1
  IN1 w0.074: v4(98.03,55.14) 97.98,55.09 97.74,55.09 97.27,55.57 96.43,55.57 94.69,57.31 87,57.31 85.25,59.05 84.51,59.05 80.24,63.33 73.61,63.33 73.22,62.94 72.06,62.94 71.65,62.53 67.59,62.53 67.49,62.63 64.86,62.63 64.76,62.53 61.95,62.53 60.88,62.81 60.48,63.06 59.55,63.82 59.17,64.22 59.01,64.37 58.9,64.42 58.7,64.5 58.32,64.61 57.98,64.62 57.62,64.72 57.62,64.72 57.57,64.75 57.18,64.99 56.89,65.08 55.91,65.29 55.57,65.48 55.46,65.52 54.75,65.94 54.06,66.61 53.41,66.98 52.7,67.1 51.62,67.47 49.16,68.92 48.89,69.18 47.33,69.18 47.09,69.42 46.24,69.42 45.93,69.11 39.07,69.11 39.04,69.09 38.82,69.09 33.16,63.43 33.16,63.15 31.85,61.84 31.56,61.84 28.37,58.65 28.37,55.37 28.49,55.24 28.49,47.18 28.26,46.95 28.26,46.92 27.78,46.45 27.78,46.06 v4(27.61,45.88)
  IN3 w0.074: v4(27.61,45.88) 27.61,45.5 v5(27.66,45.45) ; v5(97.8,55.38) v4(98.03,55.14)
PCIE_PTX_DRX_P10: length 100
  IN1 w0.074: v4(98.03,56.56) 97.85,56.38 96.32,56.38 94.91,57.78 87.2,57.78 85.46,59.53 84.71,59.53 80.42,63.82 73.4,63.82 73.01,63.42 71.83,63.42 71.42,63.01 67.8,63.01 67.69,63.11 64.66,63.11 64.55,63.01 62.01,63.01 61.2,63.22 60.76,63.45 59.61,64.46 59.55,64.53 59.29,64.75 58.92,64.96 58.53,65.07 58,65.13 57.21,65.51 56.21,65.71 55.76,65.93 55.65,65.97 55.08,66.32 54.39,66.98 53.61,67.46 53.17,67.51 52.89,67.56 51.95,67.9 49.47,69.29 49.07,69.69 47.51,69.69 47.29,69.91 46,69.91 45.68,69.59 38.62,69.59 32.68,63.65 32.68,63.35 31.65,62.32 31.35,62.32 27.89,58.86 27.89,55.17 28.01,55.04 28.01,47.38 27.13,46.5 26.95,46.5 26.87,46.42 25.85,46.42 25.6,46.17 25.6,45.96 v4(25.42,45.78)
  IN3 w0.074: v5(97.8,56.79) v4(98.03,56.56) ; v5(25.42,45.45) v4(25.42,45.78)
  BOTTOM w0.076: v5(97.8,56.79) 97.8,56.77 97.87,56.69 98.02,56.69 98.23,56.48 98.23,55.96 98.04,55.77 97.88,55.71 97.73,55.68 97.65,55.64 97.54,55.53 97.53,55.28 97.59,54.98 97.52,54.76 97.52,54.64 97.6,54.5 97.6,54.28 97.52,54.09 97.52,53.94 97.58,53.88 97.67,53.88 97.8,54 UCPU1.BR3
PCIE_PTX_DRX_P11: length 101.5
  IN1 w0.074: v4(23.19,45.78) 23.23,45.78 23.42,45.96 23.42,46.35 23.96,46.9 26.66,46.9 26.74,46.98 26.93,46.98 27.53,47.58 27.53,54.85 27.41,54.97 27.41,59.06 31.15,62.79 31.45,62.79 32.2,63.55 32.2,63.85 38.45,70.1 45.47,70.1 45.76,70.39 47.55,70.39 47.76,70.17 49.29,70.17 49.74,69.72 51.37,69.72 52.25,68.84 53.51,67.96 53.83,67.91 54.67,67.39 55.29,66.79 55.72,66.49 56.45,66.17 57.36,65.96 58.18,65.6 58.73,65.53 59.27,65.34 59.73,65.04 59.99,64.77 60.01,64.75 60.06,64.7 61.23,63.78 61.38,63.67 62.09,63.49 64.34,63.49 64.45,63.59 67.9,63.59 68,63.49 71.2,63.49 71.62,63.9 72.81,63.9 73.2,64.3 80.63,64.3 84.92,60.01 85.69,60.01 87.44,58.26 95.11,58.26 95.48,57.89 95.76,57.89 95.84,57.97 95.84,58 95.66,58.18 95.66,58.3 95.74,58.37 95.96,58.37 v4(96.02,58.31)
  IN3 w0.074: v5(23.19,45.45) v4(23.19,45.78) ; v5(95.83,57.81) 95.83,57.82 95.8,57.97 v4(96.02,58.31)
  BOTTOM w0.076: v5(95.83,57.81) 95.94,57.7 95.94,57.53 96.62,56.85 96.62,55.88 96.74,55.76 96.74,55.26 96.7,55.15 96.72,54.92 96.72,54.92 96.72,54.88 96.77,54.79 96.77,54.66 96.66,54.49 96.66,54.16 96.58,54.08 UCPU1.BN3
PCIE_PTX_DRX_P12: length 102.9
  IN1 w0.074: v4(95.73,58.74) 95.44,58.74 95.24,58.55 87.58,58.55 85.83,60.29 85.12,60.29 80.84,64.57 73.09,64.57 72.7,64.19 71.49,64.19 71.06,63.76 68.12,63.76 68.01,63.87 64.32,63.87 64.22,63.77 62.15,63.77 61.41,63.98 60.24,64.91 60,65.2 59.39,65.61 58.72,65.83 58.11,65.96 57.4,66.28 56.91,66.37 56.4,66.51 55.83,66.76 55.43,67.04 54.87,67.61 54.07,68.11 53.92,68.19 53.65,68.24 52.13,69.37 51.5,70 49.85,70 48.58,71.27 47.12,71.27 47.03,71.36 46.29,71.36 45.31,70.38 38.27,70.38 32.08,64.18 31.74,64.18 30.65,63.09 30.65,62.76 27.14,59.24 27.14,54.85 27.24,54.75 27.24,49.26 26.65,48.66 26.3,48.66 25.83,48.2 25.83,47.92 25.52,47.61 22.71,47.61 22.46,47.36 22.46,47 22.05,46.59 21.74,46.59 21.33,46.17 21.33,45.96 v4(21.51,45.78)
  IN3 w0.074: v5(95.54,58.47) 95.56,58.47 95.73,58.65 v4(95.73,58.74) ; v5(21.51,45.45) v4(21.51,45.78)
  BOTTOM w0.076: v5(95.54,58.47) 95.61,58.47 95.78,58.3 95.78,58.15 95.69,58.06 95.55,58.06 95.29,58.32 95.18,58.32 95.1,58.25 95.1,57.97 96.38,56.7 96.38,55.77 96.45,55.7 96.5,55.7 96.57,55.62 96.57,55.47 UCPU1.BN1
PCIE_PTX_DRX_P13: length 174.7
  TOP w0.112: v6(206.48,61.59) 206.27,61.8 205.75,61.8 CN50.1
  IN3 w0.074: v6(206.48,61.59) 206.56,61.67 206.83,61.67 206.93,61.58 206.93,59.24 207.35,58.82 207.35,56.89 207.78,56.47 207.78,53.81 208.31,53.27 208.31,49.86 206.09,47.64 206.09,42.24 200.69,36.84 200.07,36.84 194.42,31.19 191.82,31.19 191.7,31.18 190.59,30.9 190.2,30.76 189.62,30.52 188.79,30.06 187.57,29.33 187.55,29.32 187.54,29.31 186.41,28.64 182.9,25.13 181.97,24.36 181.47,23.99 181.28,23.86 180.76,23.53 180.69,23.48 180.68,23.48 180.01,23.06 178.85,22.33 177.53,21.64 176.79,21.22 175.56,20.64 173.74,19.92 172.69,19.45 170.11,18.74 168.21,18.26 166.41,17.9 158.16,17.9 155.05,18.17 153.25,18.72 150.91,19.5 149.46,20.05 148.99,20.21 148.21,20.52 148.2,20.52 148.06,20.59 147.89,20.67 147.87,20.67 147.8,20.7 147.42,20.86 146.02,21.59 145.8,21.76 144.88,22.26 141.63,24.78 141.62,24.79 140.92,25.44 140.91,25.44 138.86,27.35 138.17,28.04 137.73,28.51 135.5,30.74 135.38,30.87 131.48,34.77 131.39,34.77 131.38,34.78 130.66,34.78 126.77,38.67 123.34,38.67 121.54,40.47 120.72,40.78 119.15,40.78 118.44,41.5 118.44,42.97 117.81,43.6 117.81,48.7 116.15,50.35 116.15,51.45 116.4,51.7 116.4,57.49 114.49,59.4 105.99,59.4 105.08,60.31 103.41,60.31 103.07,60.66 95.8,60.66 94.37,59.23 94.37,58.27 95.31,57.34 95.31,56.67 95.56,56.41 v5(95.62,56.41)
  BOTTOM w0.076: v5(95.62,56.41) 95.68,56.47 95.79,56.47 95.85,56.41 95.85,54.76 95.78,54.69 95.68,54.69 95.61,54.61 95.61,54.16 95.72,54.05 95.83,54.05 95.92,54.13 UCPU1.BM3
PCIE_PTX_DRX_P14: length 170.7
  TOP w0.112: CN52.1 205.75,58.81 206.26,58.81 v6(206.46,58.61)
  IN3 w0.074: v6(206.46,58.61) 206.61,58.76 206.73,58.76 206.85,58.63 206.85,56.67 207.28,56.24 207.28,53.62 207.83,53.08 207.83,50.09 205.61,47.87 205.61,42.44 200.51,37.34 199.89,37.34 194.22,31.67 191.68,31.67 190.43,31.35 189.96,31.19 189.76,31.1 189.43,30.98 186.21,29.11 186.16,29.07 183.41,26.32 182.17,25.18 181.76,24.86 180.51,23.94 179.26,23.19 178.01,22.45 175.31,21.06 173.45,20.34 172.47,19.9 171.3,19.61 169.98,19.21 166.88,18.48 166.32,18.38 158.19,18.38 155,18.73 152.05,19.71 152.05,19.71 150.59,20.16 150.25,20.28 150.25,20.28 147.65,21.32 147.12,21.58 145.37,22.54 143.66,23.87 141.95,25.19 141.24,25.79 141.23,25.8 140.3,26.66 140.3,26.67 140.22,26.74 139.55,27.36 139.23,27.65 138.52,28.37 138.3,28.61 138.08,28.85 135.85,31.08 135.73,31.21 135.5,31.43 132.64,34.45 131.81,35.3 130.83,35.3 126.97,39.15 123.54,39.15 121.81,40.88 120.9,41.27 119.44,41.27 118.92,41.79 118.92,43.35 119.38,43.81 119.38,47.76 118.29,48.85 118.29,49.85 117.7,50.44 117.7,51.69 116.9,52.49 116.9,57.66 114.68,59.89 106.19,59.89 105.27,60.81 103.61,60.81 103.28,61.14 95.58,61.14 93.89,59.45 93.89,57.88 94.48,57.29 94.48,57.14 94.96,56.65 v5(95.02,56.65)
  BOTTOM w0.076: UCPU1.BL1 95.27,55.38 95.17,55.48 95.17,55.62 95.24,55.69 95.43,55.69 95.49,55.75 95.49,55.96 95.3,56.15 95.19,56.15 95.07,56.03 94.97,56.03 94.89,56.11 94.89,56.31 94.97,56.38 95.13,56.38 95.2,56.45 95.2,56.6 95.14,56.66 95.02,56.66 v5(95.02,56.65)
PCIE_PTX_DRX_P15: length 171.1
  TOP w0.112: CN54.1 205.77,55.79 206.55,55.79 v6(206.74,55.6)
  IN3 w0.074: v5(94.33,56.8) 94.24,56.8 93.59,57.45 93.59,59.56 95.45,61.42 101.87,61.42 103.84,63.39 105.02,63.39 105.66,62.76 112.31,62.76 117.2,57.87 117.2,52.69 118.03,51.86 118.03,50.64 118.57,50.1 118.57,49.05 119.66,47.95 119.66,43.38 120.76,42.29 121.02,42.29 121.29,42.02 121.29,41.72 121.44,41.35 121.51,41.32 121.98,41.11 123.6,39.49 127.05,39.49 128.23,38.31 129.33,38.31 130.45,37.19 131.36,37.19 131.83,36.72 134.14,33.88 135.09,32.43 135.4,32.08 137.71,29.63 138.29,29.05 138.73,28.58 139.4,27.9 139.53,27.77 139.74,27.57 140.48,26.87 140.68,26.7 141.85,25.64 142.3,25.27 142.55,25.08 143.84,24.11 145.2,23.06 145.65,22.76 147.69,21.61 151.43,20.19 153.49,19.56 155.15,19.01 158.21,18.65 165.98,18.65 169.17,19.31 172.46,20.23 173.73,20.78 175.15,21.34 176.58,22.05 179.24,23.53 179.61,23.77 179.96,24.01 179.96,24.01 181.29,24.86 181.59,25.08 181.99,25.4 183.32,26.73 183.58,26.96 183.59,26.97 184.09,27.43 184.1,27.45 185.06,28.37 185.97,29.27 186.3,29.5 186.3,29.5 189.36,31.28 190.85,31.79 191.72,31.96 194.12,31.96 199.79,37.63 200.4,37.63 205.33,42.56 205.33,47.99 207.55,50.21 207.55,52.92 207,53.47 207,54.16 205.95,55.22 205.95,55.86 206.09,55.99 206.25,55.99 206.32,55.92 206.32,55.37 206.4,55.28 206.51,55.28 206.63,55.41 206.63,55.49 v6(206.74,55.6)
  BOTTOM w0.076: v5(94.33,56.8) 94.33,56.79 94.72,56.39 94.72,55.94 94.89,55.78 94.89,55.52 95.08,55.32 95.13,55.05 95.08,54.75 95.08,54.64 95.16,54.5 95.16,54.29 95.08,54.15 95.08,53.97 95.16,53.89 95.26,53.89 95.35,53.99 UCPU1.BL3
PCIE_PTX_DRX_P16: length 166.3
  TOP w0.112: CN56.1 205.72,52.76 206.23,52.76 v6(206.43,52.55)
  IN3 w0.074: v5(93.85,56) 93.81,56 93.62,56.19 93.61,56.19 92.9,56.9 92.9,59.86 95.15,62.11 101.59,62.11 103.57,64.09 105.31,64.09 105.96,63.44 112.59,63.44 117.9,58.12 117.9,53.04 118.74,52.21 118.74,50.91 119.39,50.26 119.39,49.87 119.79,49.46 119.79,49.24 120.34,48.69 120.34,43.75 121.05,43.04 122.02,43.04 123.4,41.66 127.95,41.66 130.76,38.85 131.75,37.87 133.59,35.7 135.15,33.79 136.37,32.09 137.09,31.27 138.05,30.32 138.77,29.55 139.13,29.14 141.05,27.29 141.7,26.7 142.83,25.74 143.14,25.5 143.69,25.09 143.7,25.09 145.39,23.84 146.76,22.91 148.33,22.12 150.22,21.42 150.74,21.2 155.01,19.79 158.25,19.33 164.97,19.33 166.29,19.5 167.59,19.72 167.59,19.72 167.59,19.72 168.34,19.85 170.57,20.4 171.39,20.64 174.67,21.9 176.21,22.63 177.08,23.11 177.95,23.6 181.03,25.59 181.63,26.04 182.32,26.73 183.11,27.46 183.12,27.47 183.62,27.92 183.63,27.93 184.58,28.85 185.79,30.06 188.91,31.87 189.67,32.13 190.55,32.48 191.32,32.59 191.5,32.61 191.67,32.64 193.84,32.64 199.54,38.34 200.15,38.34 204.62,42.81 204.62,48.24 206.87,50.5 206.87,52.56 206.72,52.72 206.6,52.72 v6(206.43,52.55)
  BOTTOM w0.076: UCPU1.BJ3 94.04,53.92 93.97,53.85 93.87,53.85 93.78,53.94 93.78,54.24 93.89,54.35 94.16,54.35 94.22,54.41 94.22,54.49 94.33,54.66 94.33,54.79 94.28,54.87 94.26,55.16 94.34,55.38 94.34,55.52 94.14,55.72 94.14,56.02 94.01,56.14 93.93,56.14 93.85,56.07 v5(93.85,56)
PCIE_PTX_R_DRX_N8: length 2.7
  TOP w0.112: RN103.2 269.3,26.25 269.3,25.79 v6(269.11,25.6)
  BOTTOM w0.112: v6(269.11,25.6) 269.3,25.41 269.3,24.87 269.15,24.72 JNGFF1.47
PCIE_PTX_R_DRX_P8: length 2.7
  TOP w0.112: RN104.2 269.5,26.24 269.5,25.79 v6(269.69,25.6)
  BOTTOM w0.112: v6(269.69,25.6) 269.5,25.41 269.5,24.88 269.65,24.73 JNGFF1.49
PCIE_RCOMPN: length 0.7
  IN1 w0.305: v4(104.24,52.26) v2(104.56,52.09)
  IN3 w0.305: v4(104.24,52.26) v5(104,52.03)
PCIE_RCOMPP: length 0.7
  IN1 w0.305: v2(104.56,52.67) v4(104.24,52.91)
  IN3 w0.305: v4(104.24,52.91) v5(104,52.68)
PCIE_WAKE#: length 341.5
  TOP w0.127: v2(131.46,16.1) 131.01,15.66 v2(131.01,13.5) ; RN112.1 258.96,46.09 259.24,45.82 UN4.3 259.61,46.67 v2(257.75,48.53) ; v2(258.63,51.94) 258.75,52.05 RE188.2 RE189.1 ; RN24.2 212.53,51.31 213.08,50.77 v6(213.96,50.77) 214.55,50.77 217.13,53.35 v1(222.74,53.35) 223.62,53.35 v2(225.26,51.71) ; RT290.1 30.65,57.48 31.75,57.48 31.99,57.71 v2(32.43,57.71)
  IN1 w0.061: v2(258.63,51.94) 258.42,51.94 257.22,50.74 255.76,50.74 v4(255.4,50.37) 254.75,51.02 249.4,51.02 249.14,51.29 246.28,51.29 245.27,50.28 228.76,50.28 228.1,50.94 226.03,50.94 v2(225.26,51.71) ; v2(131.01,13.5) 130.7,13.5 130.56,13.64 130.56,14.41 128.15,16.82 124.15,16.82 123.3,15.97 122.81,15.97 122.68,16.1 122.68,16.63 122.42,16.89 121.89,16.89 120.98,17.79 120.56,17.79 120.05,18.31 114.86,18.31 113.81,17.25 106.31,17.25 106.13,17.43 106.13,17.86 102.8,21.19 98.92,21.19 98.49,20.76 98,20.76 95.81,18.57 95.81,18.09 95.37,17.64 94.7,17.64 93.05,16 93.05,15.28 92.52,14.74 91.08,14.74 90.8,14.46 85.15,14.46 84.58,13.89 79.89,13.89 78.88,14.89 78.66,14.89 73.79,14.89 73.46,14.56 68.99,14.56 68.32,13.89 62.69,13.89 61.25,15.32 59.07,15.32 56.96,17.43 v4(56.96,17.68) ; v4(257.36,48.84) 257.44,48.84 v2(257.75,48.53) ; v2(131.46,16.1) 131.46,16.09 131.7,15.84 v4(131.7,15.8) ; v4(35.28,62.58) 35.57,62.29 35.57,61.67 34.28,60.37 34.28,58.59 33.66,57.97 32.7,57.97 v2(32.43,57.71)
  IN3 w0.061: v4(35.28,62.58) 34.84,62.58 v5(34.75,62.48) ; v5(38.76,62.38) 38.76,60.78 38.25,60.26 38.25,59.21 38.56,58.9 38.56,57.91 38.87,57.61 38.87,55.76 38.67,55.56 38.67,51.66 39.58,50.74 41.27,50.74 43.2,48.81 43.2,47.33 42.99,47.11 42.99,46.79 43.18,46.6 44.26,46.6 44.66,47.01 45.22,47.01 46.27,45.96 46.27,41.43 47.61,40.09 48.89,40.09 51.61,37.37 51.86,37.37 52.17,37.06 52.17,36.44 56.94,31.68 56.94,26.2 56.63,25.89 56.63,22.56 57.42,21.77 57.42,21.45 58,20.87 58,18.73 v4(56.96,17.68) ; v4(255.4,50.37) 256.46,49.31 256.89,49.31 v4(257.36,48.84) ; v4(131.7,15.8) 131.3,15.8 v5(131.23,15.88)
  BOTTOM w0.102: RT186.2 RT27.1
  BOTTOM w0.127: RT27.1 27.94,61.73 28.05,61.61 28.55,61.61 29.41,62.48 v5(34.75,62.48) 34.8,62.53 35.78,62.53 35.83,62.48 38.63,62.48 38.73,62.38 v5(38.76,62.38) ; v5(131.23,15.88) 131.37,15.73 131.37,15.16 131.66,14.88 134.94,14.88 135.37,15.31 136.74,15.31 136.9,15.15 138.54,15.15 139.13,15.75 176.4,15.75 186.68,26.03 199.4,26.03 199.68,26.31 208.49,26.31 208.88,26.69 209.28,26.69 209.39,26.8 JNGFF3.55 211.36,26.8 213.03,28.47 213.03,31.63 213.7,32.3 213.7,37.33 213.22,37.81 213.22,40.09 213.7,40.57 213.7,43.72 215.11,45.13 215.11,49.61 v6(213.96,50.77)
