# Allegro board LAG441PR10-1221_GCR.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+1.0VS_VCCIO on BOTTOM: 102.34,26.61 102.31,26.65 102.31,28.16 102.52,28.38 103.36,28.38 103.67,28.15 103.97,28.38 104.71,28.38 104.89,28.2 104.89,26.77 104.74,26.61 104.07,26.61 104.05,26.64 104.05,27.14 104.03,27.16 103.53,27.16 103.51,27.15 103.51,26.62 103.5,26.62 103.26,26.62 103.26,26.62 103.26,27.15 103.25,27.16 102.73,27.16 102.72,27.15 102.72,26.61 102.71,26.61
+1.0VS_VCCIO on IN1: 96.68,46.31 97.13,46.31 97.32,46.12 97.32,44.85 97.19,44.72 96.68,44.72 96.56,44.85 96.56,46.18
+1.0VS_VCCIO on IN1: 82.18,40.98 83.53,40.98 83.97,40.55 83.97,40.23 83.63,39.89 83.63,38.95 83.71,38.87 83.71,38.64 83.61,38.54 82.74,38.54 82.17,39.1 82.17,40.42 82.06,40.53 82.06,40.86
+1.0VS_VCCIO on IN1: 94.65,40.6 94.65,41.04 94.33,41.36 93.45,41.36 92.87,40.79 92.87,39.77 93.89,38.75 94.14,38.75 94.33,38.94 94.33,39.2 93.89,39.64 93.89,40.02 94.14,40.28 94.33,40.28
+1.0VS_VCCIO on VCC: 99.14,25.29 96.11,28.32 96.11,29.46 93.19,32.26 93.19,38.22 93.06,38.35 93.06,40.86 93.12,40.91 94.54,40.91 94.65,40.8 94.65,40.39 94.59,40.33 94.59,38.83 94.79,38.63 106.53,38.63 106.53,27.94 106.04,27.45 105.09,27.45 104.58,26.94 101.53,26.94 100.75,26.16 100.75,25.29
+1.0VS_VCCIO on IN3: 104.24,28.34 104.75,28.34 104.86,28.23 104.86,27.22 104.65,27.01 103.1,27.01 102.72,27.39 102.72,27.83 103.22,28.34 103.29,28.34 103.54,28.09 103.99,28.09
+1.0VS_VCCIO on IN3: 82.78,38.54 82.22,39.1 82.22,42.07 82.33,42.18 91.86,42.18 93.19,43.52 93.19,45.99 93.51,46.31 97.07,46.31 97.32,46.06 97.32,44.91 96.3,43.9 96.3,42.82 94.65,41.17 94.65,40.53 94.33,40.21 94.33,38.72 94.15,38.54
+1.0VS_VCCIOP on BOTTOM (solid shape): 103.91,27.01 103.91,26.49 103.93,26.47 106.06,26.47 106.15,26.38 106.15,23.1 106.11,23.06 102.34,23.06 102.22,23.18 102.22,26.39 102.3,26.47 102.86,26.47 102.86,26.47 102.86,27.01 102.86,27.02 103.11,27.02 103.11,27.02 103.11,26.47 103.11,26.47 103.66,26.47 103.66,26.47 103.66,27.02 103.66,27.02 103.91,27.02
+1.2V_DDR on BOTTOM (solid shape): 99.45,18.54 99.45,16.5 99.35,16.4 98.97,16.4 98.76,16.19 98.76,15.27 98.65,15.15 97.08,15.15 97.04,15.19 97.04,18.06 97.17,18.18 98.74,18.18 98.84,18.28 98.84,18.63 98.9,18.69 99.3,18.69
+1.2V_DDR on BOTTOM (solid shape): 55.97,21.74 55.97,18.48 56.76,17.7 56.76,17.01 56.61,16.86 55.66,16.86 55.56,16.77 54.6,16.77 53.58,17.79 53.58,18.31 54.13,18.31 54.13,18.31 54.13,19.06 54.13,19.06 53.58,19.06 53.58,19.06 53.58,19.51 54.13,19.51 54.13,19.51 54.13,20.26 53.59,20.26 53.59,20.26 53.59,21.73 53.8,21.95 55.76,21.95
+1.2V_DDR on IN3 (solid shape): 56.04,20.08 56.04,17.8 55.92,17.67 54.52,17.67 54.52,20.08 54.65,20.21 55.92,20.21
+1.2V_DDR on TOP: 79.77,13.15 79.61,13.3 79.61,14.2 79.73,14.32 82.54,14.32 82.92,13.94 84.64,13.94 84.99,14.29 85.65,14.29 85.7,14.24 85.7,13.73 85.83,13.61 86.46,13.61 86.59,13.73 86.59,14.24 86.63,14.29 87.24,14.29 87.31,14.22 87.31,13.68 87.37,13.61 87.93,13.61 88.02,13.69 88.02,14.15 88.16,14.29 88.96,14.29 89,14.24 89,13.73 89.14,13.59 90,13.59 90.14,13.73 90.14,14.12 90.31,14.29 91.19,14.29 91.29,14.19 91.29,13.73 91.41,13.61 91.92,13.61 92.05,13.73 92.05,14.19 92.14,14.29 92.59,14.29 92.68,14.19 92.68,13.35 92.48,13.15
+1.2V_DDR on TOP: 58.03,13.34 57.91,13.46 57.91,17.94 58,18.03 58.51,18.03 58.99,18.51 59.42,18.51 59.52,18.41 59.52,17.43 59.03,16.94 59.03,14.12 59.28,13.86 59.66,13.86 59.79,13.99 59.79,14.37 59.86,14.44 60.36,14.44 60.43,14.37 60.43,14.12 60.55,13.99 61.15,13.99 61.21,14.05 61.21,14.45 61.26,14.5 61.95,14.5 62.08,14.37 62.08,13.86 62.33,13.61 63.09,13.61 63.22,13.73 63.22,14.37 63.29,14.44 64.29,14.44 64.87,13.86 65.3,13.86 65.43,13.99 65.43,14.42 65.49,14.48 66.03,14.48 66.27,14.24 66.27,13.99 66.39,13.86 66.78,13.86 66.9,13.99 66.9,14.37 66.98,14.45 67.46,14.45 67.54,14.37 67.54,13.99 67.66,13.86 68.05,13.86 68.17,13.99 68.17,14.37 68.25,14.45 69.24,14.45 69.32,14.37 69.32,13.41 69.24,13.34
+1.2V_DDR on IN1: 79.46,13.99 81.85,13.99 81.95,14.09 81.95,14.8 78.07,18.69 75.93,18.69 75.5,18.26 75.5,17.95
+1.2V_DDR on VCC: 54.56,17.67 54.2,18.03 54.2,21.46 53.57,22.09 53.57,27.09 54.58,28.11 54.58,29.59 53.93,30.24 51.66,30.24 51.66,39.64 63.2,39.64 64.98,41.42 75.2,41.42 75.6,41.82 75.61,41.8 83.49,41.8 83.79,41.49 83.79,38.26 84.06,37.99 92.68,37.99 92.68,32.04 95.6,29.25 95.6,28.11 98.78,24.93 98.78,21.71 98.27,21.21 98.27,17.78 98.17,17.67
+1.2V_DDRP on TOP (solid shape): 52.09,20.71 52.09,17.05 50.88,17.05 50.83,17.1 50.83,20.68 50.88,20.73 52.07,20.73
+1.2V_DDRP on BOTTOM (solid shape): 52.53,24.15 52.53,21.69 53.43,20.78 53.43,20.11 53.98,20.11 53.98,20.11 53.98,19.66 53.43,19.66 53.43,18.91 53.98,18.91 53.98,18.91 53.98,18.46 53.44,18.46 53.43,18.46 53.43,17.61 54.21,16.83 54.21,15.76 54.05,15.6 49.3,15.6 49.29,15.59 47.72,15.59 47.59,15.72 47.59,17.66 47.8,17.87 50.35,17.87 50.67,18.2 50.67,23.19 50.53,23.33 50.32,23.33 50.27,23.38 50.27,23.98 50.33,24.04 51.04,24.04 51.27,24.28 52.4,24.28
+1.8V_MEM on IN1 (solid shape): 95.33,21.9 95.33,21.18 95.16,21.01 94.19,21.01 94.06,21.14 94.06,22.09 94.21,22.25 94.98,22.25
+1.8V_MEM on TOP: 59.03,19.58 58.65,19.96 57.89,19.96 57.81,20.03 57.81,20.78 57.93,20.89 57.93,21.4 58.01,21.48 58.39,21.48 58.77,21.86 58.77,24.91 58.9,25.04 60.43,25.04 60.55,24.91 60.55,19.7 60.43,19.58
+1.8V_MEM on TOP: 84.05,19.74 83.54,19.23 83.54,18.94 83.29,18.69 81.38,18.69 80.62,17.93 71.47,17.93 70.84,18.56 70.46,18.56 70.2,18.81 70.2,24.78 70.46,25.04 71.86,25.04 72.11,24.78 72.11,22.62 72.36,22.37 83.79,22.37 84.05,22.12
+1.8V_MEM on TOP: 118.66,19.83 119.42,19.83 119.54,19.96 119.54,21.35 119.82,21.63 119.82,22.5 119.06,22.5 119.06,22.14 118.53,21.61 118.53,19.96
+1.8V_MEM on TOP: 119.93,30.52 120.71,30.52 120.79,30.45 120.79,29.03 120.69,28.92 119.26,28.92 119.06,29.13 119.06,29.66
+1.8V_MEM on TOP: 93.95,18.81 93.74,19.02 93.74,24.7 93.88,24.84 96.15,24.84 96.26,24.73 96.26,19.77 95.3,18.81
+1.8V_MEM on BOTTOM: 81.89,20.21 71.73,20.21 70.97,19.45 70.46,19.45 70.2,19.7 70.2,19.96 69.95,20.21 63.73,20.21 62.33,18.81 58.01,18.81 57.89,18.94 57.89,25.25 58.69,26.05 62.56,26.05 63.49,25.12 63.5,25.12 63.63,24.99 66.91,24.99 67.97,26.05 83.16,26.05 84.17,25.04 90.14,25.04 91.03,25.93 94.46,25.93 94.56,25.83 94.56,25.51 94.86,25.21 94.86,21.87 95.33,21.39 95.75,21.39 96.53,20.61 96.53,19.78 96.46,19.7 94.08,19.7 92.56,21.23 87.48,21.23 84.94,18.69 83.41,18.69
+1.8V_MEM on IN1: 118.81,20.69 119.09,20.69 119.54,20.24 119.54,19.96 119.42,19.83 118.27,19.83 118.05,20.06 117.44,20.06 117.44,20.62 117.64,20.82 118.68,20.82
+1.8V_MEM_R on TOP: 121.39,30.8 121.42,30.83 123.18,30.83 123.26,30.74 123.26,30.08 123.2,30.02 122.49,30.02 122.06,29.58 121.45,29.58 121.39,29.64
+1.8V_PRIM on BOTTOM (solid shape): 111.95,45.54 111.95,45.15 111.87,45.08 110.07,45.08 109.97,45.18 109.13,45.18 109.05,45.26 109.05,45.54 109.16,45.64 111.85,45.64
+1.8V_PRIM on BOTTOM (solid shape): 123.25,28.62 123.25,27.96 123.14,27.84 122.88,27.84 122.87,27.83 121.37,27.83 121.22,27.98 121.22,28.57 121.32,28.67 123.2,28.67
+1.8V_PRIM on BOTTOM (solid shape): 116.98,33.69 116.98,31.42 116.93,31.37 116.01,31.37 116,31.38 116,31.92 116,31.92 115.25,31.92 115.25,31.92 115.25,31.37 115.25,31.37 114.81,31.37 114.8,31.37 114.8,31.91 114.79,31.92 114.06,31.92 114.05,31.91 114.06,31.38 114.05,31.38 113.24,31.38 113.11,31.5 113.11,32.29 113.72,32.9 113.72,33.73 113.85,33.86 116.8,33.86
+1.8V_PRIM on TOP: 121.3,27.88 123.05,27.88 123.26,28.09 123.26,28.72 123.21,28.77 122.16,28.77 121.93,28.54 121.2,28.54 121.14,28.49 121.14,28.03
+1.8V_PRIM on TOP: 112.76,39.52 112.61,39.67 112.61,41.04 111.64,42 108.29,42 108.09,41.8 103.67,41.8 102.93,41.06 101.75,41.06 101.38,41.42 101.38,41.67 100.49,42.56 99.22,42.56 99.1,42.69 99.1,44.21 99.22,44.34 100.75,44.34 102.78,42.31 106.84,42.31 107.38,42.85 107.38,43.61 107.33,43.66 106.79,43.66 106.69,43.76 106.18,43.76 106.01,43.94 106.01,43.99 105.7,44.29 104.65,44.29 104.38,44.56 103.65,44.56 103.16,45.05 103.16,45.59 103.31,45.74 104.69,45.74 105.35,45.08 107.27,45.08 107.58,45.38 107.61,45.36 108.11,45.36 109.13,46.37 109.16,46.37 109.94,47.16 112.66,47.16 117.39,42.43 117.39,39.76 117.14,39.52 ; 2 cut-outs
+1.8V_PRIM on BOTTOM: 113.27,41.61 113.17,41.71 113.17,44.7 113.27,44.8 113.64,44.8 113.7,44.74 113.7,41.69 113.62,41.61
+1.8V_PRIM on IN1: 103,44.2 103,47.02 103.08,47.1 104.12,47.1 104.26,46.96 104.26,44.29 104.26,44.25 104.12,44.11 103.1,44.11
+1.8V_PRIM on IN2: 121.07,27.96 121.7,27.96 121.83,28.09 121.83,32.53 120.43,33.93 118.02,33.93 116.37,35.58 116.37,40.79 113.45,43.71 109.89,43.71 109.38,43.2 109.38,41.42 112.46,38.35 113.4,38.35 113.63,38.58 113.63,39.87 113.47,40.02 112.94,40.02 112.56,40.4 112.56,41.67 112.69,41.8 113.07,41.8 114.08,40.79 114.08,32.75 114.93,31.9 117.39,31.9 120.94,28.34 120.94,28.09
+1.8V_PRIM on VCC: 107.03,31.26 107.03,38.5 110.63,38.5 113.07,40.93 113.07,42.84 113.3,43.07 119.29,43.07 119.29,35.18 115.37,31.26
+1.8V_PRIM on IN3: 103.16,47.14 104.05,47.14 104.17,47.01 104.17,44.14 103.99,43.96 102.95,43.96 102.84,44.06 102.84,45.55 102.91,45.61 102.91,46.88
+1.8V_PRIM on IN3: 113.19,43.6 113.19,42.39 113.42,42.16 113.7,42.44 113.7,44.27 113.63,44.34 113.22,44.34 113.17,44.29 113.17,43.63
+1.8V_PRIMP on BOTTOM (solid shape): 114.64,31.21 115.4,31.21 115.4,31.77 115.85,31.77 115.85,31.26 116.88,31.26 117.02,31.12 117.02,29.88 116.85,29.72 114.15,29.72 114.06,29.62 114.06,27.51 113.96,27.41 112.79,27.41 112.4,27.02 112.4,26.47 111.73,25.8 108.94,25.8 108.69,26.05 108.69,27.32 108.94,27.58 109.57,27.58 109.83,27.83 109.83,29.8 111.29,31.26 114.21,31.26 114.21,31.77 114.64,31.77
+1.8V_PRIMR on TOP: 226.85,50.49 227.89,50.49 228.07,50.31 228.07,49.04 227.94,48.91 225.61,48.91 225.5,49.03 225.5,50.29 225.6,50.38 226.74,50.38
+1.8V_PRIMR_RIGHT on TOP: 227.15,46.14 226.8,46.5 226.8,48.32 227.01,48.53 227.94,48.53 228.12,48.72 228.9,48.72 228.95,48.66 228.95,46.42 228.67,46.14
+1.8VS on TOP (solid shape): 280.86,12.32 281.61,12.32 281.83,12.1 282.56,12.1 282.64,12.02 282.64,11.33 282.54,11.24 281.09,11.24 280.8,11.53 280.8,11.54 280.38,11.96 280.17,11.96 280.04,12.09 280.04,12.52 280.15,12.63 280.55,12.63
+1.8VS on TOP: 222.63,48.87 222.7,48.79 222.7,48.12 222.6,48.02 222.27,48.02 222.15,47.91 222.15,47.44 222.07,47.36 221.37,47.36 221.08,47.65 221.08,48.66 221.29,48.87
+1.8VS_AUDIO_R on TOP (solid shape): 283,15.56 283,14.95 282.64,14.59 282.64,13.55 282.55,13.46 281.72,13.46 281.53,13.65 281.53,15.29 281.83,15.6 282.96,15.6
+1.8VS_R on TOP: 221.81,50.31 223.31,50.31 223.39,50.38 224.06,50.38 224.13,50.31 224.13,49.42 223.87,49.17 223.01,49.17 222.68,49.5 221.7,49.5 221.68,49.52 221.68,50.19
+3.3V_LDO_PD_A on TOP: 28.03,62.58 30.31,62.58 31.03,61.87 31.56,61.87 32.28,61.14 32.9,61.14 33.15,61.38 34.68,61.38 34.8,61.5 34.8,61.73 34.7,61.83 34.7,61.97 34.52,62.15 32.6,62.15 31.81,62.93 31.81,63.47 31.66,63.62 30.92,63.62 30.59,63.29 28,63.29 27.82,63.11 27.82,62.78
+3.3V_LDO_PD_A on TOP: 24.6,64.91 24.99,64.91 25.08,64.82 25.08,64.52 25.91,63.7 26.4,63.7 26.54,63.56 26.54,63.24 26.38,63.08 24.77,63.08 24.77,63.08 23.96,63.08 23.83,62.95 23.83,62.45 23.92,62.37 24.29,62.37 24.45,62.21 24.45,61.37 24.3,61.23 23.92,61.23 23.83,61.14 23.83,60.66 23.98,60.51 24.33,60.51 24.45,60.38 24.45,60.08 24.35,59.98 23.71,59.98 23.38,60.31 23.38,62.54 23.31,62.61 23.31,63.62
+3.3V_TBT_FLASH on TOP: 30.42,50.81 31.47,50.81 31.54,50.74 31.54,50.02 31.05,49.53 31.05,48.57 31.23,48.39 33.06,48.39 33.17,48.5 33.17,49.55 32.92,49.8 32.92,50.81 32.98,50.87 34.03,50.87 34.1,50.81 34.1,50.06 33.62,49.59 33.62,48.71 33.72,48.61 33.72,48.6 33.86,48.46 34.92,48.46 35.08,48.3 35.08,46.42 35.63,45.87 35.63,42.63 34.91,41.91 34.91,41.21 34.74,41.04 34.06,41.04 33.9,41.19 32.68,41.19 32.64,41.23 32.64,42.1 33.17,42.63 33.17,43.63 32.79,44.01 29.72,44.01 29.43,44.31 29.43,49.73 29.94,50.24 30.3,50.24 30.34,50.29 30.34,50.59 30.34,50.6 30.34,50.73
+3V_1.8V_HDA on IN2: 98.84,38.88 99.73,38.88 99.99,39.13 99.99,39.64 100.24,39.9 102.02,39.9 102.91,40.79 102.91,43.83 102.15,44.6 98.59,44.6 98.21,44.21 98.21,42.56 98.34,42.44 99.61,42.44 99.86,42.18 99.86,41.04 98.59,39.77 98.59,39.13
+3V_5105 on TOP: 267,63.62 267.44,63.62 267.49,63.56 267.49,62.56 267.3,62.37 267.3,61.48 267.2,61.37 267.2,61.09 267.68,60.61 267.68,60.31 267.63,60.26 267.24,60.26 267.2,60.29 267.2,60.63 266.87,60.96 266.87,61.36 266.61,61.61 266.61,62.8 266.95,63.14 266.95,63.57
+3V_FPR on BOTTOM (solid shape): 303.51,65.56 303.51,64.04 303.37,63.9 302.68,63.9 302.55,64.03 302.55,64.66 302.42,64.79 301.03,64.79 300.9,64.92 300.9,65.42 301.15,65.68 303.4,65.68
+3V_LDO on BOTTOM (solid shape): 15.91,72.28 15.91,71.46 16.12,71.25 16.12,70.32 16.75,69.69 16.75,69.15 16.58,68.98 16.04,68.98 15.8,69.22 15.8,69.49 15.2,70.08 14.87,70.08 14.81,70.15 14.81,71.23 14.39,71.65 14.39,72.28 14.52,72.41 15.79,72.41
+3V_LDOP on BOTTOM (solid shape): 13.82,72.97 13.82,69.81 13.37,69.36 12.64,69.36 12.44,69.57 12.44,72.98 12.63,73.17 13.63,73.17
+3V_PCH on TOP (solid shape): 109.45,41.69 109.45,40.09 109.37,40.01 108.95,40.01 108.87,40.1 108.87,41.32 108.8,41.38 108.8,41.69 108.89,41.79 109.36,41.79
+3V_PCH on TOP (solid shape): 128,31.13 128,30.76 128.09,30.67 128.46,30.67 128.52,30.6 128.52,28.46 128.34,28.29 127.93,28.29 127.37,28.84 127.37,29.99 127.22,30.15 127.22,31.19 127.24,31.21 127.93,31.21
+3V_PCH on BOTTOM (solid shape): 106.92,27.65 106.92,27.22 107.1,27.04 107.1,26.69 107.05,26.64 105.85,26.64 105.78,26.71 105.78,27.07 105.85,27.15 106.29,27.15 106.44,27.3 106.44,27.68 106.46,27.7 106.87,27.7
+3V_PCH on BOTTOM (solid shape): 112.59,48.26 112.94,48.26 112.97,48.23 112.97,48.21 113.17,47.98 113.46,48.08 113.83,48.08 113.95,47.96 113.95,47.45 112.69,46.2 112.1,46.2 112.06,46.24 112.06,47.09 112.13,47.16 112.49,47.16 112.58,47.25 112.58,47.73 112.44,47.87 112.1,47.87 112.06,47.92 112.06,48.26 112.1,48.3 112.54,48.3
+3V_PCH on BOTTOM (solid shape): 115.34,42.98 115.34,42.44 115.63,42.14 115.63,40.16 113.28,37.81 111.29,37.81 110.96,37.48 109.21,37.48 109.08,37.61 109.08,37.86 109.23,38.02 110.32,38.02 110.65,38.35 111.97,38.35 112.09,38.46 112.09,38.83 112.18,38.92 112.61,38.92 112.7,39.01 112.7,39.35 112.8,39.45 113.4,39.45 114.72,40.77 114.72,41.52 114.37,41.87 114.37,42.89 114.51,43.03 115.29,43.03
+3V_PCH on TOP: outline of 105 points within 99.1,42.08 124.29,53.62
+3V_PCH on BOTTOM: 100.74,42.04 101.96,43.26 101.96,45.97 102.21,46.22 103.95,46.22 104.3,45.87 104.3,41.29 104.09,41.08 97.08,41.08 96.99,41.17 96.99,41.9 97.13,42.04
+3V_PCH on IN1: 102.36,41.56 102.36,42.78 102.53,42.94 104.42,42.94 104.51,42.86 104.51,41.95 103.97,41.42 102.5,41.42
+3V_PCH on VCC: 101.26,25.29 101.26,25.95 101.74,26.43 104.79,26.43 105.3,26.94 106.25,26.94 107.03,27.73 107.03,30.75 115.59,30.75 119.8,34.97 119.8,43.22 121.68,45.1 124.81,45.1 124.81,35.09 125.47,34.44 127.76,34.44 127.86,34.33 127.86,33.91 127.76,33.8 122.17,33.8 113.66,25.29
+3V_PCH on IN3: 104.56,40.26 104.54,40.28 100.14,40.28 99.86,40.56 99.86,41.29 99.61,41.55 99.61,41.93 99.76,42.08 102.07,42.08 102.22,42.23 102.22,42.89 102.36,43.03 104.06,43.03 104.34,42.76 104.34,41.71 104.24,41.61 104.24,41.26 104.25,41.25 104.25,41.04 104.36,40.93 105.42,40.93 105.63,40.72 105.63,40.4 105.49,40.26
+3V_PCH_DSW on TOP (solid shape): 98.79,41.29 98.79,40.86 98.89,40.76 99.02,40.76 99.1,40.68 99.1,40.33 99.02,40.25 98.64,40.25 98.59,40.3 98.59,40.73 98.51,40.81 98.11,40.81 98,40.91 98,41.24 98.13,41.37 98.72,41.37
+3V_PCH_DSW on IN1 (solid shape): 98.89,41.9 98.84,41.7 98.36,41.07 98.41,40.89 98.56,40.73 98.92,40.73 99.02,40.63 99.02,40.56 98.92,40.46 98.23,40.46 97.85,40.84 97.85,40.96 97.88,40.99 97.93,41.17 98.59,42.06 98.77,42.06
+3V_PCH_DSW on IN3: 98.8,42.1 98.91,41.99 98.91,41.71 98.47,41.28 98.47,41.02 98,40.55 97.72,40.55 97.65,40.61 97.65,40.93 98.13,41.41 98.13,41.61 98.62,42.1
+3V_PCH_R on TOP: 124.65,31.06 124.65,30.09 124.73,30.02 126.43,30.02 126.54,30.13 126.54,31.13 126.48,31.18 124.78,31.18
+3V_SPI on TOP (solid shape): 102.76,12.92 103.25,12.92 103.85,12.31 104.38,12.31 104.51,12.44 106.31,12.44 106.54,12.21 106.54,11.68 106.44,11.58 103.06,11.58 102.13,12.51 101.84,12.51 101.8,12.55 101.8,13.06 101.85,13.1 102.57,13.1
+3V_SPI on BOTTOM (solid shape): 104.94,12.39 104.94,11.32 104.86,11.25 104.15,11.25 104.08,11.32 104.08,12.41 104.1,12.44 104.89,12.44
+3V_SSD on TOP (solid shape): 214.3,64.93 214.3,63.96 214.09,63.75 212.99,63.75 212.87,63.87 212.87,64.81 213.15,65.08 214.14,65.08
+3V_SSD on TOP: 213.08,62.5 214.77,62.5 216.29,64.03 222.95,64.03 223.2,63.77 223.2,62.48 223.03,62.3 223.03,61.24 222.93,61.14 222.43,61.14 222.29,61.28 222.29,61.67 222.12,61.85 221.57,61.85 221.46,61.74 221.46,61.58 221.36,61.48 218.52,61.48 217.26,60.22 214.73,60.22 214.48,59.96 212.95,59.96 212.83,60.09 212.83,62.25
+3V_SSD on TOP: 215.55,45.83 215.55,47.14 215.18,47.52 212.95,47.52 212.83,47.39 212.83,45.92 212.73,45.83 212.35,45.83 212.19,45.67 212.19,44.98 212.32,44.85 212.32,44.85 212.35,44.83 214.54,44.83
+3V_SSD on BOTTOM: 212.06,46.12 214.73,46.12 214.86,46.25 214.86,47.39 214.73,47.52 212.06,47.52 211.94,47.39 211.94,46.25
+3V_SSD on BOTTOM: 214.34,65.42 216.76,63 216.76,60.47 216.38,60.09 210.41,60.09 210.03,60.47 210.03,63.52 211.94,65.42 ; 1 cut-out
+3V_SSD on IN1: 213.59,47.01 214.74,47.01 214.87,47.14 214.87,47.39 214.51,47.75 214.51,49.26 213.46,50.31 213.46,58.69 215.49,60.72 215.49,61.61 214.98,62.12 213.97,62.12 211.94,60.09 211.94,48.66
+3V_TBT on TOP (solid shape): 20.52,62.13 20.52,60.2 20.68,60.04 20.68,59.59 20.73,59.54 21.62,59.54 21.67,59.49 21.67,58.83 21.59,58.76 20.6,58.76 20.14,59.21 19.56,59.21 19.56,58.65 19.56,58.65 19.56,58.27 19.47,58.19 18.95,58.19 18.88,58.26 18.26,58.26 18.17,58.17 18.17,57.74 18.31,57.61 18.71,57.61 18.88,57.44 19.41,57.44 19.46,57.39 19.46,56.6 19.35,56.5 18.93,56.5 18.82,56.39 18.82,55.8 19.04,55.58 19.04,54.77 18.98,54.71 17.11,54.71 17.09,54.73 16.92,54.73 16.81,54.85 16.81,55.51 17.26,55.96 17.26,58.07 17.91,58.71 18.55,58.71 18.73,58.9 18.73,59.62 18.81,59.7 19.46,59.7 19.59,59.83 19.59,61.71 19.59,61.71 19.59,62.11 19.73,62.24 20.41,62.24
+3V_TBT_S0 on TOP (solid shape): 25.1,50.8 24.57,50.8 24.57,51.31 24.52,51.36 24.15,51.36 24.04,51.47 24.04,51.82 25.1,51.82
+3V_TBT_S0 on TOP: 18.96,54.03 18.96,53.81 19.28,53.49 19.28,50.31 19.15,50.18 18.8,50.18 18.39,49.77 18.39,47.9 18.94,47.35 21.91,47.35 22.75,48.19 26.22,48.19 26.36,48.32 27.03,48.32 27.21,48.15 27.21,47.44 26.94,47.17 26.09,47.17 25.85,47.41 23.74,47.41 23.61,47.29 23,47.29 22.17,46.46 18.55,46.46 17.53,47.49 17.53,50.08 18.26,50.81 18.26,52.72 17.88,53.1 17.88,53.11 17.68,53.31 17.68,53.99 17.8,54.11 18.88,54.11
+3V_TBT_S0 on IN2: 26.24,52.54 26.24,54.63 25.81,55.06 25.81,56.21 26.24,56.64 26.24,59.61 27.51,60.89 27.51,60.89 28.63,62 28.97,62 29.15,61.81 29.15,60.25 27.21,58.31 27.21,47.58 27.1,47.48 26.07,47.48 25.88,47.67 25.88,47.83 25.05,48.66 25.05,50.23 25.05,50.84 24.83,51.06 24.42,51.06 24.28,51.2 24.28,51.82 24.36,51.9 25.59,51.9
+3V_WLAN on TOP (solid shape): 253.33,36.26 253.33,36.11 253.38,36.05 254.33,36.05 254.34,36.04 254.34,34.87 254.23,34.75 253.02,34.75 252.7,34.44 252.7,32.02 252.2,31.51 250.67,31.51 250.42,31.77 250.42,34.75 252.01,36.34 253.25,36.34
+3V_WLAN on TOP: 217.91,24.4 217.91,30.21 217.75,30.37 217.75,41.24 217.54,41.45 216.45,41.45 216.29,41.29 216.29,40.7 215.77,40.17 215.64,40.17 215.54,40.08 215.54,36.67 214.73,35.86 214.73,26.69 215.62,25.8 215.62,22.24 216.25,21.61 216.27,21.61 216.5,21.38 218.27,21.38 218.77,21.88 218.77,23.54
+3V_WLAN on BOTTOM: 216.58,21.48 218.36,21.48 218.59,21.71 218.59,22.6 218.49,22.7 216.43,22.7 216.08,22.35 216.08,21.99
+3V_WLAN on BOTTOM: 216.67,39.39 218.48,39.39 218.55,39.46 218.55,40.46 217.69,41.32 216.57,41.32 216.42,41.17 216.42,39.64
+3V_WLAN on IN1: 250.42,32.72 252.26,32.72 252.39,32.59 252.39,30.82 252.01,30.44 252.01,27.9 249.02,24.91 235.18,24.91 233.15,26.94 233.15,30.37 232.19,31.32 220.51,31.32 219.4,30.21 218.38,30.21 217.78,29.61 217.52,29.61 217.33,29.8 217.33,31.71 218.6,32.98 236.89,32.98 242.23,27.64 245.34,27.64
+3V_WWAN on TOP: 256.44,31.21 255.75,31.9 255.75,35.58 255.88,35.71 255.88,36.09 256.01,36.21 256.89,36.21 257,36.32 257.55,36.32 257.66,36.21 257.66,35.58 257.28,35.2 257.28,34.18 257.4,34.05 258.42,34.05 258.55,33.93 258.55,31.36 258.39,31.21
+3V_WWAN on TOP: 273.4,34.69 274.29,34.69 274.93,34.05 276.33,34.05 276.58,33.8 276.58,31.9 276.33,31.64 274.8,31.64 274.67,31.77 274.67,32.28 274.42,32.53 273.53,32.53 273.28,32.78 273.28,34.56
+3V_WWAN on BOTTOM: 273.62,33.67 276.2,33.67 276.33,33.55 276.33,31.16 275.92,30.75 274.9,30.75 274.74,30.92 274.74,32.39 274.59,32.53 273.39,32.53 273.24,32.68 273.24,33.29
+3V_WWAN on IN1: 258.42,33.8 258.55,33.67 258.55,32.59 258.27,32.31 258.27,32.04 258.18,31.95 257.38,31.95 255.98,33.34 255.98,33.71 256.07,33.8
+3V_WWAN on IN2: 271.09,34.47 272.26,33.29 274.69,33.29 275.47,32.51 275.47,30.71 275.01,30.24 275.01,29.27 274.66,28.92 271.47,28.92 270.99,28.44 260.77,28.44 257.21,32 257.21,33.04 258.41,34.24 261.11,34.24 261.69,34.82 264.18,34.82 264.53,34.47
+3V_WWAN on IN3: 257.4,32.4 258.16,32.4 258.29,32.28 258.29,32.02 258.55,31.77 258.55,31.57 258.47,31.49 257.71,31.49 257.3,31.9 257.3,32.3
+3VA_TBT on TOP (solid shape): 23.24,61.54 23.24,59.98 23.09,59.84 23.09,58.77 23.02,58.7 22.67,58.7 22.61,58.64 22.61,57.75 22.64,57.72 23.03,57.72 23.09,57.65 23.09,56.73 22.95,56.59 22.01,56.59 21.97,56.63 21.97,57.05 21.9,57.12 21.52,57.12 21.52,57.11 21.36,57.11 21.36,56.95 20.6,56.2 20.6,54.61 20.74,54.47 21.16,54.47 21.22,54.42 21.22,54.03 21.16,53.98 20.08,53.98 20,54.06 20,55.22 20,55.48 20,56.41 19.74,56.67 19.74,57.37 19.79,57.43 21.05,57.43 21.12,57.5 21.12,58.09 21.82,58.79 21.82,59.7 22.25,60.13 22.25,61.58 22.35,61.68 23.1,61.68
+3VA_TBT on BOTTOM: 25.02,60.83 26.21,60.83 26.29,60.92 26.29,62.43 26.15,62.57 24.95,62.57 24.88,62.51 24.88,62.13 24.98,62.04 25.33,62.04 25.45,61.92 25.45,61.54 25.33,61.42 24.93,61.42 24.84,61.33 24.84,61.01
+3VA_TBT on IN2: 24.16,59.65 22.01,59.65 21.79,59.87 21.79,61.28 22.29,61.78 23.67,61.78 23.85,61.96 27.9,61.96 28.01,61.85 28.01,61.65 26.29,59.93 24.44,59.93
+3VA_TBT on IN3: 21.65,61.4 21.91,61.4 22.08,61.57 22.78,61.57 23.01,61.33 23.01,61.05 22.89,60.93 22.71,60.93 22.71,60.92 22.47,60.68 22.47,60.5 22.12,60.15 22.12,59.56 22.04,59.48 21.5,59.48 21.43,59.55 21.43,60.61 21.65,60.82 21.65,60.85 21.56,60.94 21.56,61.3
+3VA_TBT on IN3: 26.56,60.53 26.01,61.08 24.54,61.08 24.46,61.16 24.46,61.52 24.93,61.99 24.93,62.38 25.07,62.52 25.27,62.52 25.5,62.29 25.76,62.29 25.99,62.52 27.2,62.52 27.44,62.29 29.7,62.29 29.75,62.24 29.89,62.24 30.52,61.61 30.52,59.18 30.03,58.69 30.03,57.85 30.05,57.85 30.28,57.61 30.78,57.61 30.92,57.47 30.92,57.04 30.63,56.75 29.23,56.75 29.01,56.97 29.01,56.98 28.87,57.11 28.87,57.41 28.87,57.41 28.61,57.66 28.31,57.66 27.14,58.83 27.14,59.05 26.56,59.62 26.56,60.09 26.56,60.09
+3VA_TBT_LC on IN3: 26.66,54.98 26.37,54.69 24.61,54.69 24.43,54.87 24.43,55.24 24.54,55.35 24.77,55.35 24.84,55.28 25.6,55.28 25.73,55.41 25.73,55.92 26.01,56.19 26.01,58.13 25.13,59 24.96,59 24.8,59.16 24.8,59.19 24.8,60.45 24.85,60.5 25.16,60.5 25.46,60.19 25.46,60.15 26.66,58.95
+3VALW on TOP (solid shape): 256.7,42.02 256.7,40.65 256.39,40.33 255.9,40.33 255.8,40.43 255.8,42.11 256.03,42.33 256.39,42.33
+3VALW on TOP (solid shape): 34.54,53.45 34.54,51.99 34.28,51.74 33.43,51.74 33.36,51.81 33.36,53.42 33.52,53.57 34.41,53.57
+3VALW on TOP (solid shape): 132.03,42.06 132.03,41.59 131.46,41.01 131.41,41.01 130.61,41.81 130.61,43.03 130.69,43.12 130.96,43.12
+3VALW on TOP (solid shape): 224.45,58.26 224.45,57.4 225.16,56.69 225.16,56.15 225.11,56.1 224.62,56.1 224.34,56.38 222.9,56.38 222.64,56.64 222.64,57.93 223.05,58.34 224.37,58.34
+3VALW on TOP (solid shape): 31.17,53.88 31.17,51.79 31.11,51.73 30.71,51.73 30.64,51.8 30.64,53.88 30.73,53.97 31.09,53.97
+3VALW on TOP (solid shape): 130.35,37.12 130.35,36.72 130.06,36.43 128.42,36.43 128.29,36.56 128.29,36.71 128.38,36.8 129.22,36.8 129.36,36.94 129.36,37.15 129.53,37.32 130.15,37.32
+3VALW on TOP (solid shape): 127.49,35.81 127.49,35.64 128.35,34.78 129.2,34.78 129.23,34.74 129.23,34.5 129.2,34.46 128.03,34.46 127.84,34.65 127.18,34.65 126.77,35.06 126.77,35.85 126.88,35.96 127.34,35.96
+3VALW on TOP (solid shape): outline of 263 points within 130.47,20.25 197.2,43.2
+3VALW on BOTTOM (solid shape): 131.2,43.11 131.2,42.12 131.01,41.93 130.62,41.93 130.05,42.5 130.05,43.54 130.12,43.62 130.69,43.62
+3VALW on BOTTOM (solid shape): 117.96,49.1 117.96,48.08 117.47,47.59 117.47,45.04 118.01,44.51 118.68,44.51 118.82,44.37 118.82,44.01 118.72,43.91 118.1,43.91 117.93,43.74 117.93,42.21 117.91,42.18 116.94,42.18 116.83,42.3 116.83,43.92 116.5,44.24 116.5,46.59 116.25,46.84 116.25,48.05 117.37,49.17 117.89,49.17
+3VALW on BOTTOM (solid shape): 128.3,35.42 128.3,34.09 128.27,34.06 128.27,33.4 128,33.13 126.59,33.13 126.45,33.28 126.45,34.03 127.14,34.03 127.14,33.98 127.15,33.92 127.17,33.87 127.2,33.83 127.23,33.79 127.27,33.75 127.32,33.72 127.36,33.7 127.41,33.68 127.47,33.67 127.52,33.67 127.57,33.68 127.62,33.7 127.67,33.72 127.72,33.75 127.76,33.79 127.79,33.83 127.82,33.87 127.84,33.92 127.85,33.98 127.85,34.03 127.85,34.08 127.84,34.13 127.82,34.18 127.79,34.23 127.76,34.27 127.72,34.31 127.67,34.34 127.62,34.36 127.57,34.38 127.52,34.39 127.47,34.39 127.41,34.38 127.36,34.36 127.32,34.34 127.27,34.31 127.23,34.27 127.2,34.23 127.17,34.18 127.15,34.13 127.14,34.08 127.14,34.03 126.45,34.03 126.45,35.17 127.19,35.91 127.81,35.91
+3VALW on IN1 (solid shape): 254.32,42.17 254.32,41.05 254.19,40.93 253.5,40.93 253.4,41.03 253.4,42.17 253.54,42.31 254.18,42.31
+3VALW on IN2 (solid shape): 131.28,42.87 131.28,42.13 130.91,41.76 130.77,41.76 129.7,42.83 129.7,43.45 129.89,43.64 130.5,43.64
+3VALW on IN2 (solid shape): 50.8,71.99 50.8,71.65 50.7,71.54 50.25,71.54 49.46,72.33 49.46,72.6 49.6,72.73 50.06,72.73
+3VALW on IN3 (solid shape): 256.86,42.71 256.86,41.81 256.7,41.65 254.94,41.65 254.22,40.94 253.1,40.94 252.98,41.06 252.98,42.54 253.37,42.94 256.64,42.94
+3VALW on TOP: 125.3,27.53 125.01,27.83 124.74,27.83 124.64,27.93 124.64,28.72 124.7,28.78 125.48,28.78 125.57,28.86 127.06,28.86 127.74,28.19 127.74,27.84 127.63,27.74 127.08,27.74 126.92,27.9 126.92,28.14 126.8,28.26 126.52,28.26 126.31,28.06 126.31,27.77 126.07,27.53
+3VALW on TOP: 239.4,69.19 239.33,69.26 239.33,71.94 238.86,72.41 238.03,72.41 238.03,72.41 232.33,72.41 232.29,72.45 232.29,73.7 232.39,73.81 240.39,73.81 240.67,73.52 240.67,69.24 240.62,69.19
+3VALW on TOP: 275.31,58.82 275.44,58.69 275.86,58.69 275.94,58.78 275.94,59.19 275.98,59.23 276.61,59.23 276.71,59.33 276.71,59.58 276.83,59.71 277.09,59.71 277.09,59.7 277.42,59.7 277.49,59.63 277.49,58.63 277.21,58.35 277.21,57.17 277.09,57.04 276.58,57.04 276.2,57.42 275.65,57.42 275.59,57.49 275.59,58.54 275.56,58.57 274.92,58.57 274.74,58.75 274.74,59.22 274.77,59.25 275.23,59.25 275.31,59.17
+3VALW on TOP: 254.35,41.93 254.35,42.18 254.23,42.31 253.21,42.31 253.08,42.18 253.08,40.53 253.21,40.4 254.35,40.4 254.48,40.53 254.48,41.8
+3VALW on TOP: 43.35,70.96 42.82,71.48 42.74,71.48 42.73,71.49 41.82,71.49 41.74,71.56 41.74,72.13 42.16,72.55 42.71,72.55 43.01,72.86 44.01,72.86 44.04,72.83 44.04,72.13 43.92,72.01 43.92,71.03 43.85,70.96
+3VALW on TOP: 62.37,62.41 62.37,62.97 62.38,62.99 62.48,63.09 63,63.09 63.35,62.74 63.35,61.76 63.59,61.52 65.01,61.52 65.16,61.67 65.16,62.28 64.71,62.74 64.71,63.26 65.11,63.67 65.11,64.33 64.67,64.77 64.4,64.77 63.85,65.31 63.13,65.31 62.99,65.45 62.99,65.86 63.12,65.98 64.36,65.98 64.93,65.41 68.01,65.41 68.24,65.64 68.88,65.64 69.03,65.49 69.03,65.14 68.57,64.68 66.45,64.68 65.78,64.01 65.78,63.56 65.5,63.28 65.5,63.01 66.18,62.33 66.18,61.27 66.18,61.26 66.18,61.08 65.9,60.8 63.08,60.8 62.78,61.11 62.78,62.01
+3VALW on BOTTOM: 18.11,20.12 18.69,20.12 19.02,19.79 19.02,18.99 18.81,18.78 18.68,18.78 18.03,19.42 18.03,20.05
+3VALW on BOTTOM: 189.83,38.22 191.43,38.22 191.48,38.17 191.48,37.72 191.5,37.69 192.19,37.69 192.21,37.72 192.21,38.25 192.67,38.25 192.67,37.72 192.7,37.69 193.38,37.69 193.41,37.72 193.41,38.22 193.43,38.25 194.5,38.25 194.58,38.17 194.58,35.86 194.4,35.68 189.85,35.68 189.75,35.78 189.75,38.15
+3VALW on IN1: 276.71,57.68 276.96,57.68 277.09,57.55 277.09,57.17 277.21,57.04 277.6,57.04 277.72,56.91 277.72,56.41 277.6,56.28 276.96,56.28 276.45,56.79 276.45,57.42
+3VALW on IN1: 255.69,41.76 255.93,41.52 255.93,41.19 256.08,41.04 256.62,41.04 256.62,41.04 261,41.04 261.19,41.23 261.19,42.4 261.01,42.58 257.25,42.58 257.05,42.77 255.42,42.77 254.97,42.32 254.97,41.97 255.17,41.76
+3VALW on VCC: 100.15,17.8 100.05,17.9 100.05,19.85 100.81,20.61 100.81,23.15 100.92,23.26 106.42,23.26 106.93,22.75 108.85,22.75 109.62,23.51 114.57,23.51 121.05,29.99 122.25,29.99 124.03,31.77 126.32,31.77 126.85,32.3 126.85,33.29 127.97,33.29 128.37,33.7 128.37,34.54 127.97,34.94 125.68,34.94 125.32,35.3 125.32,45.1 133.05,45.1 154.95,22.09 185.02,32.34 186.4,32.34 187.5,33.16 188.46,34.64 189.33,36.18 189.55,37.54 188.91,38.76 190.81,44.6 191.45,50.71 191.45,71.14 229.44,71.14 230.58,72.28 278.36,72.28 278.36,56.51 263.52,41.93 223.52,41.93 222.5,40.91 217.57,40.91 212.93,45.55 202.31,45.55 193.65,36.89 193.65,34.82 191.38,34.82 190.79,34.22 190.79,33.02 180.59,22.88 174.37,22.88 174.29,22.8 172.74,22.2 170.47,21.45 168.96,21.07 167.19,20.69 165.18,20.44 163.54,20.31 160.51,20.31 158.75,20.44 157.74,20.56 156.1,20.82 153.96,21.32 152.7,21.7 151.57,22.08 149.17,23.09 148.42,23.46 147.46,24.03 147.34,24.15 124.92,24.15 122.89,26.18 119.25,26.18 115.16,22.09 115.16,20.32 114.04,19.2 104.39,19.2 102.99,17.8
+3VALW on VCC: 34.62,41.42 34.52,41.53 34.52,47.62 29.76,52.38 29.76,59.22 34.14,63.6 34.14,66.93 30.83,70.23 30.83,78.59 49.09,78.59 49.87,77.51 51.15,77.09 52.59,77.09 53.03,77.09 54.9,74.49 57.95,73.49 58.39,73.49 60.8,73.49 60.93,73.5 61.06,73.51 61.06,64.13 60.57,63.65 46.03,63.65 44.61,62.23 44.61,52.45 44.38,52.22 40.59,52.22 40.36,52.45 40.36,57.02 39.51,57.87 39,57.87 36.97,59.9 33.65,59.9 33.52,59.77 33.24,59.77 33.12,59.89 33.12,60.17 33.25,60.3 33.25,60.51 32.97,60.79 32.32,60.79 31.28,59.75 31.28,53.95 31.75,53.49 32.76,53.49 35.47,50.78 35.47,41.65 35.24,41.42 ; 1 cut-out
+3VALW_USH on BOTTOM (solid shape): 271.74,19.32 271.74,17.98 271.48,17.73 270.6,17.73 270.38,17.95 270.38,18.07 270.38,18.28 270.38,19.32 270.55,19.48 271.57,19.48
+3VALWP on BOTTOM (solid shape): 194.55,52.69 194.55,52.22 194.54,52.22 194.54,38.88 194.03,38.37 193.24,38.37 193.26,38.35 193.26,37.85 193.26,37.85 192.82,37.85 192.82,38.4 192.06,38.4 192.06,37.85 191.63,37.85 191.61,37.87 191.61,38.37 190.73,38.37 190.47,38.63 190.47,43.19 191.2,46.92 191.45,50.71 191.45,52.43 191.45,52.43 191.45,52.71 191.52,52.78 194.46,52.78
+3VS on TOP (solid shape): 265.56,42.16 265.56,40.46 265.45,40.35 265,40.35 264.72,40.63 264.72,42.23 264.77,42.28 265.43,42.28
+3VS on TOP (solid shape): 22.12,61.65 22.12,60.28 22.07,60.23 20.71,60.23 20.69,60.25 20.69,61.66 20.8,61.78 22,61.78
+3VS on TOP (solid shape): 47.71,71.65 47.71,69.96 47.56,69.81 47.02,69.81 46.75,70.09 46.75,71.57 46.93,71.75 47.61,71.75
+3VS on TOP (solid shape): 247.14,39.03 247.65,39.03 247.75,38.93 247.75,36.82 247.62,36.7 246.79,36.7 246.68,36.8 246.68,39.03 246.84,39.19 246.99,39.19
+3VS on TOP (solid shape): 205.27,33.92 205.27,33.24 205.04,33.01 203.85,33.01 203.06,32.23 201.54,32.23 201.45,32.31 201.45,33.96 201.77,34.28 204.91,34.28
+3VS on BOTTOM (solid shape): 229.32,72.48 229.32,71.3 229.1,71.07 228.66,71.07 228.46,71.27 228.46,72.46 228.56,72.55 229.24,72.55
+3VS on BOTTOM (solid shape): 61.15,62.46 61.15,61.01 60.7,60.56 59.84,60.56 59.47,60.93 59.47,62.13 59.82,62.48 61.12,62.48
+3VS on BOTTOM (solid shape): 186.22,14.31 186.22,13.67 186.47,13.42 187.24,13.42 187.36,13.29 187.36,12.66 187.24,12.53 185.46,12.53 185.36,12.63 185.36,14.33 185.46,14.43 186.09,14.43
+3VS on BOTTOM (solid shape): 14.33,40.67 14.33,37.78 13.55,36.99 12.79,36.99 12.35,37.44 12.35,38.05 12.82,38.52 12.82,39.45 11.63,40.64 11.63,41.61 11.9,41.88 13.12,41.88
+3VS on BOTTOM (solid shape): 192.43,34.05 192.43,33.33 191.15,32.05 190.61,32.05 190.46,32.2 190.46,32.76 190.56,32.86 190.8,32.86 191.37,33.43 191.37,34.03 191.55,34.2 192.28,34.2
+3VS on BOTTOM (solid shape): 113.36,51 113.36,50.56 113.17,50.36 113.17,48.58 113,48.42 112.61,48.42 112.11,48.92 112.11,50.96 112.17,51.02 113.34,51.02
+3VS on IN1 (solid shape): 32.77,27.87 32.77,26.91 32.56,26.7 31.66,26.7 31.45,26.91 31.45,27.79 31.74,28.09 32.55,28.09
+3VS on IN1 (solid shape): 205.65,35.2 205.65,34.37 204.57,33.29 204.44,33.29 204.38,33.36 204.38,33.68 204.86,34.16 204.86,34.35 205.08,34.56 205.08,35.09 205.29,35.31 205.54,35.31
+3VS on IN1 (solid shape): 22.08,62.03 22.08,61.63 22.13,61.57 22.13,61.29 22.03,61.18 21.55,61.18 21.43,61.29 21.19,61.29 21.03,61.45 21.03,61.78 21.03,61.79 21.03,61.98 21.24,62.18 21.93,62.18
+3VS on IN3 (solid shape): 13.65,37.84 13.65,36.88 13.52,36.75 12.78,36.75 12.58,36.95 12.58,37.77 12.76,37.95 13.54,37.95
+3VS on IN3 (solid shape): 13.88,44.96 13.88,42.28 12.62,41.02 12.06,41.02 11.66,41.43 11.66,42.32 12.33,43 12.33,44.8 12.78,45.25 13.58,45.25
+3VS on IN3 (solid shape): 17.52,23.35 17.52,21.24 17.41,21.13 16.74,21.13 16.62,21.25 16.62,21.45 16.67,21.51 16.67,23.47 16.77,23.57 17.31,23.57
+3VS on IN3 (solid shape): 32.97,27.72 32.97,27.16 32.64,26.83 30.9,26.83 30.14,26.07 30.14,25.62 27.57,23.05 20.76,23.05 18.67,25.15 18.67,25.86 18.92,26.12 19.87,26.12 21.54,24.45 27.03,24.45 28.76,26.18 28.76,26.74 30.11,28.09 32.59,28.09
+3VS on TOP: 31.93,27.27 31.76,27.44 31.76,28.13 31.93,28.3 38.47,28.3 38.63,28.15 38.63,27.47 38.42,27.27
+3VS on TOP: 17.04,21.48 16.88,21.64 16.88,23.64 17.87,24.64 17.87,25.2 18.24,25.57 19.12,25.57 19.34,25.36 19.34,22.93 17.89,21.48
+3VS on TOP: 286.41,41.47 286.78,41.47 286.93,41.32 286.93,39.66 285.95,38.68 284.94,38.68 284.87,38.74 284.87,39.59 284.97,39.69 285.12,39.69 285.32,39.88 285.32,40.46 285.44,40.58 285.86,40.58 286.08,40.8 286.08,41.14
+3VS on BOTTOM: 17.96,26.48 19.39,26.48 19.72,26.15 19.72,25.45 19.43,25.17 17.85,25.17 17.65,25.36 17.65,26.17
+3VS on IN1: 52.79,28.83 53.44,28.83 53.56,28.95 53.56,29.42 53.27,29.71 53.13,29.71 52.68,30.16 52.53,30.16 52.31,29.94 52.31,29.32
+3VS on IN1: 40.7,28.79 41,29.09 41,31.16 41.19,31.34 42.01,31.34 42.38,30.97 42.38,30.43 43.14,29.68 44.16,29.68 44.68,29.54 45.5,28.72 45.5,28.47 45.39,28.35 43.87,28.35 43.33,28.89 42.75,28.89 41.4,27.55 37.51,27.55 37.19,27.87 37.19,28.61 37.37,28.79
+3VS on IN1: 18.47,24.8 18.37,24.9 18.37,25.94 18.47,26.05 20.01,26.05 20.1,25.96 20.1,24.94 19.96,24.8
+3VS on IN1: 285.53,39.64 286.55,39.64 286.68,39.52 286.68,38.75 286.55,38.63 285.66,38.63 285.28,39.01 285.28,39.39
+3VS on IN1: 14.54,36.4 14.54,35.93 14.84,35.62 14.84,25.49 17.74,22.6 17.74,20.84 17.46,20.56 16.13,20.56 15.85,20.84 15.85,21.9 13.12,24.64 13.12,29.54 13.14,29.56 13.14,35.97 12.5,36.61 12.5,37.62 12.74,37.85 13.51,37.85 13.65,37.71 13.65,37.29
+3VS on IN2: 101.36,48.68 103.19,48.68 105.32,50.82 105.32,54.29 106.04,55.01 106.99,55.01 109.93,57.95 109.93,58.52 109.45,59 106.17,59 106.17,59 105.87,59 105.55,59.31 105.2,59.31 105,59.11 103.11,59.11 100.88,56.88 100.88,49.17
+3VS on IN2: 192.62,33.7 193.05,33.27 194.45,33.27 195.95,34.77 200.82,34.77 200.82,33.44 197.29,33.44 196.07,32.23 192.59,32.23 191.35,33.47 191.35,33.99 191.59,34.23 192.5,34.23 192.62,34.11
+3VS on IN2: 44.61,28.21 44.49,28.34 44.49,28.59 44.35,28.73 42.7,28.73 41.37,27.41 37.27,27.41 37.04,27.65 37.04,28.63 37.24,28.83 40.7,28.83 42.35,30.47 42.35,30.47 42.38,30.5 46.39,30.5 47.54,31.64 52.11,31.64 53,30.75 53.18,30.75 55.17,28.76 55.74,28.76 55.97,28.53 55.97,28.38 55.81,28.21
+3VS on IN2: 16.66,57.02 16.66,48.58 14.84,46.76 14.84,45.38 13.87,44.41 12.35,44.41 12.19,44.58 12.19,45.09 13.16,46.06 13.16,46.89 15.4,49.13 15.4,56.62 15.25,56.76 15.25,56.79 15.13,56.91 15.13,62.51 16.65,64.03 17.59,64.03 17.71,63.91 17.71,63.26 17.5,63.06 17.04,63.06 16.15,62.17 16.15,57.53
+3VS on IN2: 288.33,38.25 288.96,38.88 288.96,40.22 288.4,40.79 285.5,40.79 285.33,40.62 285.33,38.45 285.53,38.25
+3VS on IN2: 205.27,35.71 205.65,35.71 205.9,35.45 205.9,34.31 205.14,33.55 204.38,33.55 204,33.93 204,34.44
+3VS on VCC: 210.52,22.5 209.78,23.24 209.78,31.24 208.74,32.28 205.31,32.28 204.32,33.27 204.32,33.82 205.08,34.58 205.08,35.83 208.53,35.83 213.46,30.9 213.46,29 214.5,27.96 246.84,27.96 251.79,32.91 269.06,32.91 280.24,44.09 287.63,44.09 287.63,38.86 286.89,38.12 279.01,38.12 275.82,34.92 275.82,24.51 273.81,22.5 254.71,22.5 254.59,22.62 254.38,22.62 254.25,22.5
+3VS on VCC: outline of 98 points within 51.66,16.15 193.65,34.31
+3VS on IN3: 21.87,62.16 22.08,61.96 22.08,61.75 21.75,61.42 21.23,61.42 21.22,61.43 21.01,61.43 20.79,61.64 20.79,62.01 20.14,62.66 17.09,62.66 16.65,63.1 16.65,63.69 17.04,64.07 21.29,64.07 21.87,63.49
+3VS_ALS on BOTTOM: 131.08,22.12 133,22.12 133.37,22.5 134.06,22.5 134.11,22.45 134.11,21.96 134.06,21.91 133.53,21.91 133.25,21.63 131.05,21.63 131.02,21.66 131.02,22.07
+3VS_AUDIO_R on TOP: 264.97,39.08 265.51,39.08 265.56,39.03 265.56,36.77 265.45,36.67 264.69,36.67 264.57,36.8 264.57,38.12 264.9,38.45 264.9,39.01
+3VS_CAM on BOTTOM: 131.11,22.27 130.95,22.43 130.95,22.74 131.06,22.85 132.43,22.85 132.71,23.13 134,23.13 134.05,23.08 134.05,22.68 133.98,22.61 133.16,22.61 132.82,22.27
+3VS_CAM on BOTTOM: 54.04,58.49 54,58.53 54,59.49 54.05,59.54 54.59,59.54 54.76,59.38 55.19,59.38 55.28,59.29 55.89,59.29 55.96,59.35 56.07,59.35 56.12,59.3 56.12,58.54 56.07,58.49
+3VS_CR on TOP (solid shape): 285.11,41.5 285.11,40.5 285.01,40.4 284.66,40.4 284.53,40.27 284.53,39.79 284.38,39.65 284.38,37.87 284.21,37.7 284.21,36.77 284.11,36.67 283.08,36.67 282.73,37.02 282.73,41.45 282.87,41.59 285.01,41.59
+3VS_CR on TOP: 292.64,33.65 292.64,32.85 292.57,32.79 292.57,32.69 292.43,32.55 292.43,32.34 292.62,32.15 292.62,31.91 292.43,31.72 292.03,31.72 291.91,31.6 291.28,31.6 291.21,31.67 291.21,32.27 291.39,32.46 292.05,32.46 292.32,32.73 292.32,32.8 292.35,32.83 292.35,33.67 292.41,33.73 292.56,33.73
+3VS_CR on IN2: 283.54,41.63 281.72,43.45 277.15,43.45 277.02,43.33 277.02,36.47 277.41,36.09 284.9,36.09 285.15,36.34 285.15,41.46 284.97,41.63
+3VS_CR on IN3: 292.65,41.17 285.51,41.17 285.08,41.59 284,41.59 283.85,41.44 283.85,35.21 284.12,34.94 291.5,34.94 291.88,34.56 291.88,33.17 291.38,32.66 291.38,31.95 291.61,31.71 292.17,31.71 293.2,32.74 293.2,33.21 293.92,33.93 293.92,39.9
+3VS_CR_R on TOP: 286.49,38.49 286.73,38.49 286.88,38.34 286.88,37.03 286.47,36.62 285.03,36.62 284.89,36.76 284.89,37.69 284.86,37.72 284.66,37.72 284.62,37.77 284.62,38.42 284.67,38.47 285.01,38.47 285.06,38.42 285.06,38.05 285.28,37.83 285.84,37.83
+3VS_R on TOP: 198.48,32.77 198.42,32.83 198.42,33.55 198.98,34.11 200.66,34.11 200.74,34.02 200.74,32.83 200.72,32.81 199.84,32.81 199.8,32.77
+3VS_SSD_R on TOP (solid shape): 224.48,62.26 224.48,59.81 224.38,59.71 223.65,59.71 223.56,59.8 223.56,61.09 223.7,61.23 223.7,62.31 223.74,62.35 224.4,62.35
+3VS_TP on BOTTOM: 187.74,19.58 189.9,19.58 190.03,19.7 191.43,19.7 191.55,19.83 191.55,20.08 191.68,20.21 191.93,20.21 192.06,20.08 192.06,19.45 191.43,18.81 190.27,18.81 189.37,17.92 188.25,17.92 187.65,18.53 187.65,19.48
+3VS_TP_R on BOTTOM (solid shape): 187.01,19.51 187.01,18.54 187.16,18.4 187.16,16.58 186.38,15.8 185.46,15.8 185.37,15.89 185.37,16.82 186.09,17.54 186.09,19.32 186.35,19.58 186.95,19.58
+3VS_TS on TOP (solid shape): 48.23,76.71 48.23,76.16 48.18,76.1 47.69,76.1 47.55,75.96 46.43,75.96 46.34,76.05 46.34,76.7 46.47,76.84 48.11,76.84
+3VS_TS on TOP: 40.4,76.09 40.4,75.67 40.47,75.6 41.11,75.6 41.15,75.63 41.15,76.09 41.2,76.14 41.7,76.14 41.72,76.12 41.72,75.58 41.9,75.4 41.9,73.88 41.72,73.7 41.72,72.84 41.23,72.35 39.39,72.35 39.1,72.64 39.1,73.3 39.18,73.39 39.67,73.39 39.92,73.64 39.92,76.12 39.95,76.15 40.34,76.15
+3VS_TS on TOP: 37.83,75.76 37.76,75.83 37.76,76.19 36.99,76.96 36.99,77.12 37.06,77.18 37.82,77.18 38.32,76.68 38.32,75.81 38.27,75.76
+3VS_TS_R on TOP: 47.59,75.26 46.5,75.26 46.44,75.19 46.44,74.43 46.57,74.31 46.57,73.31 46.75,73.13 47.65,73.13 47.69,73.17 47.69,75.15
+3VS_WLAN_R on TOP: 253.85,39.08 254.41,39.08 254.46,39.03 254.46,36.77 254.38,36.7 253.49,36.7 253.41,36.77 253.41,38.65
+3VS_WWAN_R on TOP: 255.9,36.7 255.79,36.81 255.79,39.02 255.85,39.08 256.82,39.08 256.89,39.01 256.89,36.8 256.8,36.7
+5V_USB_L on TOP: 19.79,10.03 20.01,9.81 21.28,9.81 21.58,10.11 21.58,11.99 21.42,12.15 19.85,12.15 19.79,12.09
+5V_USB_L on BOTTOM: 14.51,15 16.98,15 17.12,15.14 17.12,15.97 17.17,16.02 18.25,16.02 18.36,15.91 18.36,14.15 18.16,13.95 15.54,13.95 15.48,13.89 15.48,13.75 15.48,13.75 15.48,13.45 15.39,13.36 14.84,13.36 14.83,13.35 14.48,13.35 14.42,13.42 14.42,14.91
+5V_USB_L on IN2: 17.18,16.02 18.74,16.02 21.44,13.33 21.44,10.94 20.74,10.24 19.4,10.24 16.86,12.78 16.86,15.7
+5V_USB_L on VCC: 11.27,10.88 11.27,11.07 12.17,11.07 12.17,12.46 11.27,12.46 11.27,13.42 11.6,13.63 11.76,13.99 12.33,13.99 13.88,15.53 13.88,16.02 17.9,16.02 18.39,15.53 18.39,14.47 14.79,10.88
+5V_USB_L on IN3: 12.1,14.12 13.16,14.12 13.36,14.31 15.07,14.31 15.3,14.08 15.3,13.37 15.05,13.12 14.54,13.12 13.75,12.34 11.59,12.34 11.34,12.59 11.34,13.35
+5V_USB_R on TOP: 292.32,60.34 290.23,62.43 288.91,62.43 288.84,62.5 288.84,63.49 289.13,63.78 291.01,63.78 292.75,62.04 292.75,60.47 292.62,60.34
+5V_USB_R on BOTTOM: 292.71,46.63 294.87,46.63 294.99,46.75 294.99,47.94 294.72,48.21 292.84,48.21 292.71,48.09
+5V_USB_R on IN2: 290.99,62.25 296.71,62.25 297.73,61.23 297.73,48.66 295.82,46.75 291.76,46.75 291.38,47.14 291.38,58.06 292.14,58.82 292.14,59.2 290.74,60.6 290.74,61.99
+5V_USB_R on IN3: 299.82,46.5 297.47,46.5 295.82,48.15 293.09,48.15 292.58,47.64 292.58,43.83 294.8,41.61 300.96,41.61 302.87,43.52 302.87,45.93 304,47.06 304,47.57 304.46,48.02 304.46,48.79 304.2,49.04 302.36,49.04
+5V_USB_R on GND4: 295.9,45.29 294.76,46.44 293.11,46.44 292.77,46.77 292.77,47.88 293.04,48.15 295.36,48.15 297.01,46.5 300.28,46.5 302.82,49.04 303.63,49.04 303.63,48.91 304.5,48.91 304.5,47.93 304.04,47.48 304.14,46.84 302.6,45.29
+5VALW on TOP (solid shape): 21.53,33.69 21.53,32.59 21.3,32.36 20.46,32.36 20.34,32.24 19.75,32.24 19.61,32.38 19.61,33.67 19.77,33.83 21.39,33.83
+5VALW on BOTTOM (solid shape): 23.41,77.02 23.41,75.4 23.29,75.28 22.49,75.28 22.07,74.85 21.17,74.85 21.11,74.91 21.11,75.9 21.04,75.97 18.75,75.97 18.69,76.03 18.69,76.87 18.86,77.05 22.55,77.05 22.65,77.15 23.29,77.15
+5VALW on BOTTOM (solid shape): 23.41,70.01 23.41,68.39 23.25,68.23 22.43,68.23 22.07,67.87 21.13,67.87 21.11,67.9 21.11,68.71 20.74,69.08 18.82,69.08 18.75,69.15 18.75,69.92 18.86,70.03 22.55,70.03 22.65,70.13 23.29,70.13
+5VALW on IN1 (solid shape): 21.49,33.54 21.49,32.54 21.4,32.45 20.76,32.45 20.63,32.58 20.63,33.64 20.76,33.77 21.26,33.77
+5VALW on IN3 (solid shape): 21.41,76.75 21.41,76.13 21.25,75.96 18.84,75.96 18.73,76.07 18.73,76.9 18.91,77.08 21.08,77.08
+5VALW on IN3 (solid shape): 21.72,68.92 21.72,68.15 21.37,67.81 20.43,67.81 20.08,68.17 20.08,68.99 19.95,69.12 19.95,69.73 20,69.78 20.85,69.78
+5VALW on TOP: 19.89,14.27 19.76,14.39 19.76,15.49 19.29,15.96 19.29,16.45 19.37,16.53 21.44,16.53 21.49,16.48 21.49,14.33 21.42,14.27
+5VALW on BOTTOM: 134.44,17.7 137,17.7 137.35,17.35 137.35,16.15 137.29,16.09 137.11,16.09 136.98,16.21 135.14,16.21 135.03,16.1 132.24,16.1 132.14,16.2 132.14,16.74 132.29,16.9 132.51,16.9 132.96,17.34 134.1,17.34 134.15,17.39 134.15,17.4
+5VALW on BOTTOM: 29.56,44.92 29.9,44.92 29.98,44.83 29.98,43.5 29.97,43.5 29.44,43.5 29.43,43.49 29.43,42.77 29.45,42.75 29.94,42.75 29.98,42.75 29.98,42.3 29.43,42.3 29.43,42.3 29.43,41.55 29.98,41.55 29.98,40.46 29.8,40.28 28,40.28 27.72,40.55 27.72,44.63 27.79,44.7 29.34,44.7
+5VALW on IN1: 22.9,70.26 23.01,70.15 23.01,70.07 21.39,68.45 21.39,67.97 21.25,67.82 20.41,67.82 20.06,68.17 20.06,68.92 20.15,69 21.45,69 22.7,70.26
+5VALW on VCC: 19.13,14.24 18.9,14.47 18.9,15.74 18.11,16.53 13.88,16.53 13.88,17.95 14.9,18.96 14.9,35.71 26.49,35.71 28.17,37.38 28.17,40.38 24.08,44.47 21.29,44.47 18.13,47.62 18.13,68.49 21.18,71.54 21.18,74.8 20.46,75.52 16.65,75.52 16.33,75.85 16.62,76.31 16.86,76.8 17.9,78.1 19.49,78.59 30.33,78.59 30.33,70.02 33.63,66.72 33.63,63.81 29.25,59.43 29.25,52.17 34.01,47.41 34.01,41.32 34.26,41.06 34.26,14.24
+5VALWB on TOP (solid shape): 284.8,12.08 284.8,11.03 284.55,10.78 283.57,10.78 283.38,10.98 283.38,11.97 283.62,12.22 284.66,12.22
+5VALWB on TOP (solid shape): 286.68,63.2 286.68,62.5 286.61,62.44 285.15,62.44 284.69,61.98 284.24,61.98 284.14,62.09 284.14,62.68 283.92,62.91 283.7,62.91 283.57,63.04 283.57,63.13 283.56,63.14 283.56,64.53 283.82,64.79 285.09,64.79
+5VALWB on TOP (solid shape): 197.16,32.14 197.16,32.03 197.1,31.97 196.19,31.97 195.99,31.77 195.99,31.53 196.12,31.4 197.12,31.4 197.15,31.37 197.15,29.94 194.09,26.88 194.09,25.7 193.94,25.55 192.19,25.55 191.93,25.8 191.93,28.22 195.35,31.64 195.35,32.09 195.39,32.13 196.03,32.13 196.11,32.2 197.1,32.2
+5VALWB on BOTTOM (solid shape): 294.36,71.01 294.36,69.05 294.2,68.9 293.66,68.9 293.66,69.38 293.01,69.38 293.01,68.9 292.46,68.9 292.46,69.38 291.81,69.38 291.81,68.9 291.22,68.9 291.06,69.06 291.06,71.01 291.31,71.27 294.11,71.27
+5VALWB on IN1 (solid shape): 269.09,41.99 269.09,41.29 268.77,40.98 267.25,40.98 267.12,41.1 267.12,42.12 267.31,42.31 268.77,42.31
+5VALWB on TOP: 267.05,42.31 267.88,42.31 268.01,42.18 268.01,40.47 267.87,40.33 267,40.33 266.93,40.4 266.93,42.18
+5VALWB on BOTTOM: 184.64,14.34 184.64,13.68 184.57,13.61 184.36,13.61 183.17,14.8 183.17,15.79 183.68,15.79 183.68,15.03 184.29,14.42 184.57,14.42
+5VALWB on VCC: 190.6,22.88 190.6,26.9 194.16,30.46 194.16,36.68 202.52,45.04 212.72,45.04 217.36,40.4 222.71,40.4 223.73,41.42 263.73,41.42 278.87,56.3 278.87,77.09 300.13,77.09 301.47,75.75 301.47,59.33 291.69,59.33 291.69,44.6 280.03,44.6 268.85,33.42 251.58,33.42 246.63,28.47 214.71,28.47 213.97,29.21 213.97,31.11 208.74,36.34 199.39,36.34 198.6,35.56 198.6,29.97 191.51,22.88
+5VALWB_USH on BOTTOM (solid shape): 270.09,19.51 270.25,19.35 270.25,17.94 270.09,17.77 269.51,17.77 269.34,17.94 269.34,19.32 269.53,19.52 270.09,19.52
+5VALWBP on BOTTOM (solid shape): 292.35,68.73 293.12,68.73 293.12,69.28 293.54,69.28 293.55,69.27 293.55,68.73 294.74,68.73 295.12,68.34 296.39,68.34 296.52,68.22 296.52,67.33 295.88,66.69 295.88,62.76 295.38,62.25 291.57,62.25 291.44,62.38 291.44,67.58 291.06,67.96 291.06,68.6 291.18,68.73 291.9,68.73 291.9,68.79 291.91,68.79 291.91,69.26 291.93,69.28 292.35,69.28
+5VALWP on BOTTOM (solid shape): 31.18,46.24 31.19,46.24 31.19,44.26 31.31,44.14 34.23,44.14 35.14,45.05 38.46,45.05 38.84,44.67 38.84,41.05 38.81,41.01 31.06,41.01 30.97,40.93 30.97,38.75 30.92,38.7 29.93,38.7 29.91,38.72 29.91,40.12 30.13,40.33 30.13,41.69 29.59,41.7 29.58,41.71 29.58,41.93 34.92,41.93 34.92,41.88 34.93,41.82 34.94,41.77 34.97,41.73 35,41.69 35.03,41.65 35.07,41.62 35.12,41.6 35.17,41.58 35.22,41.57 35.27,41.57 35.33,41.58 35.37,41.6 35.42,41.62 35.46,41.65 35.5,41.69 35.53,41.73 35.55,41.77 35.57,41.82 35.58,41.88 35.58,41.93 35.57,41.98 35.55,42.03 35.53,42.07 35.5,42.12 35.46,42.15 35.42,42.18 35.37,42.21 35.33,42.22 35.27,42.23 35.22,42.23 35.17,42.22 35.12,42.21 35.07,42.18 35.03,42.15 35,42.12 34.97,42.07 34.94,42.03 34.93,41.98 34.92,41.93 29.58,41.93 29.58,42.15 29.59,42.15 30.12,42.15 30.13,42.16 30.13,42.89 29.59,42.9 29.58,42.91 29.58,43.34 29.59,43.35 30.12,43.35 30.13,43.36 30.13,46.23 30.23,46.32 31.1,46.32
+5VS on IN2 (solid shape): 210.67,31.39 210.67,30.93 210.46,30.73 201.26,30.73 201.15,30.83 201.15,31.48 201.19,31.51 201.19,31.51 201.25,31.57 210.49,31.57
+5VS on TOP: 202.67,30.17 202.67,30.99 202.77,31.09 202.77,31.45 202.67,31.56 201.25,31.56 201.14,31.44 201.14,30.14 201.2,30.08 202.58,30.08
+5VS on BOTTOM: 198.22,32.28 200.51,32.28 200.53,32.3 201.31,32.3 201.4,32.39 201.4,33.29 201.52,33.42 202.03,33.42 202.16,33.29 202.16,31.74 202.26,31.64 202.97,31.64 203.05,31.57 203.05,30.93 203,30.88 200.63,30.88 200.38,31.13 198.22,31.13 197.97,31.39 197.97,32.02
+5VS_AUDIO on IN1 (solid shape): 293.99,29.47 293.99,28.74 293.83,28.59 292.63,28.59 292.5,28.72 292.5,29.51 292.62,29.64 293.82,29.64
+5VS_AUDIO on IN3 (solid shape): 293.86,29.34 293.86,28.71 293.69,28.55 292.47,28.55 292.32,28.7 292.32,29.34 292.53,29.55 293.64,29.55
+5VS_AUDIO on TOP: 268.45,36.34 267.18,36.34 266.99,36.15 266.99,35.32 267.05,35.26 267.94,35.26 268.58,35.9 268.58,36.21
+5VS_AUDIO on TOP: 290.93,30.31 291.95,30.31 292.71,29.55 293.79,29.55 293.85,29.48 293.85,28.66 293.72,28.53 290.93,28.53 290.87,28.59 290.87,30.24
+5VS_AUDIO on BOTTOM: 286.99,32.91 286.99,31.77 286.42,31.2 286.23,31.2 285.28,32.15 285.26,32.15 285.11,32.3 284.55,32.3 284.32,32.53 284.32,32.8 284.83,33.31 284.83,33.67 284.84,33.68 284.84,33.84 284.96,33.97 285.94,33.97
+5VS_AUDIO on IN1: 267.05,35.96 269.02,35.96 269.21,35.77 269.21,35.58 268.64,35.01 267.12,35.01 266.99,35.13 266.99,35.9
+5VS_AUDIO on IN2: 293.92,28.85 293.92,30.24 288.71,35.45 277.15,35.45 274.36,38.25 268.64,38.25 266.99,36.59 266.99,35.07 267.25,34.82 271.18,34.82 272.45,33.55 274.66,33.55 277.71,30.5 285.66,30.5 287.44,32.28 288.84,32.28 292.52,28.59 293.66,28.59
+5VS_AUDIO on IN3: 286.93,32.28 287.06,32.15 287.06,31.9 286.42,31.26 285.79,31.26 284.64,32.4 284.64,32.66 285.53,33.55 286.3,33.55 286.93,32.91
+5VS_AUDIO_R on TOP: 267.74,39.09 267.94,38.88 267.94,36.85 267.82,36.72 266.99,36.72 266.88,36.83 266.88,38.98 266.99,39.09
+5VS_R on TOP (solid shape): 199.76,31.04 200.48,31.04 200.51,31.01 200.51,29.97 200.47,29.93 199.73,29.93 199.32,30.34 198.62,30.34 198.42,30.54 198.42,31.35 198.47,31.4 199.4,31.4
+5VS_USH on BOTTOM (solid shape): 268.76,19.27 268.76,18.37 269.28,17.86 269.28,17.6 269.08,17.4 268.7,17.4 268.37,17.73 268.37,19.27 268.46,19.36 268.67,19.36
