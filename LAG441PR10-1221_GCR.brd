# Allegro board LAG441PR10-1221_GCR.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_CS#1: length 51.9
  TOP w0.076: RD63.1 63.39,17.47 63.82,17.9 63.82,20.76 64.1,21.03 v2(64.27,21.03)
  IN1 w0.076: v2(64.27,21.03) v4(64.6,21.03) 64.4,20.57 64.25,20.42 64.17,20.39 61.96,20.39 61.75,20.33 61.64,20.22 61.6,20.12 61.6,19.96 61.64,19.88 61.71,19.8 62.14,19.48 62.35,19.21 62.41,19.1 62.41,18.93 61.97,18.39 61.93,18.29 61.93,18.15 61.94,18.12 62.11,17.95 62.61,17.57 63.12,17.19 63.42,16.96 63.57,16.88 72.37,16.88 77.53,22.04 77.53,32.44 78.04,32.95 v4(78.57,32.95) ; v4(66.39,20.12) 66.68,19.83 v2(66.72,19.83)
  IN3 w0.076: v4(78.57,32.95) v5(78.21,33.06) ; v5(64.12,19.83) 64.53,19.73 64.68,19.58 64.86,19.58 65.02,19.74 65.02,20.67 64.97,20.79 64.81,20.95 v4(64.6,21.03) 64.93,21.16 65.82,21.16 66.04,21.04 66.3,20.78 v4(66.39,20.12)
  BOTTOM w0.076: UCPU1.AF32 79.59,35.74 78.87,35.02 78.87,34.9 78.24,34.28 78.24,33.09 v5(78.21,33.06)
DDR_A_D0: length 16.9
  IN3 w0.076: v5(63.47,24.63) 63.06,25.04 63.06,26.72 62.7,27.08 62.7,38.28 64.08,39.66 v5(65.06,39.66)
DDR_A_D1: length 17.5
  IN3 w0.076: v5(67.01,39.66) 66.46,39.42 64.07,39.42 63.09,38.44 63.09,26.93 63.23,26.78 63.23,26.14 v5(63.47,25.43)
DDR_A_D2: length 19.4
  IN3 w0.076: v5(67.01,38.36) 66.76,38.61 66.04,38.61 65.88,38.77 64.77,38.77 64.02,38.01 64.02,27.56 64.24,27.35 64.24,26.05 64.36,25.93 64.36,24.9 63.86,24.39 62.73,24.39 v5(62.17,23.83)
DDR_A_D3: length 17.8
  IN3 w0.076: v5(62.82,23.83) 63.06,24.08 63.84,24.08 64.53,24.76 64.53,26 64.44,26.09 64.44,27.57 64.26,27.75 64.26,37.93 64.94,38.6 65.81,38.6 66.05,38.36 v5(66.36,38.36)
DDR_A_D4: length 17.1
  IN3 w0.076: v5(65.71,39.66) 65.56,39.66 65.32,39.9 64.08,39.9 62.53,38.36 62.53,26.98 62.4,26.85 62.4,26.22 62.82,25.8 v5(62.82,25.43)
DDR_A_D5: length 18.9
  IN3 w0.076: v5(62.82,24.63) 62.82,25.09 62.58,25.33 62.58,25.81 62.24,26.15 62.24,26.98 62.36,27.11 62.36,38.42 64.01,40.07 65.51,40.07 65.68,39.9 66.12,39.9 v5(66.36,39.66)
DDR_A_D6: length 17.3
  IN3 w0.076: v5(63.47,23.03) 63.86,23.43 64.43,23.43 65.18,24.18 65.18,26.35 65.5,26.88 65.5,30.38 64.72,31.16 64.72,37.56 65.52,38.36 v5(65.71,38.36)
DDR_A_D7: length 16.7
  IN3 w0.076: v5(63.47,23.83) 63.71,23.59 64.36,23.59 65.01,24.25 65.01,26.42 65.31,26.92 65.31,30.21 64.48,31.04 64.48,37.78 v5(65.06,38.36)
DDR_A_D8: length 14.9
  IN1 w0.076: v4(65.96,37.36) 65.76,37.36 65.44,37.67 65.01,37.67 63.21,35.88 63.21,27.51 62.4,26.7 62.4,26.22 62.82,25.8 v2(62.82,25.43)
  IN3 w0.076: v5(65.71,37.14) v4(65.96,37.36)
DDR_A_D9: length 18
  IN1 w0.076: v4(67.3,37.31) 67.3,37.5 66.53,38.26 65.2,38.26 63.01,36.07 63.01,27.54 62.24,26.76 62.24,26.15 62.58,25.81 62.58,24.88 v2(62.82,24.63)
  IN3 w0.076: v5(67.01,37.14) v4(67.3,37.31)
DDR_A_D10: length 13.5
  IN1 w0.076: v2(62.17,23.83) 62.73,24.39 63.86,24.39 64.36,24.9 64.36,26.12 64.29,26.2 64.29,26.87 64.4,26.99 64.4,28.64 64.69,28.94 64.69,29.72 64.56,29.85 64.56,33.53 v4(65.42,34.39)
  IN3 w0.076: v5(65.42,34.77) 65.42,34.39 v4(65.42,34.39)
  BOTTOM w0.076: v5(65.42,34.77) 65.42,35.11 UCPU1.B33
DDR_A_D11: length 14.5
  IN1 w0.076: v4(66.78,35.61) 66.73,35.57 66.73,32.22 66.26,31.75 66.26,27.6 65.48,26.82 65.48,26.81 65.18,26.31 65.18,24.26 64.35,23.43 63.86,23.43 v2(63.47,23.03)
  IN3 w0.076: v4(66.78,35.61) v5(67.01,35.84)
DDR_A_D12: length 14.3
  IN1 w0.076: v4(65.31,37.36) 65.01,37.36 63.38,35.72 63.38,27.1 63.06,26.78 63.06,25.5 63.47,25.09 v2(63.47,24.63)
  IN3 w0.076: v5(65.06,37.14) v4(65.31,37.36)
DDR_A_D13: length 14.5
  IN1 w0.076: v4(66.59,37.38) 66.43,37.38 66.09,37.04 65.03,37.04 63.55,35.56 63.55,27.01 63.23,26.69 63.23,25.68 v2(63.47,25.43)
  IN3 w0.076: v5(66.36,37.14) v4(66.59,37.38)
DDR_A_D14: length 14.2
  IN1 w0.076: v4(65.38,35.84) 65.77,35.45 65.77,33.48 65.75,33.46 65.75,33.07 65.62,32.93 65.62,32.26 65.29,31.93 65.29,27.64 64.45,26.81 64.45,26.27 64.53,26.19 64.53,24.77 63.84,24.08 63.06,24.08 v2(62.82,23.83)
  IN3 w0.076: v5(65.71,35.84) v4(65.38,35.84)
DDR_A_D15: length 14.3
  IN1 w0.076: v4(66.13,35.61) 66,35.48 66,33.75 66.42,33.33 66.42,32.39 65.51,31.48 65.51,27.3 65.09,26.88 65.09,26.48 65.01,26.35 65.01,24.35 64.25,23.59 63.71,23.59 v2(63.47,23.83)
  IN3 w0.076: v4(66.13,35.61) v5(66.36,35.84)
DDR_A_D16: length 25.6
  IN1 w0.076: v2(60.87,23.83) 60.74,23.83 60.33,24.24 59.83,24.24 59.57,24.5 59.57,26.37 60.17,26.98 60.17,31.17 60.87,31.87 60.87,36.96 65.04,41.13 67.46,41.13 67.92,41.59 68.73,41.59 v4(69.38,42.24)
  IN3 w0.076: v5(69.61,42) v4(69.38,42.24)
DDR_A_D17: length 24.6
  IN1 w0.076: v2(61.52,25.43) 61.52,25.89 61.88,26.25 61.88,27.24 61.98,27.35 61.98,27.63 62.08,27.73 62.22,27.73 62.31,27.82 62.31,27.94 62.22,28.03 62.07,28.03 61.98,28.11 61.98,28.24 62.08,28.34 62.22,28.34 62.31,28.43 62.31,28.55 62.22,28.64 62.07,28.64 61.98,28.72 61.98,28.85 62.08,28.95 62.22,28.95 62.31,29.03 62.31,29.16 62.22,29.25 62.07,29.25 61.98,29.33 61.98,29.46 62.08,29.56 62.22,29.56 62.31,29.64 62.31,29.77 62.22,29.86 62.07,29.86 61.98,29.94 61.98,30.07 62.08,30.17 62.22,30.17 62.31,30.25 62.31,30.38 62.22,30.47 62.07,30.47 61.98,30.55 61.98,30.79 62.52,31.33 62.52,36.77 64.85,39.1 65.1,39.1 65.2,39.19 65.2,39.4 65.29,39.49 65.42,39.49 65.51,39.4 65.51,39.17 65.6,39.08 65.75,39.08 65.84,39.17 65.84,39.42 65.93,39.51 66.06,39.51 66.15,39.42 66.15,39.18 66.23,39.1 66.43,39.1 66.51,39.17 66.51,39.38 66.78,39.65 67.36,39.65 67.45,39.56 67.45,39.25 67.54,39.16 67.66,39.16 67.75,39.25 67.75,39.56 67.84,39.65 68.2,39.65 68.39,39.83 69.05,39.83 69.19,39.98 v4(69.19,40.2)
  IN3 w0.076: v5(68.96,39.97) v4(69.19,40.2)
DDR_A_D18: length 26.6
  IN1 w0.076: v4(68.08,42.24) 67.92,42.24 67.6,41.92 67.28,41.92 67.22,41.98 66.92,41.98 66.45,41.51 64.84,41.51 60.47,37.13 60.47,32.04 59.71,31.28 59.71,27.21 59.2,26.7 59.2,23.77 59.63,23.35 61.2,23.35 v2(61.52,23.03)
  IN3 w0.076: v5(68.31,42) v4(68.08,42.24)
DDR_A_D19: length 26.5
  IN1 w0.076: v2(61.52,23.83) 60.97,23.52 59.76,23.52 59.41,23.87 59.41,26.55 59.92,27.06 59.92,31.2 60.67,31.95 60.67,37.05 64.97,41.34 67.36,41.34 67.86,41.85 68.12,41.85 v4(68.73,42.24)
  IN3 w0.076: v5(68.96,42) v4(68.73,42.24)
DDR_A_D20: length 24.6
  IN1 w0.076: v4(67.89,40.2) 67.64,39.95 65.05,39.95 62.14,37.05 62.14,36.75 62.05,36.66 61.87,36.66 61.78,36.57 61.78,36.44 61.87,36.35 62.05,36.35 62.14,36.26 62.14,36.14 62.05,36.05 61.87,36.05 61.78,35.96 61.78,35.83 61.87,35.74 62.05,35.74 62.14,35.65 62.14,35.53 62.05,35.44 61.87,35.44 61.78,35.35 61.78,35.22 61.87,35.13 62.05,35.13 62.14,35.04 62.14,34.92 62.05,34.83 61.87,34.83 61.78,34.74 61.78,34.61 61.87,34.52 62.05,34.52 62.14,34.43 62.14,34.31 62.05,34.22 61.87,34.22 61.78,34.13 61.78,34 61.87,33.91 62.05,33.91 62.14,33.83 62.14,33.62 62.05,33.53 61.88,33.53 61.79,33.44 61.79,33.32 61.88,33.23 62.05,33.23 62.14,33.14 62.14,33.02 62.05,32.93 61.89,32.93 61.8,32.84 61.8,32.71 61.89,32.62 62.05,32.62 62.14,32.53 62.14,32.37 62.05,32.28 61.89,32.28 61.8,32.2 61.8,32.07 61.89,31.98 62.05,31.98 62.14,31.89 62.14,31.73 61.31,30.9 61.31,28.48 60.92,28.09 60.92,27.93 61.01,27.84 61.33,27.84 61.42,27.75 61.42,27.62 61.33,27.53 61.01,27.53 60.92,27.44 60.92,26.27 61.11,26.08 61.11,25.52 61.03,25.43 v2(60.87,25.43)
  IN3 w0.076: v5(67.66,39.97) v4(67.89,40.2)
DDR_A_D21: length 24
  IN1 w0.076: v2(61.52,24.63) 61.24,24.63 61.13,24.74 61.13,24.99 61.23,25.1 61.63,25.1 61.76,25.23 61.76,25.9 62.07,26.21 62.07,27.18 62.54,27.65 62.54,31.13 62.68,31.27 62.68,36.63 64.96,38.92 65.18,38.92 65.27,38.83 65.27,38.69 65.35,38.61 65.48,38.61 65.57,38.7 65.57,38.83 65.66,38.92 65.79,38.92 65.88,38.83 65.88,38.69 65.96,38.61 66.09,38.61 66.18,38.7 66.18,38.83 66.27,38.92 66.4,38.92 66.49,38.83 66.49,38.69 66.57,38.61 66.7,38.61 66.79,38.7 66.79,38.83 66.88,38.92 67.01,38.92 67.1,38.83 67.1,38.69 67.18,38.61 67.31,38.61 67.4,38.7 67.4,38.83 67.49,38.92 67.69,38.92 68.42,39.65 69.67,39.65 69.84,39.82 v4(69.84,40.2)
  IN3 w0.076: v5(69.61,39.97) v4(69.84,40.2)
DDR_A_D22: length 21.8
  IN1 w0.076: v4(68.54,40.2) 68.14,39.8 66.55,39.8 66.42,39.66 65.13,39.66 62.32,36.85 62.32,31.56 61.5,30.74 61.5,30.51 61.58,30.42 61.68,30.42 61.77,30.33 61.77,30.21 61.68,30.12 61.58,30.12 61.5,30.03 61.5,29.9 61.58,29.81 61.68,29.81 61.77,29.72 61.77,29.6 61.68,29.51 61.58,29.51 61.5,29.42 61.5,29.29 61.58,29.2 61.68,29.2 61.77,29.11 61.77,27.61 61.12,26.97 61.12,26.31 61.28,26.15 61.28,25.42 60.87,25.01 v2(60.87,24.63)
  IN3 w0.076: v5(68.31,39.97) v4(68.54,40.2)
DDR_A_D23: length 26.2
  IN1 w0.076: v2(60.87,23.03) 60.55,22.72 59.72,22.72 59,23.44 59,26.8 59.51,27.31 59.51,31.37 60.26,32.12 60.26,37.22 64.78,41.74 66.33,41.74 66.83,42.24 v4(67.43,42.24)
  IN3 w0.076: v5(67.66,42) v4(67.43,42.24)
DDR_A_D24: length 24.2
  IN3 w0.076: v5(60.87,23.83) 60.68,23.83 60.2,24.32 59.76,24.32 59.57,24.5 59.57,30.34 60.57,31.34 60.57,38.94 63.25,41.62 63.99,41.62 64.31,41.94 66.53,41.94 66.77,42.18 v5(67.01,42.18)
DDR_A_D25: length 26.4
  IN3 w0.076: v5(60.87,23.03) 60.62,23.03 60.3,22.72 59.74,22.72 59.02,23.44 59.02,30.61 59.96,31.56 59.96,37.45 59.96,39.19 62.98,42.21 63.86,42.21 64.23,42.59 65.23,42.59 65.39,42.42 65.88,42.42 66.12,42.18 v5(66.36,42.18)
DDR_A_D26: length 20
  IN3 w0.076: v5(60.87,25.43) 61.11,25.68 61.11,26.08 60.87,26.32 60.87,30.32 61.41,30.86 61.41,38.69 63.53,40.82 64.37,40.82 64.84,41.28 66.23,41.28 66.36,41.16 v5(66.36,40.88)
DDR_A_D27: length 20.1
  IN3 w0.076: v5(61.52,24.63) 61.76,25.33 61.76,25.9 62.05,26.19 62.05,38.56 63.75,40.25 64.67,40.25 65,40.59 66.84,40.59 67.01,40.76 v5(67.01,40.88)
DDR_A_D28: length 24
  IN3 w0.076: v5(65.06,42.18) 64.32,42.18 63.94,41.8 63.15,41.8 60.37,39.02 60.37,31.37 59.41,30.41 59.41,28.3 59.41,23.78 59.67,23.52 61.2,23.52 v5(61.52,23.83)
DDR_A_D29: length 25.4
  IN3 w0.076: v5(61.52,23.03) 61.2,23.35 59.52,23.35 59.22,23.65 59.22,30.49 60.17,31.44 60.17,39.11 63.07,42.01 63.91,42.01 64.32,42.42 65.16,42.42 65.4,42.18 v5(65.71,42.18)
DDR_A_D30: length 20.2
  IN3 w0.076: v5(65.06,40.88) 64.63,40.44 63.69,40.44 61.9,38.65 61.9,30.57 61.76,30.43 61.76,29.24 61.67,29.15 61.44,29.15 61.35,29.06 61.35,28.94 61.44,28.85 61.67,28.85 61.76,28.76 61.76,28.64 61.67,28.56 61.42,28.56 61.33,28.47 61.33,28.34 61.42,28.25 61.67,28.25 61.76,28.16 61.76,28.04 61.67,27.95 61.42,27.95 61.33,27.86 61.33,27.73 61.42,27.64 61.67,27.64 61.76,27.55 61.76,27.43 61.67,27.34 61.42,27.34 61.33,27.25 61.33,27.05 61.44,26.94 61.78,26.94 61.89,26.83 61.89,26.26 61.52,25.89 v5(61.52,25.43)
DDR_A_D31: length 20.5
  IN3 w0.076: v5(60.87,24.63) 60.87,24.68 61.28,25.08 61.28,26.15 61.12,26.31 61.12,29.51 61.21,29.6 61.48,29.6 61.57,29.69 61.57,29.81 61.48,29.9 61.21,29.9 61.12,29.99 61.12,30.15 61.61,30.64 61.61,38.65 63.61,40.65 64.49,40.65 64.96,41.12 65.62,41.12 65.71,41.03 v5(65.71,40.88)
DDR_A_D32: length 9.3
  IN3 w0.076: v5(67.37,24.63) 67.37,25.09 67.08,25.38 67.08,25.58 66.94,25.73 66.94,27.68 66.77,27.85 66.77,30.37 69.11,32.71 v5(69.11,32.75)
DDR_A_D33: length 13.9
  IN3 w0.076: v5(67.37,23.03) 66.98,23.43 66.55,23.43 66.31,23.67 66.31,26.06 66.6,26.35 66.6,27.4 66.29,27.72 66.29,30.56 68.1,32.37 68.1,33.13 68.39,33.42 68.55,33.42 68.85,33.72 68.85,34.44 v5(69.11,34.7)
DDR_A_D34: length 12.7
  IN3 w0.076: v5(70.41,34.7) 70.7,34.41 70.7,32.05 69,30.36 69,27.6 69.78,26.83 69.78,26.41 69.73,26.35 69.73,26.3 69.42,25.99 69.29,25.99 68.66,25.37 68.66,25.25 68.43,25.02 68.43,24.08 v5(68.67,23.83)
DDR_A_D35: length 9.6
  IN3 w0.076: v5(70.41,34.05) 70.41,33.74 70.15,33.48 70.15,33.07 70,32.92 70,32.14 68.45,30.59 68.45,27.24 68.26,27.05 68.26,25.85 68.02,25.61 v5(68.02,25.43)
DDR_A_D36: length 9.2
  IN3 w0.076: v5(69.11,33.4) 69.35,33.16 69.35,32.65 67.01,30.31 67.01,27.84 67.1,27.75 67.1,25.82 67.37,25.55 v5(67.37,25.43)
DDR_A_D37: length 12.7
  IN3 w0.076: v5(69.11,34.05) 69.11,33.74 68.86,33.5 68.86,32.75 66.49,30.38 66.49,27.9 66.77,27.61 66.77,25.96 66.48,25.66 66.48,23.73 66.62,23.59 67.13,23.59 v5(67.37,23.83)
DDR_A_D38: length 9.8
  IN3 w0.076: v5(70.41,33.4) 70.41,33.09 70.17,32.85 70.17,32.06 68.63,30.52 68.63,27.06 68.43,26.86 68.43,25.79 68.26,25.62 68.26,25.33 68.02,25.09 v5(68.02,24.63)
DDR_A_D39: length 10.1
  IN3 w0.076: v5(68.02,23.83) 68.26,24.08 68.26,25.09 68.46,25.29 68.46,25.44 69,25.98 69,26.31 69.11,26.42 69.11,27.08 68.81,27.38 68.81,30.45 70.41,32.05 v5(70.41,32.75)
DDR_A_D40: length 10.1
  IN3 w0.076: v5(71.62,33.4) 71.62,33.11 71.35,32.84 71.35,31.92 70.41,30.98 70.41,27.1 70.69,26.82 70.69,26.27 70.16,25.74 69.94,25.74 69.56,25.37 69.56,24.88 v5(69.32,24.63)
DDR_A_D41: length 10.6
  IN3 w0.076: v5(69.32,25.43) 69.32,25.49 69.82,25.99 70.1,25.99 70.47,26.36 70.47,26.76 70.22,27.01 70.22,31.08 71.14,32 71.14,32.9 71.33,33.08 71.33,34.1 71.62,34.39 v5(71.62,34.7)
DDR_A_D42: length 12
  IN3 w0.076: v5(72.92,32.75) 72.81,32.63 72.81,31.12 72.37,30.67 72.37,24.25 71.31,23.19 71.31,22.94 71.08,22.72 70.59,22.72 70.27,23.03 v5(69.97,23.03)
DDR_A_D43: length 15.9
  IN3 w0.076: v5(72.92,35.03) 72.83,34.94 72.83,34.48 73.19,34.12 73.19,32.67 72.97,32.45 72.97,31.06 72.52,30.61 72.52,24.17 71.47,23.12 71.47,22.87 71.15,22.55 70.52,22.55 70.31,22.77 69.89,22.77 69.63,23.03 v5(69.32,23.03)
  BOTTOM w0.076: UCPU1.R34 v5(72.92,35.03)
DDR_A_D44: length 9.9
  IN3 w0.076: v5(69.97,25.43) 70.28,25.43 70.62,25.77 70.96,25.77 71.09,25.91 71.09,26.9 70.74,27.25 70.74,28.5 70.83,28.59 71.05,28.59 71.13,28.67 71.13,28.8 71.05,28.89 70.83,28.89 70.74,28.98 70.74,29.11 70.83,29.2 71.05,29.2 71.13,29.28 71.13,30.68 71.05,30.77 70.83,30.77 70.75,30.86 70.75,30.98 70.83,31.07 71.05,31.07 71.13,31.16 71.13,31.41 71.62,31.9 v5(71.62,32.75)
DDR_A_D45: length 10.7
  IN3 w0.076: v5(71.62,34.05) 71.62,33.74 71.86,33.5 71.86,31.9 71.29,31.33 71.29,25.32 71.07,25.1 70.75,25.1 70.28,24.63 v5(69.97,24.63)
DDR_A_D46: length 12.9
  IN3 w0.076: v5(69.32,23.83) 69.32,23.76 69.73,23.35 71.23,23.35 72.21,24.33 72.21,30.73 72.64,31.16 72.64,32.81 72.92,33.09 v5(72.92,33.4)
DDR_A_D47: length 12.6
  IN3 w0.076: v5(72.92,34.05) 72.92,33.74 72.68,33.5 72.68,33.08 72.48,32.88 72.48,31.21 72.06,30.8 72.06,24.42 71.16,23.52 70.29,23.52 v5(69.97,23.83)
DDR_A_D48: length 12.6
  IN1 w0.076: v2(67.37,24.63) 67.42,24.69 67.42,24.91 67.03,25.3 67.03,25.55 66.96,25.63 66.96,31.46 67.36,31.86 67.36,32.77 67.76,33.17 67.76,34.64 67.68,34.72 67.68,35.64 68,35.96 v4(68,36.16)
  IN3 w0.076: v5(68.24,36.39) v4(68,36.16)
DDR_A_D49: length 14.1
  IN1 w0.076: v4(68,35.51) 68,35.3 68.33,34.98 68.33,34.22 68.53,34.02 68.53,33.45 68.27,33.19 68,33.19 67.51,32.7 67.51,31.8 67.13,31.41 67.13,31.29 67.22,31.2 67.41,31.2 67.5,31.11 67.5,30.99 67.41,30.9 67.22,30.9 67.13,30.81 67.13,30.68 67.22,30.59 67.41,30.59 67.5,30.5 67.5,30.38 67.41,30.29 67.22,30.29 67.13,30.2 67.13,28.41 67.22,28.32 67.52,28.32 67.61,28.24 67.61,28.11 67.52,28.02 67.22,28.02 67.13,27.93 67.13,27.8 67.22,27.71 67.52,27.71 67.61,27.63 67.61,27.5 67.52,27.41 67.22,27.41 67.13,27.32 67.13,25.74 67.37,25.5 v2(67.37,25.43)
  IN3 w0.076: v4(68,35.51) v5(68.24,35.74)
DDR_A_D50: length 15
  IN1 w0.076: v2(68.02,23.83) 68.09,23.83 68.51,24.26 68.51,25.35 68.93,25.77 68.93,26.24 69.11,26.42 69.11,31.11 69.6,31.6 69.6,34.32 69.26,34.65 69.26,35.2 69.36,35.29 69.36,35.67 69.23,35.8 69.23,36.94 68.91,37.26 v4(68.91,37.46)
  IN3 w0.076: v5(69.15,37.69) v4(68.91,37.46)
DDR_A_D51: length 16.4
  IN1 w0.076: v4(68.91,38.58) 69.23,38.26 69.23,37.24 69.38,37.08 69.38,35.86 69.53,35.71 69.53,35.25 69.42,35.13 69.42,34.72 69.75,34.38 69.75,31.53 69.28,31.06 69.28,27.18 69.78,26.69 69.78,26.41 69.73,26.36 69.73,26.29 69.28,25.83 69.23,25.83 68.68,25.28 68.68,23.84 v2(68.67,23.83)
  IN3 w0.076: v5(69.15,38.34) v4(68.91,38.58)
DDR_A_D52: length 16.7
  IN1 w0.076: v2(67.37,23.03) 66.55,23.43 66.31,23.67 66.31,25.79 66.6,26.08 66.6,31.55 67.05,31.99 67.05,32.89 67.45,33.29 67.45,34.52 67.38,34.59 67.38,35.77 67.53,35.92 67.53,37 67.72,37.45 v4(68,38.11)
  IN3 w0.076: v5(68.24,38.34) v4(68,38.11)
DDR_A_D53: length 16.5
  IN1 w0.076: v4(68.52,37.86) 68.52,37.56 68.09,37.13 67.87,37.13 67.68,36.94 67.68,35.86 67.53,35.7 67.53,34.65 67.6,34.58 67.6,33.23 67.2,32.83 67.2,31.92 66.78,31.5 66.78,25.97 66.48,25.66 66.48,23.73 66.62,23.59 67.13,23.59 v2(67.37,23.83)
  IN3 w0.076: v5(68.24,37.69) v4(68.52,37.86)
DDR_A_D54: length 13.3
  IN1 w0.076: v2(68.02,24.63) 68.23,24.63 68.33,24.74 68.33,25.4 68.43,25.5 68.43,26.69 68.62,26.89 68.7,26.89 68.81,26.99 68.81,27.33 68.73,27.41 68.66,27.41 68.56,27.5 68.56,27.68 68.67,27.79 68.71,27.79 68.8,27.88 68.8,28 68.72,28.09 68.7,28.09 68.62,28.17 68.62,28.4 68.86,28.64 68.86,31.11 69.45,31.69 69.45,34.25 69.11,34.59 69.11,35.26 69.2,35.35 69.2,35.61 68.91,35.9 v4(68.91,36.16)
  IN3 w0.076: v5(69.15,36.39) v4(68.91,36.16)
DDR_A_D55: length 13.8
  IN1 w0.076: v2(68.02,25.43) 67.93,25.52 67.93,25.9 68.02,25.99 68.18,25.99 68.26,26.07 68.26,26.86 68.38,26.98 68.38,28.55 68.47,28.64 68.59,28.64 68.68,28.72 68.68,28.85 68.59,28.94 68.47,28.94 68.38,29.03 68.38,29.18 68.47,29.27 68.62,29.27 68.71,29.36 68.71,29.49 68.62,29.58 68.47,29.58 68.38,29.67 68.38,29.79 68.47,29.88 68.62,29.88 68.71,29.97 68.71,30.1 68.62,30.19 68.48,30.19 68.38,30.29 68.38,30.41 68.46,30.49 68.62,30.49 68.71,30.58 68.71,30.71 68.62,30.8 68.49,30.8 68.38,30.9 68.38,31.11 68.46,31.18 68.71,31.18 68.8,31.27 68.8,31.4 68.62,31.58 68.62,31.7 68.72,31.8 68.84,31.8 68.97,31.66 69.16,31.66 69.29,31.79 69.29,34.09 68.88,34.49 v4(68.88,35.48)
  IN3 w0.076: v4(68.88,35.48) v5(69.15,35.74)
DDR_A_D56: length 14.8
  IN1 w0.076: v4(70.74,36.16) 70.45,35.87 70.45,34.6 70.39,34.55 70.39,33.2 70.48,33.11 70.58,33.11 70.67,33.03 70.67,32.9 70.58,32.81 70.48,32.81 70.39,32.72 70.39,32.59 70.48,32.5 70.58,32.5 70.67,32.42 70.67,32.29 70.58,32.2 70.48,32.2 70.39,32.11 70.39,31.98 70.48,31.9 70.58,31.9 70.67,31.81 70.67,31.68 70.58,31.59 70.48,31.59 70.39,31.5 70.39,31.37 70.48,31.29 70.58,31.29 70.67,31.2 70.67,31.07 70.58,30.98 70.48,30.98 70.39,30.89 70.39,30.76 70.48,30.68 70.58,30.68 70.67,30.59 70.67,30.46 70.58,30.37 70.48,30.37 70.39,30.28 70.39,27.8 70.48,27.71 70.87,27.71 70.96,27.62 70.96,27.49 70.87,27.4 70.49,27.4 70.41,27.33 70.41,27.2 70.51,27.09 70.83,27.09 70.95,26.97 70.95,26.14 70.77,25.96 70.53,25.96 70,25.43 v2(69.97,25.43)
  IN3 w0.076: v5(70.97,36.39) v4(70.74,36.16)
DDR_A_D57: length 16
  IN1 w0.076: v2(69.97,24.63) 70.12,24.48 70.28,24.48 70.37,24.58 70.37,24.79 70.47,24.88 70.74,24.88 70.82,24.97 70.82,25.1 70.73,25.19 70.31,25.19 70.22,25.28 70.22,25.42 70.55,25.76 71.02,25.76 71.12,25.86 71.12,27.88 71.04,27.97 70.64,27.97 70.56,28.05 70.56,28.18 70.66,28.27 71.06,28.27 71.14,28.35 71.14,28.49 71.05,28.58 70.63,28.58 70.55,28.66 70.55,28.8 70.63,28.88 70.91,28.88 70.99,28.96 70.99,29.09 70.89,29.19 70.63,29.19 70.55,29.27 70.55,29.41 70.63,29.49 71,29.49 71.1,29.59 71.1,30.17 70.83,30.43 70.83,33.13 70.7,33.26 70.7,35.41 v4(70.76,35.48)
  IN3 w0.076: v5(70.97,35.74) v4(70.76,35.48)
DDR_A_D58: length 17.3
  IN1 w0.076: v4(71.65,37.46) 72.09,37.02 72.09,35.31 71.97,35.19 71.97,30.98 72.11,30.83 72.11,29.11 72.46,28.76 72.46,24.09 71.09,22.72 70.59,22.72 70.27,23.03 v2(69.97,23.03)
  IN3 w0.076: v5(71.88,37.69) v4(71.65,37.46)
DDR_A_D59: length 18.9
  IN1 w0.076: v2(69.32,23.03) 69.8,22.76 70.56,22.55 71.16,22.55 72.67,24.05 72.67,28.77 72.26,29.18 72.26,30.9 72.12,31.04 72.12,35.13 72.24,35.25 72.24,37.32 v4(71.65,38.11)
  IN3 w0.076: v5(71.88,38.34) v4(71.65,38.11)
DDR_A_D60: length 14
  IN1 w0.076: v4(70.74,38.11) 70.23,37.6 70.23,36.13 70.14,36.04 70.14,34.81 70.06,34.73 70.06,27.07 70.45,26.69 70.45,26.36 70.01,25.92 69.8,25.92 v2(69.32,25.43)
  IN3 w0.076: v5(70.97,38.34) v4(70.74,38.11)
DDR_A_D61: length 14.2
  TOP w0.076: UD2.R10 v2(69.57,24.89)
  IN1 w0.076: v2(69.57,24.89) 69.57,25.38 69.95,25.75 70.08,25.75 70.63,26.3 70.63,26.74 70.23,27.14 70.23,34.6 70.29,34.66 70.29,35.93 70.38,36.02 70.38,37.11 v4(70.74,37.46)
  IN3 w0.076: v5(70.97,37.69) v4(70.74,37.46)
DDR_A_D62: length 16
  IN1 w0.076: v2(69.32,23.83) 69.8,23.35 71.31,23.35 72.2,24.23 72.2,28.81 71.95,29.06 71.95,30.78 71.82,30.91 71.82,35.26 71.94,35.38 71.94,35.87 v4(71.65,36.16)
  IN3 w0.076: v5(71.88,36.39) v4(71.65,36.16)
DDR_A_D63: length 15.1
  IN1 w0.076: v4(71.62,35.51) 71.49,35.38 71.49,35.21 71.67,35.03 71.67,30.85 71.8,30.72 71.8,29 71.9,28.89 71.9,24.51 71.99,24.42 71.99,24.27 71.87,24.14 71.71,24.14 71.63,24.23 71.5,24.23 71.41,24.14 71.41,24.01 71.5,23.93 71.5,23.79 71.22,23.52 70.58,23.52 70.42,23.67 70.27,23.67 70.13,23.54 69.99,23.54 69.9,23.63 69.9,23.76 v2(69.97,23.83)
  IN3 w0.076: v4(71.62,35.51) 71.87,35.73 v5(71.88,35.74)
DDR_A_DQS0: length 17.9
  IN3 w0.076: v5(64.12,25) 64.02,25 63.72,25.29 63.72,26.12 63.88,26.27 63.88,26.99 63.46,27.4 63.46,38.3 64.42,39.26 66.13,39.26 66.38,39.01 v5(66.68,39.01)
  BOTTOM w0.076: UD4.L10 v5(64.12,25)
DDR_A_DQS1: length 15.6
  TOP w0.076: UD2.G10 v2(64.12,25)
  IN1 w0.076: v4(66.27,36.73) 66.5,36.73 66.63,36.6 66.63,36.45 66.54,36.36 64.86,36.36 64.02,35.51 64.02,34.95 64.19,34.77 64.36,34.77 64.45,34.68 64.45,34.56 64.36,34.47 64.19,34.47 64.02,34.29 64.02,28.94 63.88,28.8 63.88,26.31 63.72,26.15 63.72,25.39 v2(64.12,25)
  IN3 w0.076: v5(66.03,36.49) v4(66.27,36.73)
DDR_A_DQS2: length 25.1
  TOP w0.076: UD2.D10 v2(62.17,24.27)
  IN1 w0.076: v4(68.54,41.11) 68.54,40.89 68.44,40.79 65.2,40.79 61.27,36.86 61.27,31.65 60.83,31.21 60.83,28.91 60.46,28.54 60.46,26.89 60.15,26.58 60.15,25.89 60.47,25.57 60.47,24.46 60.69,24.24 61.68,24.24 62.01,24.56 62.14,24.56 62.21,24.49 62.21,24.32 v2(62.17,24.27)
  IN3 w0.076: v5(68.31,40.88) v4(68.54,41.11)
DDR_A_DQS3: length 24.2
  IN3 w0.076: v5(62.17,24.27) 61.81,24.27 61.71,24.17 60.77,24.17 60.46,24.48 60.46,25.53 60.03,25.96 60.03,30.31 60.91,31.19 60.91,38.84 63.36,41.29 64.13,41.29 64.61,41.77 66.14,41.77 66.38,41.53 v5(66.68,41.53)
  BOTTOM w0.076: UD4.P10 v5(62.17,24.27)
DDR_A_DQS4: length 12.4
  IN3 w0.076: v5(66.72,24.63) 67.12,24.24 67.53,24.24 67.77,24.47 67.77,25.95 67.57,26.15 67.57,27.08 68.11,27.62 68.11,30.72 69.76,32.37 69.76,32.96 69.98,33.17 69.98,33.6 70,33.62 70,34.13 v5(69.76,34.37)
DDR_A_DQS5: length 14.9
  IN3 w0.076: v5(72.27,33.72) 72.37,33.82 72.37,33.93 72.06,34.25 71.94,34.25 71.86,34.17 71.86,33.74 72.13,33.47 72.28,33.47 72.36,33.4 72.36,33.21 72.14,32.99 72.14,32.72 72.07,32.65 72.07,32.42 72.14,32.35 72.14,32.11 72.07,32.04 72.07,31.81 72.14,31.74 72.14,31.54 71.6,31.01 71.6,24.83 71.07,24.31 70.45,24.31 70.38,24.38 70.15,24.38 70.08,24.31 69.84,24.31 69.77,24.38 69.54,24.38 69.47,24.31 69.23,24.31 69.06,24.14 68.93,24.14 68.86,24.21 68.86,24.32 v5(68.92,24.38)
  BOTTOM w0.076: UD4.D10 68.67,24.4 68.75,24.32 68.86,24.32 v5(68.92,24.38)
DDR_A_DQS6: length 15.6
  IN1 w0.076: v4(68.91,36.81) 68.84,36.88 68.65,36.88 68.52,36.74 68.52,35.37 68.7,35.18 68.7,34.41 68.97,34.15 68.97,32.4 68.68,32.11 68.31,32.11 68.07,31.87 68.07,27.23 67.53,26.69 67.53,25.98 67.76,25.74 67.76,24.35 67.58,24.16 67.28,24.16 66.81,24.63 v2(66.72,24.63)
  IN3 w0.076: v5(69.15,37.04) v4(68.91,36.81)
DDR_A_DQS7: length 16.5
  TOP w0.076: UD2.P10 v2(68.92,24.38)
  IN1 w0.076: v2(68.92,24.38) 68.92,24.47 69.09,24.65 69.19,24.65 69.2,24.64 69.68,24.16 71.15,24.16 71.59,24.61 71.59,28.74 71.48,28.85 71.48,30.55 71.31,30.72 71.31,32.96 71.48,33.14 71.48,35 71.27,35.22 71.27,36.43 v4(71.65,36.81)
  IN3 w0.076: v5(71.88,37.04) v4(71.65,36.81)
DDR_A_DQS#0: length 17.7
  IN3 w0.076: v5(64.12,25.8) 64.2,25.72 64.2,25.32 64.12,25.24 63.99,25.24 63.87,25.36 63.87,26.05 64.03,26.21 64.03,27.05 63.61,27.47 63.61,34.5 63.68,34.57 63.68,34.81 63.61,34.88 63.61,35.11 63.68,35.18 63.68,35.42 63.61,35.49 63.61,36.26 63.69,36.33 63.69,36.57 63.61,36.64 63.61,36.87 63.69,36.95 63.69,37.19 63.61,37.26 63.61,37.49 63.69,37.56 63.69,37.8 63.61,37.88 63.61,38.23 64.48,39.1 64.65,39.1 64.72,39.03 64.95,39.03 65.03,39.1 65.26,39.1 65.33,39.03 65.56,39.03 65.64,39.1 65.94,39.1 v5(66.03,39.01)
  BOTTOM w0.076: UD4.L11 64.25,25.56 64.25,25.67 v5(64.12,25.8)
DDR_A_DQS#1: length 15.6
  TOP w0.076: UD2.G11 v2(64.12,25.8)
  IN1 w0.076: v2(64.12,25.8) 64.2,25.72 64.2,25.43 64.11,25.35 63.99,25.35 63.87,25.46 63.87,26.09 64.03,26.25 64.03,28.74 64.17,28.88 64.17,34.23 64.26,34.32 64.42,34.32 64.6,34.49 64.6,34.75 64.42,34.93 64.26,34.93 64.17,35.02 64.17,35.45 64.92,36.2 66.6,36.2 66.78,36.38 66.78,36.59 v4(66.92,36.73)
  IN3 w0.076: v5(66.68,36.49) v4(66.92,36.73)
DDR_A_DQS#2: length 25.1
  TOP w0.076: UD2.D11 v2(62.17,25.07)
  IN1 w0.076: v2(62.17,25.07) 62.17,24.94 61.62,24.39 60.75,24.39 60.62,24.52 60.62,25.63 60.3,25.95 60.3,26.51 60.62,26.83 60.62,28.48 60.99,28.85 60.99,31.15 61.42,31.58 61.42,36.8 65.26,40.64 68.5,40.64 68.69,40.82 68.9,40.82 v4(69.19,41.11)
  IN3 w0.076: v5(68.96,40.88) v4(69.19,41.11)
DDR_A_DQS#3: length 24.2
  IN3 w0.076: v5(62.17,25.07) 62.44,25.07 62.53,24.98 62.53,24.65 62.43,24.55 62.01,24.55 61.89,24.42 61.75,24.42 61.65,24.33 60.83,24.33 60.62,24.54 60.62,25.59 60.18,26.03 60.18,30.24 61.06,31.12 61.06,38.78 63.42,41.14 64.19,41.14 64.67,41.62 65.94,41.62 v5(66.03,41.53)
  BOTTOM w0.076: UD4.P11 v5(62.17,25.07)
DDR_A_DQS#4: length 12.3
  IN3 w0.076: v5(66.72,25.43) 66.65,25.37 66.65,25.22 66.73,25.15 66.97,25.15 67.08,25.04 67.08,24.83 66.98,24.73 66.98,24.59 67.18,24.39 67.47,24.39 67.62,24.54 67.62,25.88 67.42,26.08 67.42,27.14 67.96,27.68 67.96,30.78 69.61,32.44 69.61,33.02 69.83,33.24 69.83,33.65 v5(69.76,33.72)
DDR_A_DQS#5: length 14.9
  IN3 w0.076: v5(68.92,25.18) 68.67,24.47 68.67,24.18 68.87,23.99 69.12,23.99 69.29,24.15 71.14,24.15 71.75,24.77 71.75,30.94 72.29,31.48 72.29,32.93 72.51,33.15 72.51,33.56 72.55,33.6 72.55,33.89 72.48,34.1 v5(72.27,34.37)
  BOTTOM w0.076: UD4.D11 v5(68.92,25.18)
DDR_A_DQS#6: length 15.7
  IN1 w0.076: v4(68,36.81) 68.14,36.81 68.36,36.59 68.36,35.3 68.55,35.11 68.55,34.35 68.82,34.08 68.82,32.46 68.62,32.26 68.24,32.26 67.92,31.93 67.92,27.29 67.38,26.75 67.38,25.92 67.61,25.68 67.61,24.41 67.51,24.31 67.35,24.31 66.96,24.7 66.96,25.06 v2(66.72,25.43)
  IN3 w0.076: v5(68.24,37.04) v4(68,36.81)
DDR_A_DQS#7: length 16.4
  TOP w0.076: UD2.P11 v2(68.92,25.18)
  IN1 w0.076: v2(68.92,25.18) 68.92,24.94 69.06,24.8 69.26,24.8 69.31,24.75 69.74,24.32 71.09,24.32 71.44,24.67 71.44,28.68 71.33,28.79 71.33,30.49 71.16,30.66 71.16,33.03 71.33,33.2 71.33,34.94 71.11,35.16 71.11,36.43 v4(70.74,36.81)
  IN3 w0.076: v5(70.97,37.04) v4(70.74,36.81)
DDR_A_ODT0: length 47.5
  TOP w0.076: v5(65.42,23.03) 65.72,23.33 65.72,26.41 65.61,26.52 65.61,28.45
  TOP w0.127: 65.61,28.45 65.61,28.99 RD73.1
  IN1 w0.076: v5(65.42,23.03) v4(65.2,23.31)
  IN3 w0.076: v5(74.18,36.73) 73.95,36.5 73.95,35.64 73.79,35.47 73.79,35.35 73.86,35.28 73.99,35.28 74.08,35.19 74.08,35.07 73.98,34.97 73.84,34.97 73.79,34.92 73.79,34.73 73.46,34.4 73.46,34.28 73.88,33.85 73.88,32.57 73.78,32.47 73.43,32.47 73.29,32.33 73.29,30.69 73.19,30.59 72.93,30.59 72.83,30.49 72.83,30.2 72.92,30.12 73.21,30.12 73.3,30.03 73.3,29.9 73.21,29.81 72.92,29.81 72.83,29.72 72.83,29.6 72.92,29.51 73.21,29.51 73.3,29.42 73.3,29.29 73.21,29.2 72.92,29.2 72.83,29.11 72.83,28.91 72.93,28.81 73.33,28.81 73.48,28.66 73.48,27.46 73.39,27.37 72.92,27.37 72.83,27.28 72.83,27.15 72.92,27.06 73.34,27.06 73.43,26.97 73.43,26.84 73.34,26.75 72.92,26.75 72.83,26.66 72.83,24.87 72.91,24.78 73.07,24.78 73.15,24.7 73.15,24.69 73.38,24.47 73.38,24.19 73.16,23.97 72.99,23.97 72.95,24.02 72.8,24.02 72.51,23.72 72.51,23.56 72.77,23.29 72.77,23.02 72.57,22.82 72.3,22.82 72.03,23.09 71.88,23.09 71.78,22.99 71.78,22.72 71.41,22.34 69.64,22.34 69.56,22.42 69.56,22.63 69.48,22.72 69.33,22.72 69.24,22.63 69.24,22.35 69.17,22.27 69.03,22.27 68.94,22.37 68.94,22.7 68.84,22.79 68.72,22.79 68.63,22.71 68.63,22.35 68.55,22.27 68.41,22.27 68.33,22.35 68.33,22.72 68.24,22.8 68.12,22.8 68.02,22.71 68.02,22.36 67.94,22.27 67.79,22.27 67.72,22.35 67.72,22.74 67.63,22.83 67.5,22.83 67.41,22.74 67.41,22.35 67.33,22.27 67.19,22.27 67.11,22.35 67.11,22.77 67.02,22.86 66.9,22.86 66.8,22.76 66.8,22.36 66.72,22.28 66.59,22.28 66.5,22.37 66.5,22.79 66.41,22.87 66.28,22.87 66.19,22.78 66.19,22.35 66.12,22.27 65.98,22.27 65.89,22.37 65.89,22.78 65.81,22.85 65.65,22.85 65.56,22.77 65.56,22.36 65.48,22.27 65.19,22.27 65.1,22.37 65.1,22.85 65.18,22.93 65.31,22.93 v5(65.42,23.03) v4(65.2,23.31)
  BOTTOM w0.076: UCPU1.AE31 78.83,36.73 v5(74.18,36.73)
DDR_B0_ZQ0: length 3.9
  TOP w0.127: UD3.B3 84.7,18.71 84.7,17.23 84.24,16.77 RD13.1
DDR_B0_ZQ1: length 4.7
  TOP w0.127: UD3.B4 84.37,19.51 84.05,19.18 84.05,17.25 83.68,16.88 RD14.1
DDR_B1_ZQ0: length 4.3
  BOTTOM w0.127: UD1.B3 93.15,18.71 93.15,17.26 94.59,15.82 RD8.1
DDR_B1_ZQ1: length 5.1
  BOTTOM w0.127: RD7.1 95.14,15.95 93.8,17.3 93.8,17.33 93.8,17.34 93.8,19.51 UD1.B4
DDR_B_CA1_0: length 38.1
  TOP w0.076: RD22.1 93.18,17.3 92.82,17.66 v2(92.82,17.85) UD3.R2
  IN1 w0.076: v2(92.82,17.85) 93.27,17.85 93.38,17.75 93.38,17.27 93.27,17.17 92.51,17.17 92.36,17.03 92.36,15.85 92.28,15.76 92.15,15.76 92.06,15.85 92.06,16.41 91.97,16.5 91.84,16.5 91.75,16.41 91.75,15.85 91.67,15.76 83.04,15.76 78.12,20.67 78.12,23.36 78.37,23.61 78.37,31.65 v4(78.57,31.84)
  IN3 w0.076: v5(78.57,32.17) v4(78.57,31.84)
  BOTTOM w0.076: v5(78.57,32.17) 78.92,32.53 78.92,33.6 79.04,33.72 UCPU1.AF35
DDR_B_CA1_1: length 36.7
  TOP w0.076: UD3.P2 v2(92.17,17.85) 92.62,17.4 RD24.1
  IN1 w0.076: v4(77.58,37.46) 78.4,37.14 78.52,37.14 78.67,37.08 78.74,37.01 78.78,36.95 78.96,36.43 78.96,35.3 79.01,35.17 79.02,35.13 79.02,35.13 79.03,35.07 79.07,34.76 79.09,34.56 79.1,34.39 79.1,34.09 79.07,33.95 79.07,33.95 79.04,33.84 79.04,23.27 78.75,22.99 78.75,21.27 79.19,20.48 83.29,16.37 90.69,16.37 v2(92.17,17.85)
  IN3 w0.076: v5(77.35,37.69) v4(77.58,37.46)
DDR_B_CA1_2: length 38.2
  TOP w0.076: RD26.1 91.51,17.84 v2(91.52,17.85) UD3.N2
  IN1 w0.076: v4(79.35,31.88) 79.6,31.88 79.71,31.78 79.71,31.39 79.62,31.3 79.39,31.3 79.31,31.22 79.31,31.1 79.41,31 79.62,31 79.71,30.91 79.71,30.78 79.62,30.69 79.39,30.69 79.31,30.61 79.31,30.49 79.41,30.39 79.62,30.39 79.71,30.3 79.71,30.17 79.62,30.08 79.39,30.08 79.31,30 79.31,29.88 79.41,29.78 79.62,29.78 79.71,29.69 79.71,29.56 79.62,29.47 79.39,29.47 79.31,29.39 79.31,29.27 79.41,29.17 79.62,29.17 79.71,29.08 79.71,28.95 79.62,28.86 79.39,28.86 79.31,28.78 79.31,28.66 79.41,28.56 79.62,28.56 79.71,28.47 79.71,28.34 79.62,28.25 79.39,28.25 79.31,28.17 79.31,28.05 79.41,27.95 79.62,27.95 79.71,27.86 79.71,27.33 79.22,26.84 79.22,23.24 78.9,22.93 78.9,21.76 79.03,21.63 79.03,21.51 78.92,21.4 78.92,21.27 79.01,21.18 79.14,21.18 79.25,21.29 79.37,21.29 79.6,21.07 79.6,20.73 79.67,20.66 79.67,20.53 79.58,20.44 79.58,20.31 79.67,20.22 79.79,20.22 79.89,20.32 80.01,20.32 80.12,20.21 80.12,20.08 80.03,19.98 80.03,19.86 80.12,19.77 80.24,19.77 80.34,19.87 80.47,19.87 80.56,19.78 80.56,19.65 80.46,19.55 80.46,19.43 80.55,19.34 80.68,19.34 80.77,19.43 80.9,19.43 81.28,19.05 81.28,18.67 83.4,16.56 85.67,16.56 85.82,16.71 85.82,16.83 85.91,16.92 86.04,16.92 86.13,16.83 86.13,16.72 86.3,16.54 88.31,16.54 88.81,17.04 89,17.04 89.09,16.95 89.09,16.78 89.18,16.69 89.3,16.69 89.39,16.78 89.39,16.95 89.48,17.04 89.61,17.04 89.7,16.95 89.7,16.78 89.79,16.69 89.91,16.69 90,16.78 90,16.95 90.09,17.04 90.25,17.04 90.33,16.96 90.33,16.79 90.42,16.7 90.61,16.7 90.73,16.83 90.73,16.96 90.61,17.08 90.61,17.21 90.7,17.3 90.84,17.3 91.04,17.11 91.17,17.11 91.26,17.19 91.26,17.32 91.17,17.41 91.17,17.58 91.44,17.85 v2(91.52,17.85)
  IN3 w0.076: v5(79.35,32.21) v4(79.35,31.88)
  BOTTOM w0.076: UCPU1.AE37 79.17,32.39 v5(79.35,32.21)
DDR_B_CA1_3: length 39.5
  TOP w0.076: RD28.1 92.06,17.36 91.82,17.6 91.82,18.74 v2(91.52,19.03)
  IN1 w0.076: v4(79.35,33.69) 79.25,33.58 79.25,32.34 79.37,32.23 79.54,32.23 79.86,31.91 79.86,27.26 79.37,26.77 79.37,23.18 79.06,22.86 79.06,21.82 79.77,21.11 79.77,20.8 81.49,19.09 81.49,18.8 83.54,16.75 85.5,16.75 86.01,17.26 86.27,17.26 86.35,17.18 86.35,16.81 86.44,16.72 86.57,16.72 86.66,16.81 86.66,17.17 86.75,17.26 86.87,17.26 86.96,17.17 86.96,16.81 87.05,16.72 87.18,16.72 87.27,16.81 87.27,17.25 87.36,17.34 87.49,17.34 87.57,17.25 87.57,16.8 87.66,16.71 87.79,16.71 87.88,16.8 87.88,17.17 87.96,17.26 88.09,17.26 88.18,17.17 88.18,17 88.27,16.91 88.4,16.91 88.49,17 88.49,17.17 88.58,17.26 89.03,17.26 89.31,17.53 89.43,17.53 89.52,17.45 89.52,17.31 89.61,17.22 89.73,17.22 89.82,17.31 89.82,17.45 89.91,17.53 90.04,17.53 90.13,17.45 90.13,17.31 90.22,17.22 90.34,17.22 90.43,17.31 90.43,17.45 90.52,17.53 90.87,17.53 91.27,17.93 91.27,18.28 91.36,18.37 91.48,18.37 91.85,18.01 91.95,18.01 92.06,18.11 92.06,18.23 91.84,18.45 91.84,18.59 91.75,18.69 91.24,18.69 91.12,18.81 91.12,19.02 91.22,19.13 91.43,19.13 v2(91.52,19.03)
  IN3 w0.076: v5(79.17,33.4) v4(79.35,33.69)
DDR_B_CA1_4: length 39.5
  TOP w0.076: RD30.1 90.95,17.48 91.2,17.74 91.2,18.7 v2(90.87,19.03)
  IN1 w0.076: v2(90.87,19.03) 90.87,18.88 90.78,18.79 90.55,18.79 90.47,18.72 90.47,18.58 90.56,18.49 91.01,18.49 91.1,18.4 91.1,18 90.8,17.7 89.24,17.7 88.97,17.43 87.84,17.43 87.67,17.6 87.67,18.24 87.59,18.32 87.46,18.32 87.36,18.23 87.36,17.59 87.2,17.43 86.58,17.43 86.49,17.52 86.49,17.71 86.41,17.79 86.28,17.79 86.19,17.7 86.19,17.52 86.1,17.43 85.92,17.43 85.41,16.92 83.61,16.92 81.64,18.89 81.64,19.15 79.92,20.87 79.92,21.17 79.21,21.89 79.21,22.8 79.52,23.12 79.52,26.71 80.02,27.2 80.02,31.98 79.59,32.41 79.59,33.03 79.67,33.12 79.67,33.82 79.42,34.07 79.42,35.1 79.12,35.4 79.12,37.03 78.69,37.46 v4(78.49,37.46)
  IN3 w0.076: v5(78.26,37.69) v4(78.49,37.46)
DDR_B_CA1_5: length 38
  TOP w0.076: UD3.F3 v2(86.72,18.78) 86.67,18.74 86.67,17.67 87.04,17.31 RD32.1
  IN1 w0.076: v2(86.72,18.78) 86.66,18.84 86.51,18.84 86.38,18.72 86.38,18.52 86.65,18.26 86.65,18.08 86.56,17.99 86.24,17.99 85.4,17.15 83.67,17.15 81.8,19.02 81.8,19.21 80.95,20.05 80.95,20.18 81.01,20.24 81.01,20.36 80.92,20.45 80.8,20.45 80.74,20.39 80.61,20.39 80.52,20.48 80.52,20.61 80.57,20.66 80.57,20.78 80.47,20.88 80.36,20.88 80.31,20.83 80.18,20.83 80.09,20.92 80.09,21.04 80.12,21.07 80.12,21.2 79.36,21.95 79.36,22.74 79.68,23.05 79.68,23.29 79.81,23.43 79.81,23.6 79.7,23.71 79.7,26.68 80.17,27.15 80.17,28.33 80.52,28.67 80.52,28.84 80.18,29.18 80.18,32.05 79.74,32.48 79.74,32.97 79.86,33.09 79.86,33.94 79.57,34.23 79.57,35.16 79.27,35.47 79.27,37.34 79.18,37.43 79.02,37.43 78.93,37.52 78.93,37.65 79.02,37.74 79.18,37.74 79.27,37.83 79.27,37.99 79.15,38.11 78.95,38.11 78.62,37.78 75.41,37.78 75.29,37.66 v4(75.29,37.46)
  IN3 w0.076: v5(75.53,37.69) v4(75.29,37.46)
DDR_B_CA1_6: length 39.6
  TOP w0.076: RD34.1 85.92,16.28 86,16.36 86,18.71 v2(86.32,19.03)
  IN1 w0.076: v4(77.58,38.11) 77.58,38.33 77.68,38.43 77.85,38.43 77.93,38.34 77.93,38.3 78.02,38.21 78.15,38.21 78.24,38.3 78.24,38.34 78.32,38.43 79.41,38.43 79.57,38.26 79.57,35.59 79.88,35.29 79.88,34.39 80.53,33.73 80.53,32.04 81.02,31.55 81.02,30.08 81.11,29.99 81.22,29.99 81.31,29.9 81.31,29.77 81.22,29.68 81.09,29.68 81,29.6 81,29.47 81.09,29.38 81.22,29.38 81.31,29.29 81.31,29.16 81.22,29.07 81.14,29.07 81.05,28.99 81.05,28.78 80.48,28.21 80.48,27.02 80.24,26.79 80.24,26.56 80.16,26.47 80.1,26.47 80.01,26.39 80.01,26.26 80.1,26.17 80.16,26.17 80.24,26.08 80.24,25.95 80.16,25.86 80.1,25.86 80.01,25.78 80.01,25.65 80.1,25.56 80.16,25.56 80.24,25.47 80.24,25.34 80.16,25.25 80.12,25.25 80.03,25.17 80.03,25.04 80.12,24.95 80.16,24.95 80.24,24.86 80.24,24.73 80.16,24.65 80.12,24.65 80.03,24.56 80.03,24.43 80.12,24.34 80.16,24.34 80.24,24.25 80.24,24.12 80.16,24.04 80.12,24.04 80.03,23.95 80.03,23.82 80.12,23.73 80.16,23.73 80.24,23.64 80.24,23.43 79.99,23.17 79.99,23.04 80.08,22.95 80.2,22.95 80.42,23.17 80.56,23.17 80.65,23.08 80.65,22.97 80.42,22.74 80.42,22.61 80.51,22.52 80.63,22.52 80.87,22.76 80.98,22.76 81.07,22.67 81.07,22.53 80.85,22.31 80.85,22.18 80.94,22.09 81.06,22.09 81.29,22.32 81.43,22.32 81.53,22.22 81.53,22.07 81.46,22 81.46,21.89 81.57,21.77 81.73,21.77 81.84,21.66 81.84,21 81.66,20.82 81.66,20.7 81.57,20.61 81.47,20.61 81.38,20.52 81.38,20.4 81.47,20.31 81.57,20.31 81.66,20.22 81.66,19.89 82.15,19.4 82.15,19.21 82.44,18.91 82.62,18.91 82.74,18.8 82.74,18.62 83.26,18.09 83.36,18.09 83.47,17.99 83.47,17.88 83.86,17.5 84.52,17.5 84.61,17.58 84.79,17.58 84.88,17.5 85.28,17.5 86.09,18.31 86.09,18.4 86.22,18.53 86.22,18.69 86.14,18.77 86,18.77 85.92,18.85 85.92,19.18 86.02,19.28 86.31,19.28 86.39,19.21 86.39,19.1 v2(86.32,19.03)
  IN3 w0.076: v5(77.35,38.34) v4(77.58,38.11)
DDR_B_CA1_7: length 39.6
  TOP w0.076: v2(86.32,18.23) 86.32,16.36 86.48,16.21 RD36.1
  IN1 w0.076: v2(86.32,18.23) 86.25,18.23 85.34,17.33 83.78,17.33 81.98,19.13 81.98,19.31 81.49,19.79 81.49,20.02 81.22,20.29 81.22,20.67 81.43,20.88 81.43,21.02 81.32,21.13 81.15,21.13 80.86,20.84 80.73,20.84 80.57,21 80.57,21.14 80.94,21.5 80.94,21.64 80.86,21.72 80.71,21.72 80.32,21.32 80.21,21.32 80.12,21.41 80.12,21.56 80.69,22.13 80.69,22.25 80.6,22.34 80.48,22.34 79.94,21.81 79.82,21.81 79.73,21.9 79.73,22.03 80.26,22.56 80.26,22.67 80.17,22.76 80.03,22.76 79.73,22.46 79.6,22.46 79.51,22.55 79.51,22.67 79.83,22.99 79.83,23.23 80.02,23.42 80.02,23.6 79.86,23.77 79.86,26.61 80.33,27.08 80.33,28.27 80.9,28.84 80.9,28.98 80.81,29.07 80.51,29.07 80.42,29.16 80.42,29.28 80.51,29.37 80.76,29.37 80.85,29.46 80.85,29.59 80.76,29.68 80.51,29.68 80.42,29.77 80.42,29.89 80.51,29.98 80.76,29.98 80.85,30.07 80.85,30.2 80.76,30.29 80.51,30.29 80.42,30.38 80.42,30.5 80.51,30.59 80.76,30.59 80.85,30.68 80.85,30.81 80.76,30.9 80.51,30.9 80.42,30.98 80.42,31.11 80.51,31.2 80.76,31.2 80.85,31.29 80.85,31.51 80.76,31.59 80.64,31.59 80.56,31.51 80.43,31.51 80.34,31.6 80.34,31.73 80.43,31.82 80.43,31.92 80.38,31.98 80.38,33.07 80.29,33.16 80.12,33.16 80.03,33.24 80.03,33.37 80.12,33.46 80.29,33.46 80.38,33.55 80.38,33.65 79.73,34.3 79.73,35.23 79.42,35.53 79.42,38.15 79.3,38.27 78.66,38.27 v4(78.49,38.11)
  IN3 w0.076: v5(78.26,38.34) v4(78.49,38.11)
DDR_B_CA1_8: length 37.5
  TOP w0.076: RD38.1 85.36,16.27 85.67,16.58 v2(85.67,18.23)
  IN1 w0.076: v4(75.29,38.11) 75.41,38.23 75.41,38.6 75.5,38.68 75.65,38.68 75.73,38.61 75.73,38.03 75.82,37.93 76.22,37.93 76.31,38.02 76.31,38.16 76.03,38.44 76.03,38.58 76.13,38.69 76.31,38.69 76.4,38.6 76.4,38.5 76.48,38.43 76.6,38.43 76.69,38.51 76.69,38.66 76.78,38.75 79.62,38.75 79.88,38.49 79.88,35.72 80.18,35.42 80.18,34.58 80.86,33.91 80.86,32.14 81.62,31.38 81.62,28.91 80.78,28.08 80.78,26.89 80.55,26.66 80.55,23.64 82.35,21.83 82.35,21.71 82.17,21.52 82.17,21.36 82.24,21.28 82.8,21.28 82.9,21.18 82.9,20.79 82.73,20.62 82.73,20.33 82.94,20.12 82.94,20.01 82.83,19.9 82.83,19.77 82.93,19.66 83.07,19.66 83.14,19.58 83.14,19.47 83.31,19.3 83.8,19.3 83.95,19.16 84.13,19.16 84.39,19.42 84.51,19.42 84.65,19.28 84.65,19.16 84.43,18.94 84.43,18.52 84.6,18.35 84.78,18.35 84.91,18.48 85.11,18.48 85.2,18.57 85.2,18.77 85.31,18.89 85.46,18.89 85.83,18.52 85.83,18.39 v2(85.67,18.23)
  IN3 w0.076: v5(75.53,38.34) v4(75.29,38.11)
DDR_B_CA1_9: length 38.4
  TOP w0.076: RD40.1 84.8,16.58 85.02,16.8 v2(85.02,18.23)
  IN1 w0.076: v4(76.67,38.11) 76.82,37.96 77.14,37.96 77.24,38.06 77.24,38.48 77.33,38.58 79.53,38.58 79.73,38.38 79.73,35.66 80.03,35.35 80.03,34.52 80.71,33.84 80.71,32.08 81.47,31.32 81.47,31.17 81.38,31.09 81.29,31.09 81.2,31 81.2,30.87 81.29,30.78 81.38,30.78 81.47,30.69 81.47,30.57 81.37,30.48 81.29,30.48 81.21,30.39 81.21,30.26 81.29,30.17 81.38,30.17 81.47,30.08 81.47,28.98 80.63,28.14 80.63,26.96 80.4,26.72 80.4,23.57 82.11,21.86 82.11,21.75 82,21.64 82,21.23 82.1,21.13 82.64,21.13 82.73,21.04 82.73,20.87 82.54,20.68 82.27,20.68 82.14,20.81 81.91,20.81 81.82,20.72 81.82,20.57 81.91,20.48 81.98,20.48 82.07,20.39 82.07,20.26 81.98,20.18 81.91,20.18 81.82,20.09 81.82,19.96 82.1,19.69 82.27,19.69 82.41,19.84 82.55,19.84 82.65,19.74 82.65,19.59 82.39,19.33 82.39,19.19 82.48,19.1 82.6,19.1 82.86,19.37 82.99,19.37 83.11,19.24 83.11,19.12 82.91,18.92 82.91,18.68 83.29,18.29 83.41,18.29 83.72,18.61 83.86,18.61 83.95,18.52 83.95,18.4 83.64,18.09 83.64,17.95 83.92,17.67 84.45,17.67 84.53,17.75 84.53,18.04 84.63,18.14 84.76,18.14 84.83,18.07 84.83,17.79 84.92,17.7 85.24,17.7 85.37,17.83 85.37,18.16 85.29,18.23 v2(85.02,18.23)
  IN3 w0.076: v5(76.44,38.34) v4(76.67,38.11)
DDR_B_CA2_0: length 36.3
  IN3 w0.076: v5(85.02,18.23) 85.02,18.41 85.12,18.51 85.48,18.51 85.57,18.6 85.57,18.78 85.5,18.86 85.17,18.86 85.08,18.95 85.08,19.17 84.98,19.27 84.59,19.27 84.51,19.36 84.32,19.36 84.14,19.17 84.01,19.17 83.85,19.33 83.66,19.33 83.47,19.14 83.16,19.14 83.06,19.23 83.06,19.85 82.99,19.93 82.83,19.93 82.72,19.82 82.72,19.26 82.65,19.19 82.49,19.19 82.41,19.27 82.41,19.92 82.33,20.01 82.18,20.01 82.09,19.92 82.09,19.28 82.01,19.19 81.86,19.19 81.77,19.28 81.77,20.07 81.89,20.19 81.89,20.35 81.8,20.43 81.53,20.43 81.45,20.35 81.45,19.27 81.36,19.18 81.24,19.18 81.14,19.28 81.14,20.35 81.06,20.43 80.92,20.43 80.83,20.34 80.83,19.28 80.75,19.21 80.61,19.21 80.52,19.3 80.52,19.63 80.43,19.72 80.31,19.72 80.23,19.81 80.23,19.93 80.31,20.02 80.43,20.02 80.52,20.11 80.52,20.24 80.43,20.33 80.31,20.33 80.23,20.42 80.23,20.54 80.31,20.63 80.55,20.63 80.64,20.72 80.64,20.85 80.56,20.94 80.31,20.94 80.23,21.03 80.23,21.15 80.31,21.24 80.53,21.24 80.61,21.33 80.61,21.45 80.52,21.55 80.31,21.55 80.23,21.63 80.23,21.76 80.31,21.85 80.6,21.85 80.69,21.95 80.69,22.07 80.61,22.16 80.31,22.16 80.23,22.24 80.23,22.37 80.31,22.46 80.48,22.46 80.58,22.56 80.58,22.68 80.5,22.77 80.33,22.77 80.24,22.86 80.24,22.98 80.32,23.07 80.46,23.07 80.55,23.16 80.55,23.32 80.46,23.4 80.31,23.4 80.23,23.48 80.23,28.27 82.74,30.78 82.74,33.02 82.59,33.18 82.59,33.65 82.51,33.72 v5(82.34,33.72)
  BOTTOM w0.076: v5(85.02,18.23) 85.03,18.23 85.03,17.31 84.45,16.73 RD42.1
DDR_B_CA2_1: length 36
  IN3 w0.076: v5(82.34,34.37) 82.43,34.46 82.68,34.46 82.77,34.37 82.77,34.16 82.68,34.06 82.34,34.06 82.1,33.82 82.1,33.61 82.2,33.51 82.2,33.34 82.1,33.24 82.1,33.08 81.85,32.83 81.85,32.62 82.05,32.41 82.48,32.41 82.58,32.32 82.58,32.17 82.49,32.09 82.03,32.09 81.95,32 81.95,31.88 82.04,31.78 82.51,31.78 82.59,31.7 82.59,31.56 82.5,31.48 82.03,31.48 81.94,31.39 81.94,31.28 82.03,31.19 82.51,31.19 82.59,31.11 82.59,30.85 82.16,30.42 82.04,30.42 81.84,30.62 81.71,30.62 81.63,30.53 81.63,30.4 81.82,30.2 81.82,30.08 81.73,29.99 81.6,29.99 81.41,30.19 81.28,30.19 81.19,30.1 81.19,29.97 81.39,29.77 81.39,29.65 81.3,29.56 81.17,29.56 80.98,29.75 80.85,29.75 80.76,29.67 80.76,29.54 80.96,29.34 80.96,29.22 80.87,29.13 80.74,29.13 80.55,29.32 80.42,29.32 80.33,29.23 80.33,29.11 80.52,28.92 80.52,28.77 80.08,28.34 80.08,22.75 80.04,22.71 80.04,20.96 80.14,20.85 80.14,20.71 80.04,20.61 80.04,20.32 80.13,20.23 80.13,20.07 80.04,19.98 80.04,19.78 80.36,19.46 80.36,19.25 80.57,19.04 80.85,19.04 80.95,18.94 80.95,18.76 81.03,18.68 81.16,18.68 81.26,18.78 81.26,18.93 81.35,19.03 81.48,19.03 81.57,18.94 81.57,18.71 81.66,18.62 81.78,18.62 81.88,18.71 81.88,18.94 81.97,19.04 82.1,19.04 82.18,18.95 82.18,18.73 82.28,18.63 82.39,18.63 82.48,18.72 82.48,18.93 82.59,19.04 83.03,19.04 83.12,18.94 83.12,18.71 83.33,18.5 83.62,18.5 83.69,18.57 83.81,18.57 83.95,18.43 83.95,18.3 83.76,18.11 83.76,17.8 83.89,17.66 84.46,17.66 84.54,17.74 84.54,18.05 84.63,18.14 84.76,18.14 84.85,18.06 84.85,17.76 84.94,17.66 85.3,17.66 85.38,17.74 85.38,17.9 85.27,18.01 85.27,18.21 85.4,18.34 85.56,18.34 v5(85.67,18.23)
  BOTTOM w0.076: v5(85.67,18.23) 85.66,18.23 85.66,16.57 85.57,16.48 RD44.1
DDR_B_CA2_2: length 35.7
  IN3 w0.076: v5(81.69,34.05) 81.63,34.11 81.63,34.23 81.82,34.42 81.96,34.42 82.13,34.25 82.13,34.09 81.93,33.89 81.93,33.15 81.63,32.85 81.63,32.58 81.47,32.42 81.47,32.23 81.61,32.09 81.61,31.98 81.53,31.9 81.4,31.9 81.31,31.81 81.31,31.69 81.4,31.59 81.54,31.59 81.62,31.51 81.62,31.36 81.54,31.28 81.41,31.28 81.34,31.22 81.34,31.09 81.48,30.95 81.48,30.84 79.98,29.34 79.98,29.2 79.92,29.14 79.81,29.14 79.71,29.25 79.6,29.25 79.51,29.16 79.51,24.22 79.77,23.95 79.77,22.91 79.71,22.85 79.71,19.67 80.05,19.33 80.05,19.12 80.44,18.74 80.54,18.74 80.66,18.61 80.66,18.47 80.56,18.37 80.56,18.25 80.65,18.16 80.78,18.16 80.91,18.28 81.04,18.28 81.12,18.19 81.12,17.81 81.02,17.7 81.02,17.53 81.1,17.45 81.34,17.45 81.43,17.53 81.43,18.22 81.52,18.31 81.64,18.31 81.73,18.22 81.73,17.53 81.82,17.45 81.95,17.45 82.04,17.54 82.04,18.22 82.13,18.31 82.25,18.31 82.34,18.22 82.34,17.55 82.43,17.46 82.58,17.46 82.86,17.74 82.86,17.87 82.65,18.08 82.65,18.38 82.73,18.47 82.89,18.47 82.96,18.39 82.96,18.25 83.04,18.17 83.35,18.17 83.43,18.09 83.43,17.93 83.35,17.85 83.3,17.85 83.22,17.77 83.22,17.63 83.31,17.55 83.54,17.55 83.76,17.33 85.5,17.33 85.64,17.48 85.79,17.48 85.87,17.39 86.34,17.39 86.52,17.58 86.52,18.15 86.43,18.23 v5(86.32,18.23)
  BOTTOM w0.076: RD46.1 86.69,16.37 86.32,16.74 v5(86.32,18.23)
DDR_B_CA2_3: length 36.8
  IN3 w0.076: v5(86.32,19.03) 86.25,19.03 85.97,18.75 85.97,18.56 86.05,18.48 86.54,18.48 86.69,18.33 86.69,17.49 86.37,17.17 83.69,17.17 83.47,17.38 83.24,17.38 83.05,17.57 82.92,17.57 82.65,17.29 80.94,17.29 80.74,17.5 80.74,17.64 80.91,17.8 80.91,17.92 80.82,18.01 80.68,18.01 80.51,17.84 80.39,17.84 80.3,17.93 80.3,18.06 80.41,18.17 80.41,18.29 80.31,18.4 80.2,18.4 80.08,18.28 79.95,18.28 79.84,18.39 79.84,18.5 80.09,18.74 80.09,18.87 80,18.96 79.86,18.96 79.68,18.78 79.55,18.78 79.47,18.86 79.47,19.02 79.74,19.29 79.74,19.43 79.56,19.61 79.56,22.91 79.62,22.98 79.62,23.89 79.36,24.16 79.36,29.44 79.43,29.52 79.55,29.52 79.66,29.4 79.79,29.4 79.89,29.5 79.89,29.64 79.74,29.79 79.74,29.91 79.83,30 79.96,30 80.13,29.83 80.26,29.83 80.35,29.92 80.35,30.04 80.17,30.22 80.17,30.34 80.26,30.43 80.39,30.43 80.56,30.26 80.68,30.26 80.77,30.35 80.77,30.48 80.6,30.65 80.6,30.77 80.69,30.86 80.83,30.86 81,30.69 81.11,30.69 81.23,30.8 81.23,30.93 81.05,31.11 81.05,31.24 81.21,31.4 81.21,31.57 81.14,31.64 81.14,31.88 81.3,32.05 81.3,32.49 81.47,32.65 81.47,32.91 81.77,33.22 81.77,33.69 81.67,33.79 81.52,33.79 81.32,33.99 81.32,34.16 81.69,34.53 v5(81.69,34.7)
  BOTTOM w0.076: RD48.1 85.01,16.84 85.37,17.2 85.37,18.36 85.75,18.73 86.02,18.73 v5(86.32,19.03)
DDR_B_CA2_4: length 36.3
  IN3 w0.076: v5(81.76,32.36) 81.85,32.27 81.85,32.14 81.77,32.06 81.77,31.8 81.88,31.69 81.88,31.55 81.77,31.45 81.77,31.23 82.04,30.97 82.04,30.86 81.96,30.78 81.67,30.78 80.15,29.27 80.15,29.07 80.32,28.9 80.32,28.79 80.18,28.65 80.05,28.65 79.97,28.73 79.97,28.82 79.87,28.92 79.75,28.92 79.66,28.82 79.66,28.55 79.75,28.46 79.84,28.46 79.93,28.37 79.93,28.24 79.84,28.15 79.75,28.15 79.66,28.07 79.66,27.94 79.75,27.85 79.84,27.85 79.93,27.76 79.93,27.63 79.84,27.55 79.75,27.55 79.66,27.46 79.66,27.33 79.75,27.24 79.84,27.24 79.93,27.15 79.93,27.02 79.84,26.94 79.75,26.94 79.66,26.85 79.66,26.72 79.75,26.63 79.84,26.63 79.93,26.54 79.93,26.42 79.84,26.33 79.75,26.33 79.66,26.24 79.66,26.11 79.75,26.02 79.84,26.02 79.93,25.93 79.93,25.81 79.84,25.72 79.75,25.72 79.66,25.63 79.66,25.5 79.75,25.41 79.84,25.41 79.93,25.32 79.93,25.2 79.84,25.11 79.75,25.11 79.66,25.02 79.66,24.89 79.75,24.8 79.84,24.8 79.93,24.71 79.93,24.59 79.84,24.5 79.75,24.5 79.66,24.41 79.66,24.28 79.75,24.19 79.84,24.19 79.93,24.1 79.93,22.85 79.86,22.78 79.86,19.74 80.2,19.4 80.2,19.19 80.5,18.89 80.7,18.89 80.8,18.78 80.8,18.69 80.85,18.64 80.85,18.55 80.95,18.45 81.18,18.45 81.31,18.58 81.48,18.58 81.59,18.47 81.89,18.47 81.97,18.55 82.12,18.55 82.2,18.47 82.51,18.47 82.74,18.69 82.89,18.69 83.25,18.33 83.47,18.33 83.59,18.22 83.59,17.73 83.83,17.5 85.43,17.5 85.55,17.62 85.55,17.9 85.64,17.99 85.76,17.99 85.85,17.9 85.85,17.65 85.94,17.56 86.27,17.56 86.35,17.64 86.35,17.85 85.92,18.29 85.92,18.36 85.8,18.47 85.8,18.82 85.92,18.93 85.92,19.17 85.72,19.37 85.72,19.51 85.83,19.63 85.94,19.63 86.19,19.37 86.55,19.37 86.67,19.26 86.67,18.59 86.78,18.48 87.15,18.48 87.27,18.6 87.27,18.84 87.08,19.03 v5(86.97,19.03)
  BOTTOM w0.076: v5(81.76,32.36) 81.76,32.68 UCPU1.AJ37 ; RD50.1 86.13,18.01 86.02,18.11 86.02,18.36 86.27,18.6 86.54,18.6 v5(86.97,19.03)
DDR_B_CA2_5: length 37.3
  IN3 w0.076: v5(91.05,17.88) 90.85,17.88 90.59,17.62 89.75,17.62 89.68,17.69 89.49,17.69 89.37,17.57 89.37,17.43 89.5,17.3 89.5,17.18 89.41,17.09 89.29,17.09 89.2,17.17 89.07,17.17 88.65,16.75 88.4,16.62 88.18,16.49 87.43,16.04 86.24,15.59 85.26,15.44 80.16,15.44 77.52,18.09 77.52,30.23 78.93,31.64 78.93,32.46 79.06,32.59 79.06,33.17 78.93,33.3 78.93,33.51 79.02,33.61 79.02,33.81 79.59,34.37 v5(79.82,34.37)
  BOTTOM w0.076: UD1.F3 91.18,18.72 91.18,18.01 v5(91.05,17.88) 91.23,17.69 RD52.1
DDR_B_CA2_6: length 36.9
  IN3 w0.076: v5(91.4,19.43) 91.38,19.44 90.99,19.44 90.89,19.34 90.89,19.22 90.8,19.13 90.67,19.13 90.58,19.22 90.58,19.34 90.49,19.43 90.26,19.43 90,19.69 89.61,19.69 89.4,19.47 88.93,19.47 88.33,18.88 88.33,18.8 88.18,18.5 88.04,18.3 87.72,17.98 87.72,17.59 87.34,17.21 86.6,16.67 85.98,16.54 80.6,16.54 78.69,18.45 78.69,19.43 78.79,19.53 78.79,23.12 78.59,23.94 78.59,29.7 80.64,31.75 80.64,32.32 80.74,32.42 80.74,33.12 80.85,33.23 v5(80.85,33.48)
  BOTTOM w0.076: v5(91.4,19.43) 91.4,19.16 UD1.E3 91.87,18.68 91.87,16.75 92.35,16.27 RD54.1 ; UCPU1.AJ36 81.61,33.48 v5(80.85,33.48)
DDR_B_CA2_7: length 37.1
  IN3 w0.076: v5(91.47,17.88) 91.2,17.68 90.33,17.23 87.56,15.91 86.37,15.46 85.68,15.28 80.1,15.28 77.37,18.02 77.37,30.28 77.64,30.93 77.72,31.11 78.36,32.31 78.58,32.53 78.72,32.64 78.84,32.78 78.88,32.87 78.88,33.09 78.76,33.2 78.76,33.58 78.83,33.77 78.88,33.91 79.54,34.65 v5(79.56,34.65)
  BOTTOM w0.076: UD1.E2 91.52,17.93 v5(91.47,17.88) 91.54,17.81 91.54,16.53 91.79,16.28 RD56.1 ; v5(79.56,34.65) 79.6,34.7 UCPU1.AG34
DDR_B_CA2_8: length 36.2
  IN3 w0.076: v5(80.47,34.05) 80.49,34.04 80.54,33.08 80.54,32.66 80.18,31.5 78.44,29.76 78.44,23.93 78.63,23.11 78.63,19.72 78.54,19.46 78.54,18.39 80.55,16.38 86.07,16.38 86.69,16.51 87.45,17.08 87.89,17.52 87.89,17.91 88.23,18.25 88.24,18.26 88.56,18.83 88.59,18.89 88.76,19.06 89.16,19.06 89.5,18.85 89.53,18.84 89.72,18.81 91.3,18.81 91.39,18.72 91.39,18.64 91.48,18.55 91.61,18.55 91.69,18.64 91.69,18.72 91.78,18.81 91.92,18.81 92,18.74 92,18.41 v5(92.18,18.23)
  BOTTOM w0.076: RD58.1 92.91,16.4 92.27,17.04 92.27,18.13 UD1.D2
DDR_B_CA2_9: length 36.3
  IN3 w0.076: v5(80.16,33.26) 80.38,32.95 80.38,32.75 80.04,31.82 79.93,31.5 79.92,31.49 78.28,29.85 78.28,23.91 78.48,23.09 78.48,19.75 78.38,19.48 78.38,18.33 80.51,16.2 86.11,16.2 86.69,16.34 86.8,16.38 87.97,17.01 88.49,17.42 88.6,17.62 88.67,17.86 88.68,17.95 88.68,18.62 88.74,18.8 88.83,18.89 89.06,18.89 89.53,18.64 90.89,18.5 92.07,18 92.18,17.99 92.35,18.01 v5(92.82,18.23)
  BOTTOM w0.076: v5(92.82,18.23) 92.83,18.22 92.83,17.16 93.47,16.53 RD60.1 ; UCPU1.AG36 80.31,33.4 v5(80.16,33.26)
