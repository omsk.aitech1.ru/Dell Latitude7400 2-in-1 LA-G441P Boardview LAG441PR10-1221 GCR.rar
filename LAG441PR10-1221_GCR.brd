# Allegro board LAG441PR10-1221_GCR.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLK_PCIE_P1_R: length 2.7
  BOTTOM w0.112: JNGFF3.47 209.41,28.8 209.26,28.65 207.86,28.65 RN45.2
CLK_PCIE_P2: length 164.1
  TOP w0.112: RN22.1 205.73,51.52 206.15,51.52 v6(206.42,51.8)
  IN3 w0.074: v6(206.42,51.8) 206.24,51.61 206.07,51.61 205.71,51.25 205.71,50.71 203.62,48.62 203.62,42.66 199.89,38.92 199.3,38.92 193.59,33.22 191.71,33.22 191.7,33.23 191.26,33.17 191.24,33.16 190.31,33.04 190.13,32.96 189.39,32.67 188.03,32.2 188.03,32.2 187.76,31.97 187.43,31.73 186.81,31.35 185.49,30.58 184.18,29.26 183.22,28.35 183.22,28.34 182.73,27.89 182.71,27.88 181.59,26.85 181.45,26.72 180.77,26.19 180.76,26.18 180.32,25.84 180.31,25.84 178.29,24.52 177.38,23.96 177.09,23.79 177.03,23.75 176.11,23.25 175.72,23.05 175.67,23.04 175.66,23.04 175.63,23.03 175.62,23.02 175.26,22.83 174.46,22.45 171.41,21.27 168.02,20.39 167.38,20.28 166.73,20.19 166.72,20.19 164.97,19.95 164.59,19.92 158.4,19.92 154.53,20.55 150.94,21.74 150.43,21.96 148.79,22.56 147.17,23.39 144.37,25.31 143.63,25.87 142.22,27.07 140.98,28.19 139.83,29.29 139.07,30.11 137.22,32.01 136.73,32.58 136.01,33.64 135.68,34.09 135.09,34.82 135.09,34.83 132.15,38.29 128.17,42.27 123.7,42.27 122.35,43.62 121.29,43.62 120.92,43.99 120.92,48.93 120.38,49.47 120.38,49.71 120.04,50.05 120.04,51.76 118.5,53.3 118.5,58.34 112.81,64.03 106.24,64.03 105.61,64.67 103.33,64.67 101.35,62.69 94.87,62.69 92.3,60.12 92.3,56.6 91.72,56.01 91.72,55.24 91.17,54.69 90.88,54.69 90.47,54.29 v5(90.47,54.08)
CLK_PCIE_P2_R: length 3.7
  IN1 w0.074: v4(204.08,51.17) 204.08,51.04 204.16,50.97 204.42,50.97 204.49,51.04 204.49,51.46 204.68,51.65 204.68,51.79 204.82,51.93 205.19,51.93 205.32,51.8 205.32,51.49 205.26,51.42 205.03,51.42 204.95,51.5 v2(204.95,51.64)
  IN3 w0.074: v5(204.66,51.11) 204.15,51.11 v4(204.08,51.17)
CLK_PCIE_P4: length 249
  TOP w0.112: RR17.1 288.74,35.24 288.01,35.24 287.82,35.05 v7(283.06,35.05) 282.5,35.05 281.13,36.42 281.13,38.95 280.85,39.23 280.65,39.23 v2(280.54,39.34)
  IN1 w0.074: v2(280.54,39.34) 280.46,39.26 267.44,39.26 267.06,38.87 265.4,38.87 264.01,40.26 251.49,40.26 248.24,43.51 218.3,43.51 217.85,43.06 216.92,43.06 216.63,43.36 213.28,43.36 212.25,42.32 211.02,42.32 210.62,41.93 205.9,41.93 196.85,32.88 196.85,31.32 195.77,30.24 190.5,30.24 187.17,26.9 179.5,26.9 173.89,21.3 159.1,21.3 153.76,22.63 152.07,23.22 150.61,23.74 149.6,24.18 149.17,24.38 147.86,25.06 146.8,25.71 144.45,27.32 143.83,27.76 143.44,28.06 141.6,29.79 140.97,30.34 139.72,31.7 138.93,32.72 137.96,34.12 136.99,35.52 136.72,35.96 136.46,36.41 136.27,36.74 135.51,38.22 133.93,42.37 132.36,46.52 130.36,48.52 130.06,48.52 129.6,48.98 129.6,50.25 128.56,51.29 128.56,51.97 127.21,53.31 121.18,53.31 120.96,53.54 120.96,56.34 120.35,56.94 120.35,58.35 112.68,66.03 110.62,66.03 110.4,65.81 110.4,65.33 v4(110.3,65.24)
  IN3 w0.074: v4(110.3,65.24) 110.38,65.24 110.5,65.37 110.5,65.53 110.4,65.64 108.21,65.64 107.55,66.3 102.79,66.3 100.77,64.28 94.19,64.28 90.77,60.85 90.77,57.52 89.55,56.3 89.55,55.69 89.64,55.59 89.64,55.23 89.43,55.02 89.18,55.02 89.08,54.93 89.08,54.8 v5(89.16,54.73)
CLK_PCIE_P4_R: length 1.7
  TOP w0.112: RR17.2 289.76,35.26 290.08,35.26 290.31,35.03 290.47,35.03 290.57,35.12 UR1.5
CLK_PCIE_P5: length 234.1
  TOP w0.112: RN17.1 271.19,27.04 271.03,27.2 v7(271.03,28.49) 271.03,29.29 269.68,30.64 268.89,30.64 264.16,35.37 264.16,38.8 v2(264.26,38.91)
  IN1 w0.074: v2(264.26,38.91) 264.2,38.97 264.2,39.24 263.88,39.56 256.49,39.56 256.02,39.09 251.04,39.09 249.06,41.08 243.73,41.08 241.88,42.93 218.64,42.93 218.19,42.48 216.68,42.48 216.39,42.77 213.66,42.77 212.61,41.73 211.24,41.73 210.82,41.31 206.13,41.31 198.13,33.32 198.13,31.78 195.86,29.51 190.78,29.51 187.6,26.33 179.74,26.33 174.13,20.72 159,20.72 153.62,22.06 153.3,22.17 153.28,22.18 152.97,22.29 152.96,22.29 152.43,22.48 151.3,22.86 151.04,22.95 150.5,23.16 150.46,23.18 150.4,23.2 149.36,23.65 149.05,23.8 149.04,23.79 147.58,24.55 146.39,25.28 145.3,26.03 144.49,26.57 143.5,27.27 143.19,27.51 143.19,27.51 143.14,27.55 141.92,28.6 141.91,28.61 141.67,28.81 139.83,30.63 138.46,32.38 138.03,33 137.63,33.48 136.96,34.46 136.77,34.76 136.32,35.51 136.26,35.6 136.22,35.67 135.09,37.62 134.87,38.05 134.88,38.07 134.87,38.09 132.98,41.7 132.06,45.6 131.76,46.26 130.08,47.94 129.78,47.94 128.43,49.28 128.43,50.11 126.13,52.42 125.38,52.42 124.67,51.71 123.17,51.71 122.2,52.67 121,52.67 120.34,53.34 120.34,56.06 119.74,56.65 119.74,58.1 114.57,63.28 113.34,63.28 111.88,64.74 109.18,64.74 109.08,64.84 109.08,65.04 v4(109.26,65.22)
  IN3 w0.074: v5(90.9,55.01) 91.07,55.18 91.13,55.18 91.32,55.37 91.32,56.29 91.92,56.9 91.92,60.29 94.73,63.09 101.22,63.09 103.2,65.07 105.78,65.07 106.44,64.42 108.91,64.42 109.11,64.62 109.11,65.07 v4(109.26,65.22)
  BOTTOM w0.112: UCPU1.BE2 91.6,54.81 91.35,55.06 90.95,55.06 v5(90.9,55.01)
CLK_PCIE_P5_R: length 2.7
  TOP w0.112: RN17.2 271.19,26.46 271.01,26.29 271.01,25.77 v6(271.19,25.6)
  BOTTOM w0.112: JNGFF1.55 271.15,24.75 271,24.9 271,25.41 v6(271.19,25.6)
CLK_SMB: length 6.3
  TOP w0.127: v2(38.81,16.97) 38.67,17.12 38.48,17.12 38.22,17.38 38.22,18.93 v7(38.53,19.25) 38.73,19.45 39.58,19.45 PR195.1
  IN1 w0.061: v4(39.18,16.93) 39.12,17 38.83,17 v2(38.81,16.97)
  IN3 w0.061: v5(38.81,16.97) 39.14,16.97 v4(39.18,16.93)
  BOTTOM w0.127: v5(38.81,16.97) 38.47,16.64 JBATT1.4
CLK_TP_SIO_I2C_DAT: length 6.7
  TOP w0.127: v2(270.19,58.47) 269.84,58.11 UE1.E10
  IN1 w0.061: v2(275.53,59.59) 271.44,59.59 270.93,59.07 270.93,58.64 270.83,58.54 270.26,58.54 v2(270.19,58.47)
CLKREQ_CNV: length 164.1
  TOP w0.127: RN32.2 218.81,36.98 218.52,37.27 v1(218.52,38.06) 218.52,39.64 v2(219.86,40.98) ; RC529.2 107.48,39.77 106.87,39.16 106.87,38.59 v6(107.3,38.15)
  IN1 w0.061: v2(219.86,40.98) 220.07,41.19 v4(220.13,41.19)
  IN2 w0.061: v4(220.13,41.19) 219.72,41.19 216.6,38.08 213.92,38.08 213.6,37.75 208.02,37.75 206.39,36.13 205.38,36.13 204.94,36.56 204.94,36.74 204.74,36.94 197.75,36.94 194.33,33.52 193.23,33.52 192.94,33.82 192.94,34.2 192.62,34.52 190.23,34.52 189.71,34 189.71,33.72 176.19,20.19 155.65,20.19 155.39,20.44 149.55,20.44 145.28,24.71 142.89,24.71 133.11,34.48 130.19,34.48 121.83,42.83 120.84,42.83 118.88,44.8 118.76,44.8 117.99,44.8 117.46,45.33 117.46,46.04 113.71,49.79 109.29,49.79 108.28,50.79 107.67,50.79 107.1,50.21 106.06,50.21 105.51,49.66 105.26,49.66 104.76,49.15 104.76,48.56 105.4,47.92 105.4,47.34 105.1,47.04 104.59,47.04 104.32,46.77 104.32,44.12 104.65,43.79 104.65,42.68 104.95,42.38 104.95,41.29 104.32,40.66 104.32,40 105.8,38.52 106.93,38.52 v6(107.3,38.15)
  BOTTOM w0.127: v6(107.3,38.15) 107.16,38.02 105.79,38.02 105.6,37.83 UCPU1.CH29
CLKREQ_CNV_R: length 3.7
  TOP w0.127: v6(219.72,37.5) 219.98,37.24 RN32.1 v1(219.98,36.07)
  BOTTOM w0.127: JNGFF3.14 219.28,37.05 v6(219.72,37.5)
CLKREQ_PCIE#0: length 158.7
  TOP w0.112: v2(48.4,44.67) 47.22,44.67 46.71,44.16 45.67,44.16 45.5,44.33 41.95,44.33 v2(41.44,43.82) ; v2(104.88,29.27) 105.18,29.27 105.36,29.09 105.36,28.24 105.62,27.98 105.62,27.26 106.04,26.83 v1(106.04,19.94) 106.04,17.83 v2(105.82,17.62)
  IN1 w0.074: v4(24.82,40.32) 25.07,40.57 27.29,40.57 27.79,40.07 28.93,40.07 32.88,44.02 40.35,44.02 40.55,43.82 v2(41.44,43.82) ; v2(48.4,44.67) 49.2,43.87 49.2,41.65 52.27,38.58 52.87,38.58 53.31,38.14 53.31,36.06 56.84,32.53 56.84,28.42 56.22,27.8 56.22,16.81 59.81,13.22 91.93,13.22 93.85,15.14 93.85,15.85 94.98,16.98 95.64,16.98 96.48,17.82 96.48,18.3 98.26,20.08 103.36,20.08 v2(105.82,17.62) ; v4(104.55,29.32) 104.82,29.32 v2(104.88,29.27)
  IN3 w0.074: v4(24.82,40.32) 24.66,40.16 v5(24.66,40.02) ; v5(103.75,34.21) 103.75,34.11 103.95,33.91 103.95,31.86 104.77,31.04 104.77,29.54 v4(104.55,29.32)
  BOTTOM w0.076: 29.81,46.29 29.77,46.25
  BOTTOM w0.112: UCPU1.CF32 104.69,35.48 103.75,34.54 v5(103.75,34.21) ; 29.77,46.25 29.77,45.62 29.22,45.07 26.86,45.07 25.31,43.52 25.31,40.67 v5(24.66,40.02) ; 29.81,46.29 30.1,46.58 30.75,46.58 31.01,46.85 31.01,48.49 31.21,48.69 32.42,48.69 33.2,49.47 33.2,52.31 32.47,53.03 32.47,54.35 32.29,54.53 31.41,54.53 30.96,54.97 30.96,55.65 30.75,55.86 30.75,56.49 RT71.1
CLKREQ_PCIE#0_R: length 3.5
  BOTTOM w0.076: UT2.AC5 28.77,55.49 29.14,55.12 29.34,55.12 29.65,55.44 29.83,55.44 29.95,55.55 29.95,56.71 RT71.2
  BOTTOM w0.102: RT71.2 RT10.1
CLKREQ_PCIE#1: length 140.8
  TOP w0.112: v2(104.25,33.95) 104.24,33.95 104.24,32.69 104.88,32.05 RC62.2 ; QN5.3 211.43,25.63 RN100.2 213,25.57 213.65,24.93 213.65,22.23 213.41,21.99 213.41,21.27 210.35,18.2 v1(210.35,15.08) 210.35,14.74 v2(211.07,14.02)
  IN1 w0.074: v4(104.1,35.62) 104.15,35.57 104.15,34.92 104.28,34.79 104.28,33.99 v2(104.25,33.95) 104.38,33.82 104.38,33.11 106,31.49 106.73,31.49 108.37,29.85 110.12,29.85 111.68,28.29 112.29,28.29 114.64,25.94 116.45,25.94 116.67,25.71 119.53,25.71 119.73,25.51 121.2,25.51 127.49,19.22 129.31,19.22 133.14,15.39 133.14,13.58 134.95,11.76 145.24,11.76 145.78,11.63 145.78,11.63 146.04,11.56 146.97,11.13 147.16,10.99 147.41,10.74 v4(148.87,10.4) ; v4(207.85,12.39) 209.48,14.02 v2(211.07,14.02)
  IN2 w0.076: v4(148.87,10.4) 149.26,9.5 149.42,9.37 185.5,9.37 186.75,10.62 205.88,10.62 207.65,12.39 v4(207.85,12.39)
  IN3 w0.074: v5(103.78,35.74) 103.96,35.74 104.08,35.62 v4(104.1,35.62)
CLKREQ_PCIE#1_R: length 4.9
  TOP w0.127: v6(209.07,27.11) 209.19,27.23 QN5.6 209.66,26.79 209.9,26.55 210.95,26.55 211.17,26.78 RN99.2 RN100.1
  BOTTOM w0.127: v6(209.07,27.11) 209.26,27.3 JNGFF3.53
CLKREQ_PCIE#2: length 177.2
  TOP w0.112: v6(105.07,37.4) 105.07,37.71 106.32,38.97 106.32,39.22 106.91,39.81 RC63.2
  IN1 w0.074: v6(223.33,20.92) 218.4,20.92 215.83,18.35 211,18.35 207.51,14.86 203.37,14.86 203.12,15.12 200.9,15.12 197.51,11.73 186,11.73 185.3,11.02 179.95,11.02 179.09,10.16 156.54,10.16 155.45,10.26 154.5,10.37 152.9,10.62 147.76,12.24 146.82,12.46 146.42,12.64 146.28,12.67 146.28,12.67 145.73,12.81 145.71,12.82 145.65,12.83 145.38,12.9 135.42,12.9 134.66,13.66 134.66,15.49 129.79,20.35 127.96,20.35 121.65,26.66 121.26,26.66 120.91,27.01 119.83,27.01 119.83,27.01 119.82,27.01 119.66,26.85 117.14,26.85 116.92,27.07 115.11,27.07 112.75,29.43 112.15,29.43 110.59,30.99 108.84,30.99 107.21,32.63 106.61,32.63 106.4,32.84 106.4,33.83 106.11,34.12 106.11,35.4 104.81,36.7 104.81,37.15 v6(105.07,37.4)
  BOTTOM w0.112: v6(105.07,37.4) 105.07,37.35 104.76,37.04 UCPU1.CF30 ; v6(223.33,20.92) 224.09,21.68 224.09,31.3 222.87,32.51 222.87,36.9 215.74,44.03 215.74,50.2 214.08,51.86 JNGFF2.52
CLKREQ_PCIE#3: length 7.1
  TOP w0.112: RC58.2 104.88,30.51 105.3,30.93 105.3,32.22 104.66,32.86 v1(104.66,33.36) 104.66,33.7 v2(104.89,33.93)
  IN1 w0.074: v4(104.01,36.16) 104.23,36.16 104.53,35.86 104.53,35.15 104.66,35.02 104.66,34.16 v2(104.89,33.93)
  IN3 w0.074: v5(103.78,36.39) v4(104.01,36.16)
CLKREQ_PCIE#4: length 225.5
  TOP w0.112: v2(290.39,36.59) 290.66,36.32 UR1.2 ; v6(104.25,37.4) 104.25,37.5 105.9,39.15 105.9,39.41 106.34,39.85 RC67.2
  IN1 w0.074: v2(290.39,36.59) 290.67,36.32 v4(290.99,36.32) ; v6(104.25,37.4) 104.43,37.22 104.43,36.52 104.91,36.04 104.91,35.48 105.35,35.04 105.35,33.77 105.58,33.54 105.58,32.45 106.16,31.87 106.89,31.87 108.53,30.23 110.28,30.23 111.84,28.67 112.45,28.67 114.8,26.31 116.6,26.31 116.83,26.09 119.68,26.09 119.88,25.89 121.35,25.89 127.65,19.6 129.48,19.6 133.51,15.56 133.51,13.74 135.11,12.14 145.29,12.14 145.5,12.09 145.61,12.06 145.61,12.06 145.83,12.01 146.16,11.92 147.26,11.42 149.92,10.68 150.07,10.4 v4(150.07,10.39)
  IN2 w0.076: v4(150.07,10.39) 150.41,10.05 150.95,10.05 150.99,10.01 150.99,10.01 151.25,9.75 185.34,9.75 186.59,11 205.64,11 207.33,12.69 v4(207.33,12.71)
  IN3 w0.074: v5(275.68,35.83) 275.68,31.47 274.16,29.95 274.16,28.05 275.16,27.06 275.16,25.28 274.41,24.53 274.41,23.61 271.17,20.37 267.59,20.37 264.8,17.58 252.06,17.58 248.35,13.86 221.32,13.86 220.42,12.96 207.58,12.96 v4(207.33,12.71) ; v5(291.32,36.32) 291.32,36.32 v4(290.99,36.32)
  BOTTOM w0.076: UCPU1.CE30 103.91,37.04 104.25,37.38 v6(104.25,37.4)
  BOTTOM w0.112: v5(291.32,36.32) 287.29,36.32 286.8,35.83 v5(275.68,35.83)
CLKREQ_PCIE#5: length 196.8
  TOP w0.112: RC530.2 105.71,30.71 v1(105.71,32.38) 105.71,32.68 v2(105.98,32.95) ; QN4.3 269.22,35.19 269.09,35.32 268.54,35.32 RN96.2 268.18,35.11 267.63,34.55 v2(267.63,33.29)
  IN1 w0.074: v4(151.15,10.39) 151.14,10.4 150.95,10.76 146.78,12.06 146.29,12.28 145.77,12.41 145.77,12.41 145.66,12.44 145.66,12.44 145.34,12.52 135.26,12.52 133.89,13.89 133.89,15.72 129.64,19.97 127.8,19.97 121.5,26.28 121.11,26.28 120.76,26.63 119.99,26.63 119.83,26.47 116.98,26.47 116.76,26.69 114.95,26.69 112.6,29.04 112,29.04 110.43,30.61 108.68,30.61 107.05,32.25 106.43,32.25 105.98,32.7 v2(105.98,32.95) 105.98,33.67 105.73,33.93 105.73,35.22 105.35,35.6 v4(105.32,35.6) ; v4(267.54,32.89) 267.54,33.2 v2(267.63,33.29) ; v4(262.19,25.44) 262.19,24.47 257.38,19.67 254.44,19.67 252.63,17.85 241.13,17.85 240.05,18.93 224.21,18.93 222.72,20.42 218.43,20.42 215.99,17.98 211.16,17.98 206.91,13.73 v4(206.91,13.09)
  IN2 w0.076: v4(151.15,10.39) 151.15,10.39 151.41,10.13 185.18,10.13 186.43,11.39 186.75,11.39 186.75,11.39 205.21,11.39 v4(206.91,13.09)
  IN3 w0.074: v4(262.19,25.44) 262.19,25.49 262.78,26.08 263.54,26.08 267.58,30.12 267.58,32.77 267.54,32.81 v4(267.54,32.89) ; v5(104.69,36.39) 105.32,35.76 v4(105.32,35.6)
CLKREQ_PCIE#5_R: length 8
  TOP w0.127: v6(270.64,34.08) 270.22,33.67 QN4.6 270.22,32.65 269.94,32.37 v1(269.76,32.37) 269.18,32.37 268.76,32.8 268.76,33.64 268.55,33.84 RN95.1 RN96.1
  BOTTOM w0.127: v6(270.64,34.08) 270.4,33.84 JNGFF1.52
CNV_BRI_PRX_DTX: length 163.7
  TOP w0.127: RN46.2 222.31,32.74 v1(222.31,31.71) v6(222.31,30.56)
  IN1 w0.061: v4(107.32,43.47) 107.23,43.47 107.04,43.28 v2(107.02,43.28) ; v4(135.04,14.55) 135.04,15.63 128.63,22.05 126.79,22.05 v4(122.14,26.7)
  IN2 w0.061: v4(122.14,26.7) 122.14,26.71 122.14,27.28 122.66,27.79 122.66,30.14 123.15,30.63 123.15,36.25 120.28,39.12 118.39,39.12 113.58,43.92 109.83,43.92 109.48,43.58 107.43,43.58 v4(107.32,43.47)
  IN3 w0.061: v5(134.85,13.52) 135.04,13.71 v4(135.04,14.55)
  IN3 w0.076: v5(107.09,43.24) v4(107.32,43.47)
  BOTTOM w0.127: v5(134.85,13.52) 134.85,12.76 135.2,12.4 140.74,12.4 141.59,13.26 178.53,13.26 188.81,23.54 197.26,23.54 203.48,17.32 211.34,17.32 213.6,15.05 216.67,15.05 218.82,17.2 218.82,19.32 222.31,22.82 v6(222.31,30.56)
CNV_BRI_PRX_R_DTX: length 2.7
  TOP w0.127: v1(218.65,36.01) 218.65,35.34 v6(218.87,35.12) 218.92,35.07 RN46.1
  BOTTOM w0.127: JNGFF3.22 218.75,35.05 218.82,35.12 v6(218.87,35.12)
CNV_BRI_PTX_DRX: length 2.6
  TOP w0.127: RC525.2 v2(108.27,43.83)
  IN1 w0.061: v4(106.6,43.53) 106.6,43.56 106.9,43.86 108.24,43.86 v2(108.27,43.83)
  IN3 w0.076: v5(106.44,43.24) 106.6,43.4 v4(106.6,43.53)
CNV_BRI_PTX_R_DRX: length 162.6
  TOP w0.127: RC597.1 220.64,32.4 v6(220.19,32.85)
  IN1 w0.061: v4(123.24,26.69) 123.24,26.42 126.98,22.68 128.89,22.68 135.9,15.66 135.9,14.68 v4(135.78,14.55) ; v4(108.96,44.54) 108.85,44.43 v2(108.85,44.21)
  IN2 w0.061: v4(108.96,44.54) 113.78,44.54 118.63,39.7 120.53,39.7 123.73,36.5 123.73,30.39 123.24,29.9 v4(123.24,26.69)
  IN3 w0.061: v5(135.36,13.49) 135.78,13.91 v4(135.78,14.55)
  BOTTOM w0.127: v5(135.36,13.49) 135.23,13.37 135.23,12.88 135.35,12.76 140.59,12.76 141.44,13.61 178.16,13.61 188.45,23.89 197.41,23.89 203.48,17.82 211.55,17.82 213.81,15.56 216.46,15.56 218.31,17.41 218.31,19.53 221.45,22.67 221.45,29.38 221.87,29.8 221.87,31.17 v6(220.19,32.85) 218.89,31.55 JNGFF3.36
CNV_COEX1: length 197
  IN1 w0.061: v4(264.53,30.07) 265.2,29.4 271.65,29.4 272.34,30.08 272.34,30.19 272.47,30.32 272.91,30.32 v2(273.15,30.08)
  IN2 w0.061: v4(214.71,32.4) 214.04,33.06 210.11,33.06 209.4,32.35 199.28,32.35 198.51,31.59 188.53,31.59 176.45,19.51 155.32,19.51 155.06,19.77 149.27,19.77 145,24.04 142.48,24.04 139.92,26.6 130.81,26.6 130.57,26.84 128.84,26.84 128.79,26.9 127.47,26.9 127.13,26.55 125.45,26.55 124.77,27.23 124.77,28.73 125.51,29.48 125.51,32 124.9,32.61 124.9,36.91 120.99,40.82 119.1,40.82 113.94,45.98 111.87,45.98 111.35,46.5 109.31,46.5 v4(108.95,46.14)
  IN3 w0.061: v4(264.53,30.07) 264.53,29.59 263.23,28.3 253.03,28.3 250.75,26.01 238.71,26.01 237.28,27.45 229.1,27.45 228.29,28.26 223.84,28.26 222.3,29.8 219,29.8 216.39,32.4 v4(214.71,32.4) ; v4(108.95,46.14) 107.63,46.14 107.28,45.79 v5(106.64,45.79)
  BOTTOM w0.127: UCPU1.CH17 105.94,45.32 106.41,45.79 v5(106.64,45.79)
CNV_COEX2: length 194.7
  IN1 w0.061: v2(272.58,30.08) 272.58,30.03 271.74,29.19 262.81,29.19 262.66,29.34 261.89,29.34 261.75,29.2 v4(261.75,28.7)
  IN2 w0.061: v4(213.78,32.37) 209.77,32.37 209.51,32.1 199.38,32.1 198.61,31.33 188.67,31.33 176.59,19.25 155.22,19.25 154.95,19.52 149.16,19.52 144.9,23.78 142.37,23.78 139.84,26.32 130.71,26.32 130.44,26.59 128.74,26.59 128.68,26.64 127.58,26.64 127.23,26.3 125.34,26.3 124.51,27.12 124.51,28.84 124.76,29.08 124.76,36.88 120.94,40.69 119.04,40.69 113.91,45.83 109.75,45.83 v4(109.46,46.12)
  IN3 w0.061: v4(213.78,32.37) 214.19,32.77 216.45,32.77 219.29,29.92 222.35,29.92 223.89,28.38 228.34,28.38 229.15,27.57 237.33,27.57 238.76,26.14 250.7,26.14 252.98,28.42 261.47,28.42 v4(261.75,28.7) ; v4(109.46,46.12) 109.46,45.89 109.31,45.74 108.39,45.74 108.22,45.92 107.63,45.92 107.03,45.32 v5(106.44,45.32)
CNV_COEX3: length 197.1
  TOP w0.127: v2(136.85,17.87) 138.73,16 146.25,16 151.16,14.47 152.17,14.32 152.17,14.32 180.36,14.32 182.82,16.78 194.01,16.78 197.51,20.29 199.89,20.29 201.79,18.39 207.63,18.39 v1(210.16,20.91) 210.88,21.63 210.88,22 v2(211.56,22.68) ; RN54.2 271.72,30.08 271.5,29.86 271.5,27.74 271.83,27.41 271.83,25.65 272.11,25.37 272.11,23.45 271.61,22.95 v6(270.41,22.95)
  IN1 w0.061: v4(212.51,22.65) 212.48,22.68 v2(211.56,22.68) ; v4(111.26,35.07) 111.26,35.06 110.98,34.78 110.98,34.03 112.85,32.16 113.01,32.16 114.39,30.78 115.8,30.78 116.7,29.87 118.42,29.87 118.76,30.21 124.24,30.21 124.87,29.58 126.55,29.58 127.24,28.9 127.24,28.65 128.12,27.77 128.12,27.28 128.73,26.67 128.73,26.02 129.58,25.16 130.62,25.16 131.99,23.79 131.99,22.9 133.22,21.67 133.6,21.67 136.01,19.27 136.01,18.17 136.3,17.87 v2(136.85,17.87)
  IN3 w0.061: v5(110.64,42.27) 110.63,42.26 110.63,37.61 111.14,37.1 111.14,35.2 v4(111.26,35.07) ; v4(212.51,22.65) 213.03,22.65 213.79,23.41 217.55,23.41 217.92,23.03 235.95,23.03 238.5,20.48 264.84,20.48 267.32,22.95 270.4,22.95 v6(270.41,22.95)
  BOTTOM w0.127: UCPU1.CP20 109.15,43.41 109.79,42.77 110.15,42.77 v5(110.64,42.27)
CNV_DET#: length 4.6
  TOP w0.076: UE1.L11 271.03,52.82 271.03,52.3 271.12,52.2 271.12,51.35 271.03,51.26 271.03,51.05 271.45,50.63 271.55,50.63
  TOP w0.127: 271.55,50.63 272.39,49.79 RE485.2
CNV_PRX_DTX_N0: length 129.9
  IN3 w0.074: v5(109.69,37.15) 109.75,37.09 109.79,37.09 110.57,36.3 110.57,33.91 113.3,31.18 116.12,31.18 117.13,30.17 123.96,30.17 124.56,29.58 126.54,29.58 127.52,28.6 127.52,28.53 127.89,28.16 128.38,28.16 128.44,28.22 129.26,28.22 130.3,27.28 130.31,27.28 130.44,27.15 132.34,25.42 132.87,24.88 132.87,24.87 133.27,24.46 133.27,24.46 134.5,23.21 134.5,21.48 135.47,20.51 137.43,20.51 138.31,19.63 138.31,18.08 139.78,16.61 142.44,16.61 143.59,15.92 146.1,14.69 147.77,14.08 149.27,13.73 151.02,13.23 152.24,12.81 153.46,12.4 154.19,12.23 155.28,11.98 169.95,11.98 170.33,12 170.71,12.03 173.41,12.51 175.64,13.36 175.95,13.49 181.89,16.53 186.4,19.51 190.9,24.23 190.96,24.23 190.97,24.24 190.97,24.24 190.98,24.25 199.85,24.25 202.78,27.17 206.57,27.17 211.47,32.07 212.2,32.07 212.4,31.87 212.4,31.74 v5(212.53,31.61)
  BOTTOM w0.112: JNGFF3.15 211.1,36.8 211.25,36.65 211.63,36.65 212.21,36.07 212.21,32.12 212.42,31.91 212.42,31.72 v5(212.53,31.61)
CNV_PRX_DTX_N1: length 131.1
  IN3 w0.074: v5(213.09,32.78) 212.27,32.78 212.03,32.55 211.27,32.55 206.38,27.65 202.52,27.65 199.6,24.73 190.73,24.73 189.08,23.09 189.03,23.03 189.02,23.02 186.33,20.2 180.81,16.56 180.19,16.25 172.83,12.91 169.88,12.48 155.25,12.48 155.17,12.49 154.29,12.7 153.69,12.84 152.58,13.22 150.95,13.75 148.96,14.32 148.21,14.49 146.76,14.99 144.15,16.27 142.58,17.19 140.32,18.81 138.88,19.9 136.17,22.34 134.85,23.64 130.25,28.22 129.5,28.65 128.68,28.89 126.61,30.09 124.75,30.09 124.18,30.66 117.33,30.66 116.25,31.74 113.42,31.74 110.93,34.23 110.93,36.76 109.99,37.7 108.15,37.7 107.89,37.44 107.89,37.26 v5(107.74,37.11)
  BOTTOM w0.112: JNGFF3.9 211.1,38.3 211.26,38.14 211.96,38.14 212.76,37.35 212.76,32.84 212.91,32.68 212.99,32.68 v5(213.09,32.78)
CNV_PRX_DTX_P0: length 129.9
  IN3 w0.074: v5(212.12,31.61) 212.2,31.68 212.2,31.79 212.12,31.86 211.55,31.86 206.66,26.97 202.86,26.97 199.94,24.05 191.06,24.05 191.04,24.03 190.99,24.03 188.77,21.7 186.53,19.35 181.99,16.35 176.03,13.31 175.72,13.17 173.46,12.32 170.73,11.83 169.95,11.78 155.25,11.78 154.14,12.04 153.4,12.21 150.96,13.03 149.22,13.53 147.73,13.88 147.72,13.88 146.02,14.51 143.5,15.74 142.39,16.41 139.69,16.41 138.11,17.99 138.11,19.54 137.34,20.31 135.39,20.31 134.3,21.4 134.3,23.12 133.07,24.38 132.67,24.79 132.67,24.8 132.2,25.27 130.3,27 130.23,27.07 130.22,27.07 129.18,28.02 128.53,28.02 128.47,27.96 127.81,27.96 127.32,28.45 127.32,28.51 126.46,29.37 124.47,29.37 123.88,29.97 117.05,29.97 116.03,30.98 113.21,30.98 110.37,33.82 110.37,36.22 109.7,36.89 109.57,36.89 109.36,37.1 109.07,37.1 v5(109.05,37.08)
  BOTTOM w0.112: JNGFF3.17 211.1,36.3 211.25,36.45 211.54,36.45 212,35.99 212,32.04 212.21,31.83 212.21,31.7 v5(212.12,31.61)
CNV_PRX_DTX_P1: length 131
  IN3 w0.074: v5(108.39,37.15) 108.19,37.15 108.09,37.26 108.09,37.36 108.23,37.5 109.91,37.5 110.73,36.67 110.73,34.15 113.34,31.54 116.16,31.54 117.25,30.46 124.1,30.46 124.67,29.89 126.56,29.89 128.6,28.7 129.42,28.47 130.12,28.06 134.7,23.49 134.71,23.49 136.03,22.2 136.15,22.09 138.76,19.74 140.2,18.65 142.47,17.02 144.06,16.09 146.68,14.81 148.16,14.3 148.92,14.13 149.9,13.84 150.89,13.56 152.52,13.03 153.63,12.65 154.25,12.5 155.13,12.3 155.24,12.28 169.89,12.28 172.89,12.71 180.28,16.07 180.91,16.38 186.46,20.04 189.16,22.88 189.18,22.89 189.23,22.95 190.81,24.53 199.68,24.53 202.61,27.45 206.46,27.45 211.35,32.35 212.12,32.35 212.35,32.58 212.86,32.58 213.02,32.43 213.02,32.38 212.94,32.3 v5(212.76,32.3)
  BOTTOM w0.112: v5(212.76,32.3) 212.81,32.35 212.81,32.5 212.55,32.76 212.55,37.26 211.88,37.94 211.24,37.94 211.1,37.8 JNGFF3.11
CNV_PTX_DRX_N0: length 120.9
  IN3 w0.074: v5(207.61,25.85) 207.61,25.67 207.53,25.6 207.45,25.6 207.39,25.66 207.39,25.69 207.33,25.75 207.33,25.9 207.05,26.18 203.18,26.18 200.28,23.28 191.54,23.28 191.53,23.28 191.38,23.28 190.89,22.76 189.35,21.21 186.75,18.34 181.98,15.37 175.72,12.28 174.46,11.83 173.2,11.39 172.16,11.14 170.56,10.94 155.51,10.94 152.53,11.64 152.44,11.66 151.94,11.87 151.6,11.98 149.59,12.62 148.92,12.8 148.8,12.83 148.79,12.83 148.7,12.85 147.55,13.05 144.62,14.13 142.66,15.16 142.02,15.58 139.33,15.58 137.18,17.73 135.74,17.73 134.31,19.16 133.96,19.16 132.52,20.6 132.52,22.56 130.52,24.57 129.81,24.57 129.15,25.23 127.53,25.23 124.44,28.31 123.63,28.31 122.75,29.2 116.63,29.2 115.71,30.12 112.99,30.12 109.85,33.26 109.85,35.4 109.55,35.69 108.54,35.69 v5(108.39,35.84)
  BOTTOM w0.112: JNGFF3.65 209.42,24.3 209.24,24.12 208.14,24.12 207.53,24.73 207.53,25.52 207.4,25.65 207.4,25.8 207.45,25.85 v5(207.61,25.85)
CNV_PTX_DRX_N1: length 119.3
  IN3 w0.074: v5(109.34,35.19) 109.48,35.05 109.48,32.94 112.81,29.61 115.42,29.61 116.31,28.72 117.68,28.72 118.68,27.71 121.03,27.71 121.15,27.83 124.25,27.83 127.35,24.73 128.97,24.73 129.61,24.09 130.16,24.09 131.47,22.78 131.47,20.41 132.08,19.8 132.64,19.8 133.76,18.68 134.12,18.68 135.55,17.25 136.98,17.25 139.31,14.93 142.08,14.93 142.17,14.87 143.1,14.35 144.03,13.83 145.75,13.1 147.3,12.61 148.84,12.32 152.4,11.18 155.47,10.46 171.19,10.46 173.33,10.74 178.24,12.82 182.41,15.04 187.43,18.17 189.51,20.67 191.63,22.8 200.49,22.8 203.31,25.62 205.83,25.62 206.41,25.04 207.76,25.04 207.96,25.24 208.16,25.24 208.29,25.37 208.29,25.44 208.22,25.52 208.02,25.52 v5(208.01,25.51)
  BOTTOM w0.112: JNGFF3.59 209.46,25.8 209.33,25.67 208.56,25.67 208.21,25.32 208.09,25.32 208.01,25.4 v5(208.01,25.51)
CNV_PTX_DRX_P0: length 120.9
  IN3 w0.074: v5(107.74,35.89) 108.14,35.49 109.47,35.49 109.64,35.32 109.64,33.18 112.91,29.92 115.63,29.92 116.55,29 122.67,29 123.55,28.11 124.36,28.11 127.45,25.02 129.07,25.02 129.73,24.37 130.44,24.37 132.32,22.48 132.32,20.51 133.88,18.96 134.23,18.96 135.66,17.53 137.1,17.53 139.25,15.38 141.96,15.38 142.55,14.99 144.54,13.95 147.5,12.86 148.66,12.65 148.81,12.61 148.82,12.62 148.86,12.6 149.54,12.43 151.54,11.79 151.87,11.68 152.38,11.48 152.47,11.44 155.49,10.74 170.57,10.74 172.2,10.95 173.25,11.2 175.79,12.09 182.08,15.2 186.88,18.19 189.5,21.07 191.04,22.62 191.47,23.08 191.62,23.08 191.62,23.08 200.37,23.08 203.26,25.98 206.97,25.98 207.13,25.82 207.13,25.6 v5(207.1,25.57)
  BOTTOM w0.112: v5(207.1,25.57) 207.19,25.57 207.33,25.44 207.33,24.65 208.05,23.92 209.31,23.92 209.43,23.8 JNGFF3.67
CNV_PTX_DRX_P1: length 119.3
  IN3 w0.074: v5(108.62,35.23) 108.91,34.95 109.21,34.95 109.28,34.87 109.28,32.86 112.73,29.41 115.33,29.41 116.22,28.52 117.6,28.52 118.6,27.51 121.12,27.51 121.24,27.63 124.16,27.63 127.26,24.53 128.89,24.53 129.53,23.89 130.08,23.89 131.27,22.7 131.27,20.33 132,19.6 132.56,19.6 133.68,18.48 134.03,18.48 135.46,17.05 136.9,17.05 139.22,14.73 142.02,14.73 142.07,14.69 143.94,13.65 145.68,12.91 147.25,12.41 148.79,12.12 152.35,10.98 155.45,10.26 171.2,10.26 173.38,10.54 178.32,12.64 182.51,14.87 187.57,18.01 189.66,20.54 191.72,22.6 200.57,22.6 203.39,25.42 205.75,25.42 206.33,24.84 207.84,24.84 208.04,25.04 208.37,25.04 v5(208.39,25.06)
  BOTTOM w0.112: v5(208.39,25.06) 208.39,25.21 208.64,25.46 209.3,25.46 209.46,25.3 JNGFF3.61
CNV_RF_RESET: length 63.9
  TOP w0.127: RE485.1 272.39,48.18 v2(272.49,48.08) ; RN119.2 222.87,36.39 QN10.1 222.87,37.83 RW19.1 222.73,38.91 v1(227.52,38.91) 230.19,38.91 231.96,40.68 v2(231.96,46.12)
  IN1 w0.061: v2(231.96,46.12) 232.14,46.3 255.5,46.3 255.95,45.84 260.38,45.84 261.6,44.62 270.73,44.62 272.49,46.38 v2(272.49,48.08)
CNV_RF_RESET#: length 158.8
  TOP w0.127: RC528.2 108.5,32.58 107.24,33.83 v2(107.24,34.1) ; v6(223.62,30.59) v1(223.62,32.87) 223.62,32.9 221.61,34.91 RN118.1 221.03,35.11 220.62,35.52 220.62,37.81 220.39,38.04 RN31.2
  IN1 w0.061: v2(107.24,34.1) v4(107.24,34.8)
  IN2 w0.061: v4(121.75,23.73) 121.75,23.87 121.48,24.14 119.53,24.14 115.05,28.61 114.38,28.61 109.24,33.75 108.23,33.75 108.13,33.65 107.72,33.65 107.24,34.13 v4(107.24,34.8)
  IN3 w0.061: v5(106.87,35.77) 106.97,35.67 106.97,35.07 v4(107.24,34.8) ; v5(181.73,13.46) 182.25,12.93 183.82,12.93 184.14,13.25 201.06,13.25 202.47,14.66 209.18,14.66 212.22,17.7 215.16,17.7 216.18,18.71 v5(221.56,18.71) ; v5(134.48,12.57) 134.48,13.7 134.66,13.87 134.66,14.91 133.2,16.36 132.43,16.36 131.49,17.31 130.76,17.31 128.95,19.11 127.3,19.11 126.03,20.38 126.03,21.73 123.66,24.1 122.1,24.1 121.75,23.75 v4(121.75,23.73)
  BOTTOM w0.127: v5(181.73,13.46) 181.23,13.46 180.67,12.9 141.74,12.9 140.89,12.05 135.01,12.05 v5(134.48,12.57) ; v5(106.87,35.77) 106.71,35.83 UCPU1.CJ32 ; v5(221.56,18.71) 221.56,20.01 223.62,22.07 v6(223.62,30.59)
CNV_RF_RESET#_R: length 4.1
  TOP w0.127: v1(220.83,38.28) 220.6,38.51 219.56,38.51 219.39,38.35 RN31.1 219.09,37.74 v6(219.09,37.5)
  BOTTOM w0.127: v6(219.09,37.5) 218.54,38.05 JNGFF3.10
CNV_RGI_PRX_DTX: length 159.1
  TOP w0.127: RN47.2 220,30.65 v1(220.24,30.41) 220.6,30.41 v6(220.78,30.59) ; v2(106.03,44.16) 106.03,43.78 106.4,43.41 RC527.2
  IN1 w0.061: v2(106.03,44.16) 106.03,44.21 106.02,44.22 v4(106.02,44.51)
  IN2 w0.061: v4(123.78,26.7) 123.53,26.96 123.53,29.78 124.02,30.27 124.02,36.62 120.65,39.99 118.75,39.99 113.83,44.91 106.42,44.91 v4(106.02,44.51)
  IN3 w0.061: v5(105.79,44.28) v4(106.02,44.51) ; v4(123.78,26.7) 123.68,26.6 123.68,25.3 126.93,22.06 126.93,20.71 127.65,19.99 129.3,19.99 131.12,18.17 131.85,18.17 132.79,17.23 133.67,17.23 134.99,15.91 136.36,15.91 138.88,13.39 140.49,13.39 140.49,13.39 v5(140.48,13.39)
  BOTTOM w0.127: v6(220.78,30.59) 220.76,30.57 220.76,22.71 217.8,19.74 217.8,17.62 216.25,16.07 214.02,16.07 211.76,18.33 203.47,18.33 197.55,24.25 188.08,24.25 177.8,13.97 141.06,13.97 140.49,13.39 v5(140.48,13.39)
CNV_RGI_PRX_R_DTX: length 4.4
  TOP w0.127: v1(219.49,33.99) v6(219.49,32.85) 219.49,32.67 220,32.16 RN47.1
  BOTTOM w0.127: JNGFF3.34 218.81,32.05 219.49,32.73 v6(219.49,32.85)
CNV_RGI_PTX_DRX: length 2
  TOP w0.127: v1(104.19,44.28) 104.51,43.96 v2(105.03,43.96)
  IN1 w0.061: v2(105.03,43.96) 105.03,44.17 v4(105.37,44.51)
  IN3 w0.076: v5(105.14,44.28) v4(105.37,44.51)
CNV_RGI_PTX_R_DRX: length 157.4
  TOP w0.127: v6(218.86,32.81) 218.73,32.68 RC490.1 RC491.1
  IN1 w0.061: v4(135.43,14.96) 135.43,15.72 128.82,22.33 126.91,22.33 122.69,26.56 v4(122.69,26.7) ; v2(105.67,44.01) 105.48,43.82 v4(105.48,43.72)
  IN2 w0.061: v4(122.69,26.7) 122.69,27.42 122.95,27.67 122.95,30.02 123.44,30.51 123.44,36.38 120.41,39.41 118.51,39.41 113.71,44.21 109.71,44.21 109.36,43.87 107,43.87 106.94,43.92 106.35,43.92 106.29,43.87 105.68,43.87 105.53,43.72 v4(105.48,43.72)
  IN3 w0.061: v5(136.71,14.31) 136.06,14.96 v4(135.43,14.96)
  BOTTOM w0.127: v6(218.86,32.81) 218.6,32.55 JNGFF3.32 216.62,32.55 216.27,32.9 216.27,34.12 215.52,34.87 214.91,34.87 214.33,34.28 214.33,32.26 213.57,31.5 213.57,21.02 212.41,19.86 203.46,19.86 197.99,25.32 186.99,25.32 176.71,15.03 139.42,15.03 138.7,14.31 v5(136.71,14.31)
CNVI_EN#: length 171.7
  TOP w0.127: v1(249.19,47.31) 249.92,48.05 v6(250.04,48.05) 250.37,48.05 250.66,47.76 QN6.2 250.66,46.84 250.42,46.6 RN110.1
  IN1 w0.061: v4(220.99,35.44) 221.27,35.72 v2(221.61,35.72)
  IN2 w0.061: v6(250.04,48.05) 248.18,48.05 246.68,46.55 234.19,46.55 223.07,35.44 v4(220.99,35.44) 220.66,35.44 215.91,30.69 211.6,30.69 211.09,30.18 198.72,30.18 198.37,30.53 189,30.53 176.92,18.46 154.89,18.46 154.62,18.72 148.83,18.72 144.57,22.99 142.04,22.99 139.58,25.45 131.68,25.45 130.99,24.76 125.87,24.76 125.51,24.4 123.46,24.4 122.78,25.07 121.49,25.07 121.08,25.48 119.18,25.48 117.03,27.64 117.03,28.26 115.84,29.46 114.72,29.46 108.57,35.61 108.57,37.06 108.04,37.58 v4(107.34,37.58)
  IN3 w0.061: v5(106.96,37.67) 107.25,37.67 v4(107.34,37.58)
  BOTTOM w0.127: UCPU1.CH30 105.97,37.46 106.32,37.46 106.39,37.39 106.7,37.39 106.83,37.52 v5(106.96,37.67)
CNVI_RCOMP: length 3.2
  BOTTOM w0.305: RC439.2 111.57,36.85 110.47,35.74 UCPU1.CR32 109.4,35.74 109.38,35.77 UCPU1.CP32
CODEC_MUTE#: length 7.7
  TOP w0.127: UA1.2 279.99,25.82 279.09,26.73 RA118.2 278.78,26.75 CA32.2 278.19,26.76 RA121.1 277.95,27.32 277.63,27.64 DA27.2 ; DA27.2 277.37,27.26 277,26.89 RA120.2 ; DA27.2 276.73,27.64 v1(275.4,28.97)
CONTACTLESS_DET#: length 197.3
  TOP w0.127: v2(218.29,17.98) 218.29,19.01 217.82,19.47 v1(216.53,19.47) 215.04,19.47 214.09,20.42 214.09,21.65 214.35,21.91 214.35,25.58 212.5,27.44 v6(212.5,30.27) ; v2(107.05,33.03) 107.38,32.71 107.38,31.96 106.65,31.24 RC620.1
  IN1 w0.061: v4(108,34.05) 108,33.98 v2(107.05,33.03) ; v2(218.29,17.98) 220.36,20.05 222.57,20.05 224.05,18.56 239.86,18.56 240.94,17.48 252.79,17.48 254.58,19.27 271.36,19.27 271.82,18.81 271.82,16.68 v2(272.33,16.17)
  IN2 w0.061: v4(108,34.05) 109.35,34.05 114.5,28.9 115.17,28.9 119.65,24.43 122.84,24.43 123.28,23.98 125.68,23.98 126.04,24.34 131.21,24.34 131.9,25.03 139.41,25.03 141.87,22.57 144.39,22.57 148.66,18.31 154.45,18.31 154.71,18.04 177.1,18.04 189.17,30.12 198.19,30.12 198.55,29.76 211.99,29.76 v6(212.5,30.27)
  IN3 w0.061: v4(108,34.05) 108.02,34.03 v5(108.41,34.03)
CONTACTLESS_DET#_R: length 9.9
  TOP w0.127: v6(272.76,15.49) 272.26,14.99 DB9.1 273.15,14.43 v1(273.34,14.62)
  BOTTOM w0.127: v6(272.76,15.49) 271.03,15.49 269.79,16.73 268.54,16.73 267.06,18.22 JUSH1.23
CORE_VID0: length 37.1
  IN2 w0.061: v4(102.93,33.5) 102.93,33.51 103.14,33.72 105.37,33.72 106.34,32.76 108.52,32.76 109,32.28 v4(109,31.98)
  IN3 w0.061: v5(122.68,41.23) 123.03,41.23 123.17,41.09 v5(126.67,41.09) ; v5(109,31.59) v4(109,31.98) ; v4(102.93,33.5) 102.5,33.07 v5(102.48,33.07)
  BOTTOM w0.127: v5(126.67,41.09) 126.79,41.09 127.18,41.47 v1(128.45,41.47) 128.57,41.47 129.39,42.28 129.39,43.49 128.75,44.13 PR1428.2 ; v5(122.68,41.23) 122.58,41.13 122.16,41.13 120.9,39.87 117.26,39.87 116.51,39.12 116.51,35.75 115.67,34.91 112.72,34.91 109.43,31.62 109.03,31.62 v5(109,31.59)
CORE_VID1: length 37.1
  IN2 w0.061: v4(109.43,31.49) 109.43,32.04 108.59,32.88 106.39,32.88 105.43,33.85 102.86,33.85 v4(102.73,33.97)
  IN3 w0.061: v4(109.43,31.49) 109.46,31.46 109.51,31.46 v5(109.71,31.26) ; v5(102.48,33.72) v4(102.73,33.97) ; v5(122.86,40.92) 123.17,40.92 123.23,40.85 126.83,40.85 127.02,41.04 v5(127.55,41.04)
  BOTTOM w0.127: v5(127.55,41.04) 127.66,41.15 128.66,41.15 129.73,42.22 129.73,43.97 PR1429.2 ; v5(109.71,31.26) 109.71,31.41 109.77,31.47 109.77,31.6 112.83,34.65 115.77,34.65 116.76,35.64 116.76,38.17 118.2,39.61 121.16,39.61 v1(121.6,40.05) 122.42,40.87 122.82,40.87 v5(122.86,40.92)
CPU_C10_GATE#: length 82.6
  TOP w0.127: R273.1 108.81,67.79 111.9,64.7 v1(112.76,64.7) v6(113.77,63.69)
  IN1 w0.061: v4(102.27,37.36) 102.21,37.41 102.13,37.41 101.32,36.61 101.32,36.26 101.16,36.1 101.16,35.72 101.02,35.58 100.27,35.58 99.81,36.04 99.81,36.34 99.61,36.54 99.45,36.54 99.12,36.87 98.06,36.87 97.55,36.37 97.55,36.04 97.19,35.68 97.19,34.91 97.77,34.34 97.77,34.08 98.02,33.83 98.02,33.66 98.46,33.22 99.64,33.22 100.07,32.78 100.07,31.46 99.07,30.46 99.07,30.1 99.24,29.94 99.24,29.41 98.84,29.02 98.84,28.03 98.42,27.62 98.42,26.99 98.66,26.76 v4(99.9,26.76)
  IN2 w0.061: v6(113.77,63.69) 112.75,62.67 112.75,60.96 v6(113.32,60.38)
  IN3 w0.061: v4(99.9,26.76) 100.08,26.76 101.11,25.73 101.11,23.06 100.11,22.06 100.11,20.52 v5(100.18,20.45) ; v5(104.33,48.79) 104.61,49.07 104.94,49.07 105.08,48.93 105.08,48.01 105.33,47.76 105.33,47.29 105.66,46.96 107.96,46.96 108.27,46.65 108.93,46.65 109.18,46.91 109.49,46.91 109.79,46.6 109.79,43.78 110.37,43.2 110.37,39.21 110.15,38.98 108.75,38.98 v5(108.72,39.02)
  IN3 w0.089: v4(102.27,37.36) v5(102.63,37.36)
  BOTTOM w0.102: 103.47,38.4 103.47,38.47 103.67,38.68 106.79,38.68 106.87,38.75 107.89,38.75 107.96,38.68 108.16,38.68 108.51,39.02 v5(108.72,39.02)
  BOTTOM w0.127: PR1430.1 100.18,20.48 v5(100.18,20.45) ; v6(113.32,60.38) 113.69,60.02 113.69,58.39 113.41,58.11 112.8,58.11 110.35,55.65 110.35,54.21 110.08,53.94 109.54,53.94 109.38,53.79 108.8,53.79 108.67,53.66 108.67,53.28 107.91,52.52 107.53,52.52 107.25,52.24 107.25,51.91 107.05,51.71 105.62,51.71 105.47,51.56 105.47,49.98 105.24,49.75 104.99,49.75 104.81,49.57 104.81,49.27 v5(104.33,48.79) ; v5(102.63,37.36) 102.53,37.46 102.53,37.86 102.68,38.02 103.08,38.02 103.47,38.4
CPU_DP1_AUXN: length 65.6
  IN1 w0.074: v4(33.25,51.94) 33.36,51.83 34.06,51.83 37.14,54.92 37.14,59.19 38.33,60.38 39.51,60.38 42.06,62.93 42.06,63.53 42.45,63.91 43.22,63.91 44.85,63.57 45.17,63.28 45.4,62.58 45.81,62.25 46.48,62.05 46.75,61.84 46.86,61.58 46.97,61.47 47.55,61.35 50.27,60.69 52.59,60.69 54.57,60.17 54.92,60.17 56.31,59.62 56.94,59.44 57.1,59.38 57.39,59.31 58.45,58.94 58.46,58.93 59.74,58.4 59.77,58.39 59.78,58.39 61.36,58.02 61.52,58 63.62,58 64.01,57.61 67.16,57.61 67.55,58 77.68,58 77.98,57.7 79.27,57.7 80.82,56.15 80.82,54.42 80.24,53.84 80.16,53.84 78.92,52.6 78.92,51.97 78.71,51.76 78.52,51.76 v4(78.37,51.61)
  IN3 w0.074: v4(33.25,51.94) 33.25,51.94 33.15,51.85 v5(32.91,51.85) ; v5(78.14,51.38) v4(78.37,51.61)
  BOTTOM w0.112: CT26.2 32.25,51.69 32.76,51.69 v5(32.91,51.85)
CPU_DP1_AUXN_C: length 5.3
  IN3 w0.074: v5(31.49,51.86) 31.31,51.86 31.17,52 30.83,52 30.72,52.11 29.94,52.11 29.23,52.82 27.99,52.82 27.65,53.17 27.28,53.17 v5(26.83,52.92)
CPU_DP1_AUXP: length 65.5
  IN1 w0.074: v4(78.37,52.26) 78.37,52.08 78.49,51.96 78.63,51.96 78.72,52.06 78.72,52.69 80.07,54.04 80.15,54.04 80.62,54.5 80.62,56.07 79.19,57.5 77.9,57.5 77.6,57.8 67.63,57.8 67.24,57.41 63.93,57.41 63.54,57.8 61.51,57.8 61.32,57.82 59.74,58.19 59.71,58.2 59.66,58.22 58.37,58.75 57.34,59.12 57.04,59.18 56.87,59.25 56.25,59.43 56.24,59.44 54.89,59.97 54.55,59.97 52.56,60.49 50.24,60.49 47.51,61.16 46.87,61.29 46.69,61.46 46.59,61.71 46.39,61.86 45.72,62.06 45.23,62.46 45,63.17 44.75,63.38 43.2,63.71 42.53,63.71 42.26,63.44 42.26,62.85 39.6,60.18 38.42,60.18 37.34,59.11 37.34,54.84 34.14,51.63 33.68,51.63 33.6,51.55 33.6,51.26 33.53,51.18 33.34,51.18 33.25,51.27 v4(33.25,51.41)
  IN3 w0.074: v5(78.14,52.03) v4(78.37,52.26) ; v4(33.25,51.41) v5(32.91,51.41)
  BOTTOM w0.112: CT25.2 32.26,51.49 32.83,51.49 v5(32.91,51.41)
CPU_DP1_AUXP_C: length 5.3
  IN3 w0.074: v5(31.49,51.3) 31.49,51.45 31.1,51.84 30.76,51.84 30.65,51.95 29.87,51.95 29.17,52.66 27.92,52.66 27.82,52.77 27.71,52.77 27.6,52.65 27.38,52.65 27.3,52.73 27.3,52.85 27.37,52.92 v5(27.48,52.92)
CPU_DP1_CTRL_CLK: length 175.4
  TOP w0.127: v2(37.7,44.97) 37.61,44.97 37.32,45.26 37.32,48.56 37.16,48.72 37.16,55.85 36.03,56.98 34.99,56.98 34.37,57.59 v2(34.19,57.59) ; v2(116.65,14.63) 116.65,15.3 117.49,16.14 117.49,18.41 v1(116.81,19.1) 116.61,19.29 116.61,22.24 115.75,23.11 115.75,31.06 116.29,31.6 116.29,32.94 114.46,34.77 114.46,35.63 v2(114.54,35.71)
  IN1 w0.061: v2(103,50.65) v4(103.31,50.96) 103.45,50.96 103.67,50.74 103.67,50.02 103.82,49.87 105.47,49.87 105.89,50.3 106.42,50.3 106.46,50.25 107.62,50.25 108.63,49.23 108.63,48.7 109.8,47.53 109.8,47.32 110.69,46.44 110.69,45.23 111.36,44.56 111.36,42.85 111.87,42.34 111.87,38.91 114.45,36.33 114.45,35.79 v2(114.54,35.71) ; v2(116.65,14.63) 115.92,14.63 114.57,13.28 114.57,12.37 112.43,10.23 56.05,10.23 53.2,13.08 53.2,16.88 53.02,17.05 53.02,21.95 52.56,22.41 52.56,26.54 51.7,27.4 50.77,27.4 50.33,27.84 50.33,31.67 49.61,32.39 48.75,32.39 47.93,33.21 47.93,34.54 45.98,36.48 43.02,36.48 41.68,37.83 41.68,42.04 42.12,42.48 42.12,43.77 41.33,44.56 38.03,44.56 37.7,44.88 v2(37.7,44.97) ; v2(34.19,57.59) 33.34,56.74 v4(32.79,56.74)
  IN3 w0.061: v4(32.79,56.74) 32.79,56.84 v5(32.56,57.07)
  IN3 w0.076: v4(103.31,50.96) v5(103.08,50.73)
  BOTTOM w0.127: RT91.1 32.22,58.08 32.51,57.79 32.51,57.12 v5(32.56,57.07)
CPU_DP1_CTRL_DATA: length 190.4
  TOP w0.127: v2(116.58,14.24) 116.32,14.51 116.32,15.46 v1(116.63,15.76) 117.23,16.37 117.23,18.22 116.38,19.07 116.38,22.15 115.52,23.01 115.52,31.15 116.06,31.7 116.06,32.85 114.24,34.68 114.24,35.68 v2(114.18,35.73) ; v2(25.89,56.42) 25.89,55.33 27.67,53.55 27.67,49.09 28.91,47.85 28.91,45.77 28.21,45.06 28.21,44.19 27.72,43.71 27.72,42.45 27.42,42.15 v2(27.42,40.93)
  IN1 w0.061: v2(25.89,56.42) 25.68,56.64 25.68,57.61 25.22,58.06 v4(25.22,58.87) ; v2(116.58,14.24) 116.35,14.47 115.99,14.47 114.73,13.21 114.73,12.3 112.5,10.06 55.98,10.06 53.03,13.01 53.03,16.81 52.86,16.98 52.86,21.88 52.4,22.34 52.4,26.47 51.64,27.23 50.7,27.23 50.17,27.77 50.17,31.6 49.54,32.22 48.68,32.22 47.77,33.14 47.77,34.47 45.92,36.32 42.96,36.32 41.52,37.76 41.52,42.11 41.96,42.55 41.96,43.7 41.26,44.4 32.72,44.4 28.79,40.47 27.95,40.47 27.49,40.93 v2(27.42,40.93) ; v2(114.18,35.73) 114.29,35.84 114.29,36.26 111.71,38.84 111.71,42.27 111.19,42.78 111.19,44.49 110.52,45.16 110.52,46.37 109.64,47.25 109.64,47.46 108.47,48.63 108.47,49.16 107.55,50.08 106.4,50.08 106.35,50.13 105.96,50.13 105.53,49.71 103.75,49.71 103.51,49.95 103.51,50.17 103.37,50.31 v4(103.31,50.31) 103.11,50.11 102.98,50.11 v2(102.97,50.1)
  IN3 w0.076: v5(103.08,50.08) v4(103.31,50.31) ; v4(25.22,58.87) 25.22,58.88 24.55,59.56 24.55,60.02 v5(24.6,60.08)
CPU_DP1_HPD: length 119.5
  TOP w0.127: v2(108.6,52.39) RC4.1 ; v2(97.24,60.28) v1(96.79,60.28)
  IN1 w0.061: v4(87.35,61.07) 88.05,61.07 89,60.13 91.19,60.13 91.82,60.76 96.77,60.76 v2(97.24,60.28) 97.51,60.02 v4(97.51,59.91) ; v4(108.28,52.27) 108.47,52.27 v2(108.6,52.39)
  IN2 w0.061: v4(108.28,52.27) 107.54,52.27 106.83,52.98 106.83,53.57 110.84,57.58 110.84,59.12 110.21,59.75 106,59.75 105.82,59.93 105.13,59.93 102.9,59.93 102.66,59.69 102.36,59.69 102.07,59.99 97.58,59.99 v4(97.51,59.91)
  IN3 w0.061: v5(108.69,52.09) 108.51,52.27 v4(108.28,52.27) ; v5(27.75,56.86) 27.72,56.89 27.72,57.25 28.13,57.65 28.69,57.65 28.9,57.44 28.9,57.24 29.65,56.49 30.87,56.49 30.96,56.58 31.31,56.58 31.63,56.89 31.63,59.04 31.6,59.07 31.6,62.09 30.44,63.25 30.44,64.32 v5(30.78,64.66) ; v5(59.38,71.28) 59.73,71.62 62.17,71.62 63.58,73.03 69.1,73.03 74.42,67.71 74.61,67.71 76.6,67.71 78.65,65.67 80,65.67 84.27,61.39 87.03,61.39 v4(87.35,61.07)
  BOTTOM w0.127: v5(30.78,64.66) 30.78,64.84 31.3,65.36 36.55,65.36 37.05,64.86 59.2,64.86 59.75,65.41 59.75,70.62 59.38,70.99 v5(59.38,71.28) ; v5(108.69,52.09) 108.5,52.28 UCPU1.CN6
CPU_DP1_N0: length 68.7
  IN1 w0.074: v4(31.14,54.31) 31.31,54.48 31.54,54.48 31.72,54.66 32.58,54.66 32.71,54.54 33.57,54.54 34.82,55.78 34.93,55.78 35.43,56.28 35.43,59.89 37.4,61.86 37.4,63.33 38.41,64.34 39.26,64.34 40.72,65.8 42.58,65.8 46.46,65.01 46.59,64.96 49.21,63.93 50.48,63.83 51.1,63.81 51.35,63.75 51.47,63.71 52.5,63.34 52.8,63.21 52.89,63.14 53.34,62.76 53.37,62.72 53.64,62.5 53.64,62.5 54.04,62.17 54.2,62.11 55.5,61.85 55.5,61.85 56.4,61.52 57.41,61.2 58.4,60.86 59.57,60.41 60.07,60.2 60.95,59.94 61.89,59.75 64.31,59.75 64.73,59.33 66.37,59.33 66.76,59.72 76.74,59.72 77.28,60.27 79.16,60.27 82.6,56.82 82.6,54.73 83.18,54.15 83.18,53.41 83.07,53.3 82.85,53.3 82.64,53.09 82.64,52.77 82.74,52.67 82.91,52.67 82.99,52.75 v4(82.99,52.91)
  IN3 w0.074: v5(30.41,54.27) 30.45,54.31 v4(31.14,54.31) ; v5(82.76,52.68) v4(82.99,52.91)
CPU_DP1_N0_C: length 1.9
  BOTTOM w0.076: CT14.1 29.62,54.48 28.91,54.48 28.8,54.36 28.51,54.36 28.44,54.43 28.44,54.52 28.49,54.57 UT2.AC7
CPU_DP1_N1: length 65.1
  IN1 w0.074: v4(32.42,53.73) 32.63,53.73 32.7,53.8 32.7,53.98 32.77,54.05 33.77,54.05 34.96,55.25 35.18,55.25 35.91,55.97 35.91,59.69 37.89,61.68 38.94,61.68 40.59,63.33 40.59,64.03 41.87,65.31 42.58,65.31 46.34,64.52 47.05,64.22 48,63.86 49.07,63.42 51.07,63.32 51.7,63.11 52.35,62.85 52.64,62.73 52.89,62.52 52.91,62.49 53.69,61.79 54.4,61.52 55.39,61.37 56.25,61.06 56.6,60.95 56.96,60.83 57.79,60.52 59.53,59.91 60.36,59.57 61.99,59.24 64.13,59.24 64.53,58.85 66.62,58.85 67,59.24 78.2,59.24 78.47,58.96 79.78,58.96 82.1,56.64 82.1,53.8 82.01,53.71 82.01,53.48 81.94,53.41 81.56,53.41 81.48,53.33 81.48,53.13 81.57,53.04 81.94,53.04 v4(82.07,52.91)
  IN3 w0.074: v5(81.83,52.68) v4(82.07,52.91) ; v5(32.09,53.54) v4(32.42,53.73)
CPU_DP1_N1_C: length 3.5
  BOTTOM w0.076: 28.99,53.71 28.91,53.63 28.91,53.51 28.84,53.44 28.56,53.44 28.51,53.49 28.51,53.59 28.57,53.65 UT2.AC9
  BOTTOM w0.112: CT15.1 31.33,53.71 28.99,53.71
CPU_DP1_N2: length 67.2
  IN1 w0.074: v4(31.08,53.39) 31.17,53.49 31.98,53.49 32.1,53.36 32.67,53.36 32.98,53.67 33.79,53.67 35.03,54.92 35.27,54.92 36.19,55.83 36.19,59.58 37.99,61.38 39.06,61.38 41,63.32 41,64.01 42.02,65.03 42.52,65.03 46.16,64.28 48.99,63.13 49.47,63.11 51.24,62.81 52.73,62.27 52.79,62.2 53.63,61.48 54.28,61.24 55.21,61.11 58.97,59.81 59.87,59.39 61.81,58.96 64.02,58.96 64.41,58.57 66.73,58.57 67.12,58.96 78.07,58.96 78.36,58.68 79.66,58.68 81.8,56.54 81.8,53.96 81.3,53.47 81.3,52.91 80.88,52.49 80.88,52.25 80.56,51.93 v4(80.23,51.77)
  IN3 w0.074: v4(31.08,53.39) 31.04,53.35 v5(30.41,53.35) ; v5(79.98,52.03) v4(80.23,51.77)
CPU_DP1_N2_C: length 2
  BOTTOM w0.076: UT2.AC11 28.49,52.73 28.44,52.79 28.44,52.89 28.49,52.95 28.8,52.95 28.89,52.85 29.01,52.85 29.28,53.12 29.6,53.12 CT24.1
CPU_DP1_N3: length 65.3
  IN1 w0.074: v4(32.43,52.28) 32.43,52.19 32.52,52.1 32.7,52.1 32.78,52.18 32.78,52.51 33.23,52.96 34.79,52.96 36.87,55.04 36.87,59.3 38.24,60.67 39.41,60.67 41.76,63.02 41.76,63.63 42.31,64.19 43.25,64.19 45.48,63.72 47.37,62.66 50.98,62.11 52.46,61.59 52.97,61.1 53.5,60.76 54.14,60.57 54.85,60.47 54.94,60.46 56.83,59.76 57.7,59.53 58.86,59.1 59.85,58.66 61.75,58.28 63.74,58.28 64.13,57.89 67.03,57.89 67.42,58.28 77.8,58.28 78.09,57.99 79.38,57.99 81.1,56.27 81.1,54.24 80.72,53.86 80.72,53.36 80.42,53.06 80.07,53.06 79.65,52.64 79.65,52.3 79.52,52.16 79.37,52.16 79.29,52.24 v4(79.29,52.45)
  IN3 w0.074: v5(79.06,52.68) v4(79.29,52.45) ; v4(32.43,52.28) 32.31,52.28 v5(32.13,52.47)
CPU_DP1_N3_C: length 3.7
  BOTTOM w0.076: UT2.AC13 28.58,51.75 28.58,51.66 28.65,51.6 28.89,51.6 28.96,51.67 28.96,51.79 29.04,51.87 29.1,51.87 29.1,51.87 29.23,51.87 29.58,52.22 30.14,52.22
  BOTTOM w0.112: 30.14,52.22 30.76,52.22 31.14,52.6 31.32,52.6 CT18.1
CPU_DP1_P0: length 68.7
  IN1 w0.074: v4(31.14,54.83) 31.28,54.69 31.46,54.69 31.64,54.86 32.67,54.86 32.8,54.74 33.49,54.74 34.74,55.98 34.84,55.98 35.23,56.37 35.23,59.98 37.2,61.95 37.2,63.41 38.33,64.54 39.18,64.54 40.64,66 42.6,66 46.52,65.21 46.67,65.14 49.25,64.13 50.5,64.03 51.13,64.01 51.41,63.95 51.54,63.9 52.49,63.56 52.5,63.56 52.91,63.38 53.02,63.29 53.49,62.9 53.52,62.86 53.76,62.66 54.14,62.35 54.26,62.3 55.56,62.04 55.57,62.04 55.58,62.03 56.47,61.71 57.47,61.39 58.47,61.05 59.65,60.59 60.13,60.39 61,60.13 61.91,59.95 64.39,59.95 64.81,59.53 66.29,59.53 66.68,59.92 76.65,59.92 77.2,60.47 79.24,60.47 82.8,56.9 82.8,54.81 83.38,54.24 83.38,52.8 v4(82.99,52.26)
  IN3 w0.074: v5(30.41,54.83) v4(31.14,54.83) ; v5(82.76,52.03) v4(82.99,52.26)
CPU_DP1_P0_C: length 1.8
  BOTTOM w0.076: CT13.1 29.64,54.64 29.13,54.64 29,54.78 28.48,54.78 UT2.AB7
CPU_DP1_P1: length 65.1
  IN1 w0.074: v4(32.42,54.29) 32.45,54.25 33.69,54.25 34.88,55.45 35.1,55.45 35.71,56.05 35.71,59.78 37.81,61.88 38.85,61.88 40.39,63.41 40.39,64.11 41.79,65.51 42.61,65.51 46.4,64.71 47.12,64.41 48.07,64.05 49.11,63.62 51.11,63.52 51.77,63.3 52.43,63.04 52.74,62.9 53.03,62.66 53.05,62.63 53.8,61.97 54.46,61.71 55.44,61.56 56.31,61.25 57.02,61.02 57.86,60.71 59.6,60.1 60.42,59.76 62.01,59.44 64.22,59.44 64.61,59.05 66.53,59.05 66.92,59.44 78.28,59.44 78.56,59.16 79.86,59.16 82.3,56.73 82.3,53.71 82.21,53.63 82.21,53.29 82.34,53.16 82.41,53 82.41,52.81 v4(82.07,52.26)
  IN3 w0.074: v5(32.09,54.1) v4(32.42,54.29) ; v5(81.83,52.03) v4(82.07,52.26)
CPU_DP1_P1_C: length 3.5
  BOTTOM w0.076: UT2.AB9 28.48,53.86 28.8,53.86 28.85,53.91
  BOTTOM w0.112: CT23.1 31.31,53.91 28.85,53.91
CPU_DP1_P2: length 67.2
  IN1 w0.074: v4(80.22,52.4) 80.22,52.2 80.29,52.13 80.47,52.13 80.68,52.33 80.68,52.57 81.1,53 81.1,53.55 81.59,54.05 81.59,56.46 79.58,58.47 78.27,58.47 77.99,58.76 67.21,58.76 66.81,58.37 64.33,58.37 63.94,58.76 61.79,58.76 59.8,59.2 58.9,59.63 55.16,60.92 54.23,61.04 53.53,61.31 52.65,62.06 52.61,62.1 51.19,62.62 49.45,62.91 48.94,62.93 46.1,64.08 42.5,64.83 42.11,64.83 41.2,63.92 41.2,63.23 39.15,61.18 38.07,61.18 36.39,59.5 36.39,55.75 35.36,54.72 35.12,54.72 33.87,53.47 33.06,53.47 32.75,53.16 32.01,53.16 31.89,53.28 31.52,53.28 31.43,53.19 31.43,52.9 31.35,52.83 31.27,52.8 31.16,52.8 v4(31.08,52.88)
  IN3 w0.074: v4(31.08,52.88) 30.5,52.88 v5(30.41,52.79) ; v4(80.22,52.4) 79.98,52.64 v5(79.98,52.68)
CPU_DP1_P2_C: length 2
  BOTTOM w0.076: UT2.AB11 28.48,52.53 28.92,52.53 29.35,52.96 29.66,52.96 CT16.1
CPU_DP1_P3: length 65.3
  IN1 w0.074: v4(79.29,51.8) 79.46,51.96 79.6,51.96 79.85,52.21 79.85,52.56 80.15,52.86 80.5,52.86 80.92,53.27 80.92,53.78 81.3,54.16 81.3,56.35 79.47,58.19 78.17,58.19 77.88,58.48 67.34,58.48 66.95,58.09 64.21,58.09 63.82,58.48 61.77,58.48 59.91,58.85 58.94,59.28 57.76,59.72 56.89,59.95 54.97,60.66 54.96,60.66 54.87,60.67 54.18,60.77 53.59,60.94 53.1,61.25 52.56,61.76 51.03,62.31 47.44,62.85 45.55,63.91 43.27,64.39 42.23,64.39 41.56,63.72 41.56,63.11 39.32,60.87 38.15,60.87 36.67,59.39 36.67,55.12 34.71,53.16 33.15,53.16 32.79,52.8 v4(32.42,52.8)
  IN3 w0.074: v4(32.42,52.8) 32.38,52.8 v5(32.14,53.03) ; v5(79.06,52.03) v4(79.29,51.8)
CPU_DP1_P3_C: length 3.8
  BOTTOM w0.076: 30.09,52.43 30.05,52.39 29.52,52.39 29.16,52.04 28.53,52.04 UT2.AB13
  BOTTOM w0.112: CT17.1 31.32,52.8 31.05,52.8 30.68,52.43 30.09,52.43
CPU_DP2_AUXN: length 58.2
  IN1 w0.074: v4(33.16,50.29) 33.34,50.47 33.8,50.47 37.92,54.6 37.92,56.12 38.28,56.49 40.5,56.49 41.52,57.5 44.72,57.5 45.59,56.63 51.53,56.63 52.14,57.24 52.14,58.63 52.9,59.39 54.68,59.39 54.9,59.34 55.08,59.26 56.05,58.89 56.77,58.65 57.18,58.56 58.17,58.21 59.59,57.62 60.19,57.44 61.32,57.21 63.28,57.21 63.67,56.82 67.49,56.82 67.89,57.22 77.36,57.22 77.67,56.91 78.86,56.91 79.05,56.72 79.05,56.31 79.27,56.08 79.32,56.08 v4(79.55,55.84)
  IN3 w0.074: v5(79.22,55.86) 79.24,55.84 v4(79.55,55.84) ; v4(33.16,50.29) v5(32.83,50.29)
  BOTTOM w0.076: UCPU1.AD4 79.09,54.3 79.09,54.51 79.04,54.62 78.87,54.79 78.87,55.68 79.08,55.89 79.19,55.89 v5(79.22,55.86)
  BOTTOM w0.112: CT36.2 32.28,50.38 32.73,50.38 v5(32.83,50.29)
CPU_DP2_AUXN_C: length 5.5
  IN3 w0.074: v5(26.83,52.27) 27.43,52.02 28.6,52.02 29.97,50.65 30.47,50.65 30.72,50.4 31.04,50.4 31.16,50.28 31.4,50.28 v5(31.5,50.19)
CPU_DP2_AUXP: length 58.2
  IN1 w0.074: v4(79.57,56.39) 79.46,56.28 79.36,56.28 79.25,56.39 79.25,56.8 78.94,57.11 77.75,57.11 77.44,57.42 67.8,57.42 67.41,57.02 63.75,57.02 63.36,57.41 61.34,57.41 60.24,57.63 59.66,57.81 58.24,58.4 57.23,58.75 56.82,58.85 56.12,59.08 55.16,59.45 54.96,59.53 54.71,59.59 52.82,59.59 51.94,58.72 51.94,57.33 51.45,56.83 45.68,56.83 44.8,57.7 41.43,57.7 40.42,56.69 38.2,56.69 37.72,56.21 37.72,54.68 33.72,50.68 33.33,50.68 v4(33.16,50.85)
  IN3 w0.074: v4(33.16,50.85) v5(32.83,50.85) ; v4(79.57,56.39) 79.56,56.37 79.17,56.37 v5(79.15,56.35)
  BOTTOM w0.076: UCPU1.AD3 78.64,54.4 78.56,54.48 78.56,54.63 78.71,54.78 78.71,55.75 79.15,56.19 v5(79.15,56.35)
  BOTTOM w0.112: CT35.2 32.25,50.59 32.57,50.59 v5(32.83,50.85)
CPU_DP2_AUXP_C: length 5.4
  IN3 w0.074: v5(31.5,50.75) 31.5,50.55 31.4,50.45 31.22,50.45 31.1,50.57 30.79,50.57 30.54,50.81 30.04,50.81 28.67,52.18 27.85,52.18 27.78,52.26 27.78,52.43 27.71,52.5 27.52,52.5 27.46,52.44 27.46,52.3 v5(27.48,52.27)
CPU_DP2_CTRL_CLK: length 106.3
  IN1 w0.061: v4(104.89,61.77) 104.58,61.46 104.58,61.22 104.19,60.83 102.69,60.83 100.57,62.94 85.87,62.94 81.88,66.93 70.33,66.93 69.93,66.53 68.62,66.53 68.33,66.24 64.11,66.24 62.38,67.6 61.55,68.76 60.5,69.49 59.74,69.78 57.8,70.16 55.92,71 54.82,71.79 54.44,72.17 53.34,72.17 52.73,72.78 51.1,72.78 50.23,73.65 49.67,73.65 48.79,74.53 42.63,74.53 41.93,73.83 37.18,73.83 36.79,73.44 34.02,73.44 33.44,72.86 33.44,71.17 32.12,69.85 32.12,68.2 31.16,67.23 31.16,65.77 v4(30.97,65.58)
  IN3 w0.061: v4(104.89,61.77) 105.1,61.57 v5(105.29,61.57) ; v5(32.08,56.47) 32.32,56.71 32.32,57.64 31.9,58.06 31.9,62.19 30.73,63.36 30.73,63.82 31.47,64.56 31.47,65.08 v4(30.97,65.58)
  BOTTOM w0.127: v5(105.29,61.57) 105.21,61.49 105.21,59.91 105.02,59.71 105.02,58.87 105.54,58.35 105.54,57.83 RC5.2 105.93,56.41 105.6,56.08 105.6,54.82 105.4,54.62 105.4,54.18 105.68,53.9 UCPU1.CH4
