# Allegro board LAG441PR10-1221_GCR.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TP_EN: length 135.6
  TOP w0.102: UE1.L9 268.99,53.16 v2(268.99,52.82)
  TOP w0.127: v6(246.58,50.79) 246.26,50.79 v1(245.91,51.15)
  IN1 w0.061: v2(268.99,52.82) 269.03,52.78 269.03,52.22 268.42,51.61 268.11,51.61 267.48,50.98 265.66,50.98 265.41,51.23 264.09,51.23 263.98,51.34 263.36,51.34 263.25,51.23 262.82,51.23 261.49,49.9 255.24,49.9 254.27,50.87 249.29,50.87 249.01,51.14 246.93,51.14 v6(246.58,50.79)
  BOTTOM w0.127: v6(246.58,50.79) 245.79,50.01 245.79,39.06 246.91,37.94 246.91,35.77 247.9,34.79 247.9,34.6 249.7,32.79 249.7,30.33 250.27,29.76 250.27,28.42 251.36,27.33 251.36,16.24 249.71,14.59 249.71,10.84 249.31,10.45 222.02,10.45 220.39,11.44 185.11,11.44 R246.1
TP_EN_R: length 3
  BOTTOM w0.127: v1(183.31,12.76) R246.2 R28.1 185.01,12.76 U15.3
TP_I2C_DAT: length 5.1
  IN1 w0.061: v4(192.13,18.12) v2(191.54,18.12)
  IN3 w0.061: v5(192.34,18.6) 192.13,18.38 v4(192.13,18.12)
  BOTTOM w0.127: JTP1.3 192.12,18.38 v5(192.34,18.6) 192.63,18.89 DP4.1 192.63,19.7 RP6.1 RP4.2 RP14.2
TP_I2C_SCL: length 5.2
  IN1 w0.061: v4(192.67,18.12) v2(193.19,18.12)
  IN3 w0.061: v5(192.78,18.56) 192.67,18.45 v4(192.67,18.12)
  BOTTOM w0.127: JTP1.4 192.63,18.4 v5(192.78,18.56) 193.39,19.17 DP3.1 193.08,19.51 RP7.1 193.01,19.96 RP5.2 RP3.2
TPM_GPIO0: length 1.2
  TOP w0.254: UZ6.6 46.07,29.4 RZ37.2
TPM_GPIO0_NU: length 2.1
  TOP w0.127: RZ23.2 v1(41.57,33.85)
  TOP w0.254: RZ23.2 42.02,32.95 42.09,32.89 UZ6.29
TPM_PIRQ#: length 96.4
  TOP w0.127: UZ6.18 46.57,36.34 46.77,36.54 RZ19.2
  IN1 w0.061: v4(53.47,30.99) 53.11,31.35 53.11,34 50.43,36.67 50.09,36.67 49.64,37.12 49.64,37.87 49.18,38.33 47.01,38.33 46.82,38.14 v2(46.82,36.93)
  IN2 w0.061: v4(106.33,23.31) 106.65,22.99 106.65,22.52 106.44,22.31 105.46,22.31 104.88,21.72 103.15,21.72 101.1,19.67 95.44,19.67 94.84,20.27 94.84,21.57 93.85,22.56 93.85,25.7 94.07,25.91 94.07,27.65 93.58,28.14 75.04,28.14 73.9,27 68.13,27 66.79,28.34 65.65,28.34 65.34,28.04 60.08,28.04 59.82,28.29 57.09,28.29 56.27,29.11 55.4,29.11 54.05,30.46 54.05,30.68 53.74,30.99 v4(53.47,30.99)
  IN3 w0.061: v4(106.33,23.31) 106.51,23.49 106.51,25.39 105.03,26.87 105.03,27.87 104.97,27.93 104.97,28.25 105.19,28.47 105.42,28.47 105.7,28.75 105.7,28.9 105.8,29 105.8,29.32 105.14,29.98 105.14,31.2 104.33,32.01 104.33,34.88 103.96,35.25 103.79,35.32 103.47,35.64 103.47,36.4 v5(103.29,36.58)
  BOTTOM w0.127: v5(103.29,36.58) 103.18,36.69 103.18,37.25 102.87,37.69 UCPU1.CC29
TS_I2C_SCL: length 214.7
  TOP w0.127: v6(113.33,33.14) 113.66,32.81 113.66,32.48 114.15,31.99 114.15,25.85 v1(114.63,25.37) 114.73,25.27 114.73,22.89 115.81,21.81 115.81,18.8 116.58,18.03 116.58,16.68 v2(116.52,16.62)
  IN1 w0.061: v2(116.52,16.62) 116.53,16.61 116.53,16.34 v4(116.44,16.25) ; v4(40.51,76.09) 40.72,76.09 v2(40.82,75.98)
  IN2 w0.061: v4(40.51,76.09) 40.46,76.09 40.31,75.94 40.31,75.67 40.09,75.45 39.22,75.45 37.73,76.94 37.73,77.45 37.34,77.84 35.75,77.84 35.52,78.07 33.46,78.07 32.9,77.51 32.9,75.88 37.68,71.1 37.68,67.28 37.04,66.64 37.04,65.09 34.64,62.69 34.64,62.01 35.41,61.24 35.41,55.69 33.99,54.27 33.99,49.65 31.79,47.46 31.79,46.58 31.18,45.96 31.18,41.96 29.04,39.83 29.04,38.77 27.36,37.09 27.36,36.45 26.97,36.06 26.97,30.52 26.81,30.36 26.81,26.04 24.7,23.93 24.08,23.93 22.39,22.24 22.39,19.15 27.6,13.94 35.59,13.94 38.28,11.25 47.9,11.25 48.49,11.85 53.12,11.85 53.29,12.01 55.46,12.01 56.04,11.44 109.91,11.44 111.45,12.98 112.16,12.98 115.02,15.84 116.49,15.84 116.6,15.94 116.6,16.09 v4(116.44,16.25)
  IN3 w0.061: v6(113.33,33.14) 113.52,33.14 113.78,33.4 113.78,34.11 112.67,35.23 112.67,35.55 112.37,35.86 112.37,37.43 111.77,38.04 111.77,40.88 111.61,41.04 111.61,43.43 110.94,44.09 110.94,46.28 109.75,47.47 109.65,47.47 108.63,48.48 108.63,49.06 v5(108.68,49.11)
TS_I2C_SCL_R: length 5.3
  TOP w0.127: RV57.1 RV21.2
  IN1 w0.061: v2(40.84,76.56) 40.79,76.61 v4(40.36,76.61)
  IN3 w0.061: v5(39.57,75.82) 39.6,75.85 39.6,76.23 39.98,76.61 v4(40.36,76.61)
  BOTTOM w0.127: JEDP1.16 38.03,77.51 38.14,77.4 38.14,76.93 38.81,76.26 39.34,76.26 39.57,76.03 v5(39.57,75.82)
TS_I2C_SDA: length 215.6
  TOP w0.127: v6(113.32,33.72) 113.34,33.72 113.92,33.15 113.92,32.58 114.49,32.01 v1(114.49,30.63) 114.49,25.99 114.98,25.5 114.98,22.99 116.06,21.91 116.06,18.91 116.84,18.13 116.84,16.69 v2(116.92,16.61)
  IN1 w0.061: v2(116.92,16.61) 116.92,16.32 v4(116.97,16.26) ; v2(39.61,75.99) 39.71,76.09 v4(39.97,76.09)
  IN2 w0.061: v4(39.97,76.09) 40.12,75.94 40.12,75.75 40.01,75.64 39.3,75.64 37.92,77.02 37.92,77.53 37.42,78.03 35.83,78.03 35.6,78.26 33.39,78.26 32.72,77.59 32.72,75.8 37.5,71.02 37.5,67.36 36.86,66.72 36.86,65.17 34.46,62.77 34.46,61.93 35.22,61.17 35.22,55.77 33.8,54.35 33.8,49.73 31.61,47.54 31.61,46.65 30.99,46.04 30.99,42.04 28.86,39.91 28.86,38.84 27.18,37.17 27.18,36.53 26.79,36.14 26.79,30.6 26.62,30.44 26.62,26.12 24.62,24.12 24,24.12 22.2,22.32 22.2,19.08 27.52,13.75 35.51,13.75 38.2,11.06 47.97,11.06 48.57,11.66 53.2,11.66 53.37,11.83 55.38,11.83 55.96,11.25 109.99,11.25 111.53,12.79 112.24,12.79 115.1,15.65 116.57,15.65 116.78,15.86 116.78,16.07 v4(116.97,16.26)
  IN3 w0.061: v5(108.07,49.11) 108.14,49.11 108.45,48.8 108.45,48.4 109.57,47.28 109.68,47.28 110.75,46.21 110.75,44.02 111.42,43.35 111.42,40.96 111.58,40.8 111.58,37.96 112.18,37.35 112.18,35.78 112.48,35.48 112.48,35.15 113.6,34.04 113.6,33.84 113.44,33.69 113.36,33.69 v6(113.32,33.72)
TS_I2C_SDA_R: length 4.2
  TOP w0.127: RV58.1 v2(39.6,76.51)
  IN1 w0.061: v2(39.6,76.51) 39.42,76.51 v4(39.24,76.33)
  IN3 w0.061: v5(39.18,75.94) 39.18,76.27 v4(39.24,76.33)
  BOTTOM w0.127: v5(39.18,75.94) 38.68,75.94 37.73,76.89 37.73,77.35 37.63,77.45 JEDP1.15
TS_INT#: length 240.6
  TOP w0.127: v2(120.67,16.8) 120.67,16.87 120.95,17.15 120.95,18.19 123.43,20.67 123.43,23.5 v1(124.63,24.7) 124.63,24.82 126.29,26.47 v2(126.41,26.47) ; RV19.1 39.18,75.09 39.18,76.77 39.18,76.77 v2(39.18,76.9)
  IN1 w0.061: v2(39.18,76.9) 38.16,76.9 37.87,77.2 37.87,77.95 37.78,78.03 32.55,78.03 v4(32.26,77.74) ; v2(120.67,16.8) 120.67,16.38 v4(120.76,16.3) ; v4(127.18,27.36) 127.18,26.81 126.85,26.47 v2(126.41,26.47)
  IN2 w0.061: v4(32.26,77.74) 31.91,77.39 31.91,72.99 31.73,72.8 31.73,68.68 32.6,67.81 32.6,67.47 31.41,66.27 31.41,65.33 30.93,64.85 30.93,64.2 30.26,63.54 30.26,59.63 28.6,57.97 28.6,47.17 28.99,46.79 28.99,45.68 25.86,42.55 22.12,42.55 21.47,41.9 21.47,41.79 21.47,41.12 22.04,40.55 22.04,35.64 19.58,33.17 19.58,32.23 18.02,30.67 18.02,24.97 18.27,24.72 18.27,24.72 18.61,24.37 18.61,20.51 21.02,18.11 21.02,16.83 23.3,14.55 25.1,14.55 26.73,12.92 35.17,12.92 37.86,10.23 52.96,10.23 53.72,10.99 55.04,10.99 55.62,10.42 110.27,10.42 112.28,10.42 115.86,13.99 119.32,13.99 120.76,15.43 v4(120.76,16.3) ; v4(108.08,48.66) 108.58,48.15 110.23,48.15 110.54,48.46 112.28,48.46 113.67,47.07 114.39,47.07 118.68,42.78 119.59,42.78 120.46,41.91 121.45,41.91 126.79,36.57 126.79,34.29 127.14,33.93 127.14,27.4 v4(127.18,27.36)
  IN3 w0.061: v4(108.08,48.66) 107.87,48.66 v5(107.75,48.54)
  BOTTOM w0.076: v5(107.75,48.54) 108.02,48.81 109.28,48.81 109.38,48.81 109.58,48.89 109.68,48.89 110.17,49.38
  BOTTOM w0.127: RC463.2 111.64,50.86 110.17,49.38
TS_INT#_R: length 6.3
  TOP w0.127: RV19.2 39.5,74.34 v2(39.76,74.08) 39.76,74.07 39.57,73.88 39.5,73.88 RV60.2
  IN1 w0.061: v2(39.76,74.08) 39.44,74.08 v4(39.37,74.15)
  IN3 w0.061: v5(39.92,75.61) 39.92,74.69 v4(39.37,74.15)
  BOTTOM w0.127: JEDP1.17 38.43,77.04 38.91,76.55 39.46,76.55 39.92,76.09 v5(39.92,75.61)
TS_RST#: length 21
  TOP w0.127: v2(112.99,25.37) 112.99,28.7 111.87,29.82 RC626.1 ; v2(109.74,29.46) 110.1,29.1 RV15.2 111.28,28.01 v1(111.11,27.84) 110.16,27.84 v2(110.12,27.88) ; v2(104.15,32.17) 104.32,32.01 RC564.2
  IN1 w0.061: v2(110.12,27.88) 111.11,26.89 111.71,26.89 112.99,25.61 v2(112.99,25.37) ; v2(104.15,32.17) 104.56,32.17 105.62,31.12 106.36,31.12 106.8,30.67 106.8,30.12 107.47,29.46 v2(109.74,29.46)
TS_RST#_R: length 187.2
  TOP w0.127: v2(112.62,25.49) v1(112.62,27.07) 112.62,28.57 111.5,29.69 RV15.1
  IN1 w0.061: v4(124.31,20.84) 124.11,20.84 122.09,22.86 119.52,22.86 118.67,23.7 113.97,23.7 112.62,25.05 v2(112.62,25.49)
  IN2 w0.061: v4(124.31,20.84) 122.79,20.84 122.38,20.42 113.61,20.42 108.65,15.46 105.52,15.46 104.23,16.75 100.77,16.75 100.04,16.02 97.62,16.02 97.17,15.57 91.58,15.57 91.08,16.07 52.88,16.07 52.78,15.96 51.36,15.96 51.36,15.97 49.29,15.97 46.79,18.46 41.61,18.46 40.9,19.17 40.9,19.91 40.53,20.29 38.22,20.29 37.88,20.62 36.06,20.62 35.58,20.14 33.75,20.14 29.33,24.56 29.33,29.1 29.63,29.39 29.63,34.61 32.26,37.25 32.26,39.39 33.74,40.86 33.74,42.67 36.93,45.87 36.93,49.21 37.01,49.29 37.01,49.77 37.34,50.1 37.34,50.41 36.96,50.79 36.96,53.92 37.55,54.51 37.55,58.28 38.96,59.69 38.96,62.73 39.72,63.49 39.72,65.17 41.66,67.1 41.66,68.61 45.36,72.32 45.36,72.6 45.11,72.85 45.11,73.22 44.98,73.35 44.98,74.9 42.84,77.04 41.59,77.04 v4(41.27,76.73)
  IN3 w0.061: v5(40.85,76.59) 41.13,76.59 v4(41.27,76.73)
  BOTTOM w0.127: JEDP1.18 38.83,77.13 39.15,76.8 40.64,76.8 v5(40.85,76.59)
UART_MISO: length 20.5
  TOP w0.127: v2(30.18,68.27) 30.18,67.53 30.49,67.21 RT151.2
  IN1 w0.061: v2(30.18,68.27) 29.55,68.9 29.15,68.9 29.11,68.87 28.56,68.87 27.93,68.23 27.93,67.91 27.44,67.42 v4(27.4,67.42)
  IN2 w0.061: v4(27.4,67.42) 27.69,67.71 27.69,68.88 27.5,69.07 27.2,69.07 26.86,69.41 26.57,69.41 26.42,69.27 25.87,69.27 25.4,69.73 24.76,69.73 24.32,70.17 24.32,71.23 24.09,71.46 23.59,71.46 23.14,71.91 23.14,72.57 23.26,72.69 23.27,72.69 24.15,73.58 26.45,73.58 26.96,74.08 v4(26.96,74.92)
  IN3 w0.061: v4(26.96,74.92) 27.04,74.85 v5(27.29,74.85) ; v5(27.73,67.42) v4(27.4,67.42)
  BOTTOM w0.127: UT5.E2 27.4,74.93 27.32,74.85 v5(27.29,74.85)
UART_MOSI: length 21.7
  TOP w0.127: RT153.2 30.75,68.03 v2(30.56,68.21)
  IN1 w0.061: v2(30.56,68.21) v4(30.56,68.6)
  IN2 w0.061: v4(27.38,74.41) 27.57,74.22 27.57,73.51 27.37,73.31 26.86,73.31 26.72,73.45 24.21,73.45 23.32,72.56 23.32,72.56 23.27,72.51 23.27,71.96 23.64,71.58 24.14,71.58 24.45,71.28 24.45,70.22 24.81,69.86 25.49,69.86 25.93,69.42 26.36,69.42 26.5,69.56 26.95,69.56 27.28,69.23 27.74,69.23 28.75,70.24 29.5,70.24 30.56,69.19 v4(30.56,68.6)
  IN3 w0.061: v5(27.73,67.92) 27.97,67.67 28.59,67.67 28.67,67.58 29.75,67.58 30.56,68.39 v4(30.56,68.6) ; v5(27.73,74.43) 27.71,74.41 v4(27.38,74.41)
UEFI_MGMT#_R: length 13.2
  TOP w0.127: v2(297.79,68.17) R217.2 296.89,68.45 297.08,68.64 297.08,68.87 296.96,68.99 Q14.1
  IN1 w0.061: v4(297.38,68.48) 297.7,68.17 v2(297.79,68.17)
  IN3 w0.061: v5(306.31,67.32) 305.49,67.32 304.14,65.97 300.71,65.97 298.19,68.48 v4(297.38,68.48)
UI2_A_DE0: length 1.5
  TOP w0.127: UI2.16 287.1,49.78 RI40.1
UI2_A_DE1: length 2.6
  TOP w0.127: UI2.18 286.1,49.51 RI44.1 285.18,49.89 v1(284.83,49.55)
UI2_A_EQ0: length 1.6
  TOP w0.127: UI2.17 286.6,49.65 RI42.1
UI2_A_EQ1: length 1.5
  TOP w0.127: RI38.1 287.6,49.87 UI2.15
UI2_B_DE0: length 3.1
  TOP w0.127: RI74.1 287.1,42.84 v6(287.1,43.35) UI2.3
  BOTTOM w0.127: v6(287.1,43.35) v1(287.1,41.88)
UI2_B_DE1: length 1.7
  TOP w0.127: RI78.1 288.9,43.64 288.6,43.94 UI2.6
UI2_B_EQ0: length 4.7
  TOP w0.127: RI76.1 v6(286.36,43.39) 286.6,43.64 UI2.2
  BOTTOM w0.127: v6(286.36,43.39) 286.59,43.16 286.59,40.94 v1(286.3,40.65)
UI2_B_EQ1: length 4.5
  TOP w0.127: UI2.4 287.6,43.49 v6(287.74,43.35) 287.74,42.84 RI72.1
  BOTTOM w0.127: v1(287.97,40.67) 287.74,40.9 v6(287.74,43.35)
UI2_I2C_EN: length 2.7
  TOP w0.127: v1(283.73,43.91) RI30.2 284.67,44.98 284.84,45.14 UI2.24
UI2_PD#: length 3.4
  TOP w0.127: UI2.5 288.1,43.89 288.38,43.61 v6(288.38,43.36) 288.38,42.85 RI68.2
  BOTTOM w0.127: v6(288.38,43.36) 288.38,42.32 v1(288.81,41.89)
UI2_REXT: length 3.5
  TOP w0.127: RI29.2 290.51,43.71 v1(290.51,44.37) 290.51,44.44 289.81,45.14 UI2.7
UI2_TEST: length 1.5
  TOP w0.127: RI101.2 288.1,49.73 UI2.14
UI4_ILIM_SEL1: length 3.8
  TOP w0.127: v1(282.74,61.51) 284.36,61.51 284.62,61.26 RI53.2 284.63,61.05 UI4.4
UI5_ILIM_SEL1: length 2.4
  TOP w0.127: v1(17.33,16.31) 17.8,16.31 18.17,15.94 RI64.2 18.4,15.93 UI5.4
UIM_CLK: length 42.9
  IN3 w0.061: v5(294.21,31.16) 294.22,31.15 295.04,31.15 297.14,33.25 v5(299.33,33.25)
  BOTTOM w0.127: JNGFF1.32 265.4,30.49 266.95,28.94 274.9,28.94 276.05,27.79 277.54,27.79 278.57,28.81 278.57,29.42 280.66,31.51 282.87,31.51 283.73,32.38 283.73,34.08 283.96,34.31 v1(288.09,34.31) 288.29,34.31 290.03,32.57 290.03,31.94 290.92,31.04 CS1.1 CS6.1 291.67,31.15 DS1.1 DS1.9 294.2,31.15 v5(294.21,31.16)
UIM_DATA: length 56.2
  IN3 w0.061: v5(294.15,32.69) 294.19,32.65 294.66,32.65 298.11,36.1 309.63,36.1 v5(312.49,33.25)
  BOTTOM w0.127: JNGFF1.34 265.9,30.6 267.13,29.37 275.08,29.37 276.23,28.22 277.36,28.22 278.13,28.99 278.13,29.7 280.4,31.97 282.69,31.97 283.3,32.58 283.3,34.26 283.78,34.74 v1(286.26,34.74) 288.5,34.74 RS1.2 CS5.1 CS3.1 291.74,32.65 DS1.4 DS1.7 294.11,32.65 v5(294.15,32.69)
UIM_DET: length 2.7
  TOP w0.127: v2(273.77,30.93) 273.72,30.98 RN10.1
  IN1 w0.061: v4(274.03,30.35) 273.77,30.61 v2(273.77,30.93)
  IN3 w0.061: v5(274.28,30.6) v4(274.03,30.35)
  BOTTOM w0.127: JNGFF1.66 273.9,30.98 v5(274.28,30.6)
UIM_DET_R: length 31
  IN1 w0.061: v4(287.79,34.36) 287.47,34.04 278.71,34.04 276.6,31.93 v2(273.72,31.93)
  IN3 w0.061: v5(295.62,41.27) 295.62,34.14 294.63,33.15 294.16,33.15 v5(294.15,33.16) ; v4(287.79,34.36) 288.23,33.92 290.69,33.92 291.19,33.42 v5(291.6,33.42)
  BOTTOM w0.127: v5(291.6,33.42) 291.69,33.42 291.96,33.15 DS1.5 DS1.6 294.14,33.15 v5(294.15,33.16)
UIM_RESET: length 44.1
  TOP w0.127: v6(281.72,30.9) v1(281.72,31.48)
  IN3 w0.061: v5(291.6,31.64) 291.27,31.31 289.9,31.31 287.21,34 284.14,34 283.74,33.6 283.74,32.77 281.88,30.9 v6(281.72,30.9) ; v5(294.17,31.66) 294.18,31.65 294.86,31.65 299,35.79 v5(299.33,35.79)
  BOTTOM w0.127: v5(294.17,31.66) 294.15,31.65 DS1.8 DS1.2 292.71,31.64 v5(291.6,31.64) ; v6(281.72,30.9) 280.8,30.9 279.04,29.15 279.04,28.68 277.72,27.36 275.87,27.36 274.72,28.5 266.66,28.5 264.9,30.26 JNGFF1.30
UPD1_SMBCLK: length 317.2
  TOP w0.076: UE1.C3 263.79,60.05 263.31,60.05 263.26,60.1 262.39,60.1 262.32,60.17 262.19,60.17
  TOP w0.127: v2(32.83,65.8) 32.83,65.54 32.59,65.3 RT109.1 ; 262.19,60.17 261.69,60.17 261.32,60.53 RE105.1
  IN1 w0.061: v2(260.43,60.5) 260.13,60.5 v4(260.08,60.55) ; v2(32.83,65.8) 32.83,65.96 v4(33.03,66.16) 32.89,66.3 32.89,66.4 36.03,69.54 36.63,69.54 38.05,70.96 40.19,70.96 40.36,71.13 40.45,71.13 v4(40.62,70.96)
  IN3 w0.061: v4(40.62,70.96) 40.82,71.16 40.95,71.16 41.28,71.5 41.28,73.28 42.08,74.08 48.78,74.08 49.26,73.59 50.91,73.59 52,72.5 59.26,72.5 59.63,72.13 61.96,72.13 63.59,73.75 63.59,74.36 65.27,76.04 68.32,76.04 69.62,74.74 69.62,73.23 74.64,68.22 76.85,68.22 78.81,66.25 80.13,66.25 84.49,61.9 88.54,61.9 91.88,65.24 100.39,65.24 102.4,67.24 108.1,67.24 108.63,66.71 111.91,66.71 116.45,62.17 116.45,60.94 118.94,58.44 118.94,53.49 121.52,50.91 125.31,50.91 126.68,49.53 126.68,48.77 128.36,47.1 128.36,45.68 128.27,45.59 128.27,44.05 129.22,43.1 129.22,41.76 132.35,38.63 135.39,35.05 135.74,34.61 136.09,34.16 136.09,34.16 136.45,33.68 136.97,32.92 138.1,31.74 139.21,30.54 140.75,28.92 140.75,28.92 140.76,28.91 140.78,28.9 141.21,28.48 141.23,28.46 142.46,27.35 143.86,26.16 144.22,25.89 145.63,24.91 145.79,24.8 147.41,23.7 148.87,22.95 151.35,22.04 154.99,20.86 158.23,20.35 158.24,20.35 158.89,20.3 164.61,20.3 166.55,20.54 168.33,20.87 169.57,21.18 171.54,21.72 174.23,22.77 175.11,23.18 176.99,24.17 178.2,24.91 180.15,26.18 181.15,26.95 181.18,26.98 182.46,28.15 182.47,28.16 182.96,28.61 183.3,28.93 183.81,29.43 183.92,29.53 185.26,30.87 186.62,31.66 187.22,32.04 187.53,32.26 188.2,32.86 190.13,34.78 193.87,34.78 194.66,35.57 195.35,35.57 199.08,39.31 199.74,39.31 203.24,42.81 203.24,48.82 205.31,50.89 205.31,63.69 207.94,66.32 212.6,66.32 213.64,65.27 244.78,65.27 249.12,60.93 259.7,60.93 v4(260.08,60.55) ; v4(33.03,66.16) 32.89,66.3 32.89,66.54 31.93,67.51 31.93,68.98 31.82,69.09 31.82,69.27 v5(31.95,69.4)
  BOTTOM w0.076: UT1.B5 26.23,69.42 26.47,69.67 26.47,70.21 26.78,70.52 29.09,70.52 29.12,70.5 29.14,70.5
  BOTTOM w0.127: 29.14,70.5 29.44,70.5 30.92,69.02 31.63,69.02 31.95,69.33 v5(31.95,69.4)
UPD1_SMBDAT: length 321.8
  TOP w0.127: v2(32.45,65.8) 32.45,65.93 v1(32.17,66.21) 31.71,66.21 31.58,66.08 RT111.1 ; 265.04,60.41 265.02,60.42 265.02,60.7 264.67,61.05 264.67,61.66 264.95,61.94 264.95,63.43 RE104.1 264.72,63.3 264.72,63 v2(264.63,62.91)
  IN1 w0.061: v4(40.61,71.5) 40.43,71.32 40.28,71.32 40.11,71.15 37.97,71.15 36.55,69.73 35.95,69.73 32.7,66.48 32.7,66.35 v4(32.5,66.15) 32.45,66.1 v2(32.45,65.8) ; v2(264.63,62.91) 264.63,62.81 v4(264.36,62.54)
  IN3 w0.061: v4(32.5,66.15) 32.7,66.36 32.7,66.46 31.74,67.43 31.74,68.91 31.63,69.02 31.63,69.33 v5(31.56,69.4) ; v4(40.61,71.5) 40.76,71.35 40.87,71.35 41.1,71.58 41.1,73.36 42,74.26 48.85,74.26 49.34,73.78 50.99,73.78 52.08,72.69 59.33,72.69 59.71,72.32 61.88,72.32 63.4,73.83 63.4,74.44 65.19,76.23 68.4,76.23 69.81,74.82 69.81,73.31 74.72,68.41 76.93,68.41 78.89,66.44 80.21,66.44 84.57,62.08 88.46,62.08 91.8,65.42 100.32,65.42 102.32,67.43 108.18,67.43 108.71,66.9 111.99,66.9 116.63,62.25 116.63,61.01 119.13,58.52 119.13,53.56 121.6,51.09 125.39,51.09 126.87,49.61 126.87,48.85 128.55,47.17 128.55,45.6 128.46,45.51 128.46,44.13 129.41,43.17 129.41,41.84 132.49,38.76 135.53,35.17 136.24,34.28 136.24,34.28 136.61,33.79 137.12,33.04 138.24,31.87 139.35,30.67 140.89,29.05 141.36,28.6 142.59,27.49 143.98,26.3 144.33,26.04 145.73,25.07 145.9,24.96 147.5,23.86 148.95,23.13 151.41,22.21 155.03,21.04 158.25,20.54 158.9,20.49 164.6,20.49 166.52,20.73 168.29,21.06 169.52,21.36 171.48,21.9 174.16,22.94 175.03,23.35 176.9,24.34 178.1,25.07 180.04,26.33 181.02,27.09 181.05,27.12 182.33,28.28 182.34,28.3 182.83,28.75 183.17,29.07 183.68,29.56 183.79,29.67 185.15,31.02 186.52,31.83 187.12,32.2 187.41,32.41 188.07,32.99 190.05,34.97 193.79,34.97 194.58,35.76 195.27,35.76 199.01,39.5 199.66,39.5 203.05,42.89 203.05,48.89 205.12,50.97 205.12,63.77 207.86,66.5 212.67,66.5 213.72,65.46 244.86,65.46 249.2,61.12 262.99,61.12 264.36,62.49 v4(264.36,62.54)
  BOTTOM w0.076: 29.14,70.75 29.12,70.75 29.09,70.72 26.69,70.72 26.27,70.3 26.27,69.96 UT1.A5
  BOTTOM w0.127: v5(31.56,69.4) 31.43,69.27 31.02,69.27 29.54,70.75 29.14,70.75
UPD1_SMBINT#: length 382.6
  TOP w0.102: UE1.F10 v2(269.85,57.22)
  IN1 w0.061: v4(276.73,50.84) 277.05,50.84 280.28,54.07 280.28,58.7 279.68,59.3 276.02,59.3 275.73,59.01 v2(275.59,59.01) 275.59,59.08 275.38,59.3 271.55,59.3 271.18,58.93 271.18,58.57 270.9,58.29 270.4,58.29 269.99,57.88 269.99,57.51 269.85,57.37 v2(269.85,57.22)
  IN2 w0.061: v4(26.24,69.75) 26.73,69.75 27.07,70.1 27.07,70.4 27.34,70.67 28.1,70.67 28.23,70.8 31.18,70.8 31.54,70.43 31.54,68.09 30.9,67.46 30.9,66.26 30.1,65.46 30.1,64.88 30.29,64.69 30.29,64.37 29.69,63.77 29.69,59.87 27.9,58.07 27.9,47.15 27.22,46.48 18.11,46.48 16.75,45.11 16.75,44.81 17.28,44.28 17.28,42.15 17.9,41.53 18.14,41.53 19.51,40.16 19.51,37.88 19.07,37.45 19.07,32.35 17.57,30.85 17.57,24.79 17.82,24.54 17.82,24.53 18.17,24.18 18.17,20.33 20.57,17.93 20.57,16.65 25.44,11.78 26.87,11.78 27.02,11.78 27.85,12.61 35.03,12.61 37.74,9.9 38.08,9.9 38.09,9.91 53.11,9.91 53.87,10.68 54.91,10.68 55.49,10.1 119.47,10.1 121.08,11.7 121.08,13.63 124.36,16.91 126.79,16.91 128.82,16.08 130.47,14.43 130.47,12.95 130.84,12.58 131.36,12.58 132.24,11.69 151.69,11.69 151.94,11.44 184.51,11.44 185.8,12.74 186.65,12.74 201.51,12.74 203.55,14.78 216.37,14.78 235.89,34.3 239.75,34.3 241.16,35.71 256.87,35.71 259.31,38.14 267.14,38.14 270.95,41.95 270.95,43.8 276.73,49.58 v4(276.73,50.84)
  IN3 w0.061: v4(26.24,69.75) 26.06,69.75 v5(25.73,69.42)
UPD2_SMBCLK: length 331.8
  TOP w0.102: UE1.D7 v2(267.44,58.79)
  TOP w0.127: v2(71.08,68.9) 71.29,68.9 73,67.19 81.5,67.19 82.71,68.41 v1(82.85,68.41) 83.01,68.56 83.81,68.56 83.96,68.41 83.96,68.27 v2(83.9,68.21) ; v2(31.03,72.42) 31.11,72.35 31.11,71.61 30.83,71.33 RT126.1
  IN1 w0.061: v4(270.59,65.2) 270.59,65.42 v2(270.74,65.58) ; v2(83.9,68.21) 84.01,68.09 84.01,68.01 84.01,67.81 85.75,66.07 101.26,66.07 102.65,67.46 107.43,67.46 108.19,68.22 v4(108.47,68.22) ; v4(60.52,73.37) 60.83,73.06 60.83,72.78 61.04,72.57 69.15,72.57 69.52,72.2 69.52,70.01 70.55,68.98 71,68.98 v2(71.08,68.9) ; v4(267.08,58.82) 267.11,58.79 v2(267.44,58.79) ; v4(30.55,73.76) 30.52,73.73 30.52,72.93 v2(31.03,72.42)
  IN2 w0.061: v4(193.38,35.81) 193.03,36.16 193.01,36.16 193,36.17 192.7,36.17 192.32,35.79 189.72,35.79 188.4,34.48 188.4,34.19 177.1,22.89 171.89,22.89 170.46,21.45 156.49,21.45 156.16,21.79 149.99,21.79 145.81,25.97 144.95,25.97 137.3,33.62 137.3,34.51 133.36,38.45 133.36,41.32 133.56,41.53 v4(133.56,41.59)
  IN3 w0.061: v4(30.55,73.76) 30.49,73.82 v5(30.49,74.12) 30.35,74.25 30.35,74.43 30.11,74.67 29.3,74.67 29.09,74.87 27.92,74.87 27.37,75.43 27.37,75.84 v5(27.19,76.02) ; v5(60.77,73.13) 60.53,73.37 v4(60.52,73.37) ; v4(193.38,35.81) 193.18,36.01 193.18,36.1 193.59,36.51 194.9,36.51 198.68,40.3 199.31,40.3 201.61,42.6 201.61,44.29 202.12,44.8 202.12,63.8 203.72,65.4 204.95,65.4 206.93,67.38 213.28,67.38 214.02,66.64 246.52,66.64 249.18,63.98 257.57,63.98 260.43,66.83 264.73,66.83 266.33,65.23 267.86,65.23 268.09,65 268.89,65 269.32,65.44 270.35,65.44 v4(270.59,65.2) 270.44,65.06 270.44,64.98 267.41,61.95 267.41,59.15 v4(267.08,58.82) ; v4(133.56,41.59) 133.53,41.62 133.26,41.62 132.67,42.22 132.67,44.93 132.01,45.59 132.01,46.43 130.42,48.01 129.53,48.01 128.23,49.31 128.23,52.06 126.66,53.64 123.49,53.64 123.17,53.31 121.25,53.31 120.83,53.73 120.83,56.74 120.41,57.16 120.41,58.81 118.01,61.21 118.01,62.6 112.88,67.73 109.59,67.73 108.94,68.39 108.63,68.39 v4(108.47,68.22)
  BOTTOM w0.127: v5(30.49,74.12) 30.39,74.02 30.39,73.69 30.54,73.54 52.54,73.54 53.3,72.78 60.73,72.78 60.84,72.89 60.84,73.05 v5(60.77,73.13) ; UT5.B5 26.64,76.02 v5(27.19,76.02)
UPD2_SMBDAT: length 333.7
  TOP w0.102: v2(267.45,58.03) 267.45,58.02 UE1.E7
  TOP w0.127: v2(84.28,68.21) 84.22,68.27 84.22,68.52 83.92,68.82 82.76,68.82 81.39,67.45 73.11,67.45 71.27,69.29 v2(71.08,69.29) ; v2(30.58,72.43) 30.58,72 RT128.1
  IN1 w0.061: v4(61.45,73.36) 61.26,73.36 61.02,73.12 61.02,72.86 61.11,72.76 69.23,72.76 69.71,72.28 69.71,70.08 70.63,69.17 70.96,69.17 v2(71.08,69.29) ; v2(271.3,65.58) 271.16,65.44 v4(271.16,65.21) ; v2(267.45,58.03) 267.44,58.03 v4(267.21,58.26) ; v4(108.46,68.76) 107.35,67.65 102.58,67.65 101.19,66.26 85.83,66.26 84.2,67.89 84.2,68.13 v2(84.28,68.21) ; v4(30.01,73.71) 30.2,73.52 30.2,72.81 v2(30.58,72.43)
  IN2 w0.061: v4(192.85,35.81) 192.65,35.6 189.8,35.6 188.59,34.4 188.59,34.11 177.18,22.7 171.97,22.7 170.53,21.26 156.42,21.26 156.08,21.6 149.91,21.6 145.73,25.78 144.88,25.78 137.11,33.55 137.11,34.43 133.17,38.37 133.17,41.76 133.39,41.98 v4(133.39,42.15)
  IN3 w0.061: v5(26.23,76.93) 26.23,76.51 26.92,75.81 26.98,75.81 27.18,75.61 27.18,75.35 27.85,74.68 29.02,74.68 29.22,74.48 30.04,74.48 30.16,74.35 30.16,74.23 30.05,74.12 v5(30.05,74.11) 30.06,74.1 30.06,73.75 v4(30.01,73.71) ; v4(267.21,58.26) 267.21,58.32 267.6,58.72 267.6,61.87 270.52,64.79 270.74,64.79 v4(271.16,65.21) 270.75,65.62 269.25,65.62 268.81,65.19 268.17,65.19 267.94,65.42 266.41,65.42 264.8,67.02 260.35,67.02 257.5,64.17 249.26,64.17 246.6,66.83 214.1,66.83 213.36,67.57 206.85,67.57 204.87,65.59 203.64,65.59 201.93,63.88 201.93,44.87 201.42,44.37 201.42,42.68 199.23,40.48 198.61,40.48 194.82,36.7 193.51,36.7 192.99,36.18 192.99,35.95 v4(192.85,35.81) ; v5(61.16,73.13) 61.16,73.13 61.42,73.36 v4(61.45,73.36) ; v4(108.46,68.76) 108.65,68.57 109.02,68.57 109.67,67.92 112.96,67.92 118.2,62.68 118.2,61.28 120.59,58.89 120.59,57.24 121.02,56.81 121.02,53.81 121.33,53.5 123.09,53.5 123.42,53.83 126.74,53.83 128.42,52.14 128.42,49.38 129.6,48.2 130.5,48.2 132.19,46.5 132.19,45.67 132.85,45.01 132.85,42.3 133,42.15 v4(133.39,42.15)
  BOTTOM w0.127: v5(61.16,73.13) 61.15,73.13 61.09,73.07 61.09,72.79 60.83,72.52 53.2,72.52 52.43,73.28 30.44,73.28 30.14,73.59 30.14,74.02 v5(30.05,74.11)
UPD2_SMBINT#: length 364.2
  TOP w0.102: UE1.F5 265.84,57.19 v2(265.83,57.19)
  TOP w0.127: v2(272.96,48.19) v1(274.1,48.19)
  IN1 w0.061: v2(265.83,57.19) 265.76,57.27 v4(265.76,57.52) ; v4(25.77,76.78) 26.13,76.78 26.51,76.4 26.55,76.4 26.7,76.25 27.32,76.25 27.92,75.64 28.4,75.64 28.4,75.63 28.41,75.63 29.02,75.02 29.91,75.02 30.24,75.35 v4(34.1,75.35) ; v4(272.96,48.66) v2(272.96,48.19)
  IN2 w0.061: v4(265.76,57.52) 265.83,57.52 266.77,56.58 267.66,56.58 268.44,55.81 270.27,55.81 272.96,53.12 v4(272.96,48.66) 272.96,47.74 268.77,43.55 267.52,43.55 266.43,42.46 265.31,42.46 264.62,41.78 263.77,41.78 262.53,40.53 257.34,40.53 255.55,38.74 238.19,38.74 217.5,18.04 212.46,18.04 212.14,17.73 202.84,17.73 201.24,16.12 182.97,16.12 179.43,12.58 152.42,12.58 152.16,12.83 133.57,12.83 132.77,13.63 132.77,15.83 131.4,17.2 128.42,17.2 126.67,17.92 123.73,17.92 123.27,17.46 114.24,17.46 109.68,12.89 103.66,12.89 103.35,13.2 101.41,13.2 101.21,13 97.47,13 97.01,12.54 57.76,12.54 56.71,13.59 53.84,13.59 53.72,13.46 53.1,13.46 52.61,12.97 48.42,12.97 48.16,13.23 44.34,13.23 44.18,13.07 42.35,13.07 39.86,15.56 27.48,15.56 23.7,19.34 23.7,22.57 24.26,23.13 24.62,23.13 25.04,23.13 27.49,25.58 27.49,29.9 27.78,30.19 27.78,35.72 28.17,36.12 28.17,36.75 29.85,38.43 29.85,39.67 31.86,41.68 31.86,43.8 31.95,43.89 31.95,45.59 32.65,46.29 33.54,46.29 33.99,46.74 33.99,48.7 34.54,49.24 34.54,54.04 35.96,55.46 35.96,62.87 36.24,63.14 36.24,63.54 37.6,64.9 37.6,66.41 38.24,67.05 38.24,71.9 36.14,74 35.99,74 34.99,75 34.45,75 v4(34.1,75.35)
  IN3 w0.061: v5(25.73,76.43) 25.77,76.48 v4(25.77,76.78)
USB2_ID: length 0.7
  IN1 w0.061: v4(104.24,50.96) 104.22,50.95 v2(104,50.73)
  IN3 w0.076: v5(104,50.73) v4(104.24,50.96)
USB3_MRX_DTX_N4: length 2.4
  TOP w0.112: UN1.8 252.06,27.05 252.21,26.9 v7(252.75,26.9) 253.23,26.9 253.3,26.98 253.59,26.98 RN15.1
USB3_MRX_DTX_P4: length 2.4
  TOP w0.112: UN1.7 252.07,26.55 252.22,26.7 252.44,26.7 252.47,26.67 253.04,26.67 253.07,26.7 253.31,26.7 253.39,26.78 253.59,26.78 RN16.1
USB3_MRX_L_DTX_N4: length 14
  TOP w0.112: RN15.2 254.64,26.95 255.85,26.95 255.96,27.06 255.96,27.29 255.76,27.48 v6(255.72,27.48)
  BOTTOM w0.112: v6(255.72,27.48) 255.76,27.48 255.96,27.29 255.96,26.96 256.19,26.73 257.02,26.73 257.92,25.83 261.02,25.83 261.26,25.58 264.65,25.58 264.95,25.29 264.95,25.03 264.85,24.93 264.73,24.93 264.65,24.85 JNGFF1.29
USB3_MRX_L_DTX_P4: length 14
  TOP w0.112: v6(256.32,27.49) 256.16,27.33 256.16,26.97 255.93,26.74 254.57,26.74 RN16.2
  BOTTOM w0.112: v6(256.32,27.49) 256.16,27.32 256.16,27.05 256.27,26.94 257.1,26.94 258.01,26.03 261.1,26.03 261.34,25.79 264.74,25.79 265.15,25.37 JNGFF1.31
USB3_MTX_DRX_N4: length 2.4
  TOP w0.112: RN12.1 253.61,24.9 v7(252.75,24.9) 252.19,24.9 252.04,25.05 UN1.4
USB3_MTX_DRX_P4: length 2.4
  TOP w0.112: RN14.1 253.58,24.7 253.09,24.7 253.06,24.67 252.45,24.67 252.42,24.7 252.2,24.7 252.05,24.55 UN1.3
USB3_MTX_L_DRX_N4: length 17.1
  TOP w0.112: RN12.2 254.65,24.84 255.41,24.84 255.44,24.87 256.04,24.87 256.07,24.84 256.42,24.84 257.76,26.18 257.76,27.25 v6(257.52,27.49)
  BOTTOM w0.112: v6(257.52,27.49) 257.76,27.25 257.76,26.98 258.21,26.53 260.49,26.53 260.82,26.86 262.95,26.86 263.63,26.18 265.5,26.18 266.45,25.23 266.45,25.08 266.34,24.97 266.25,24.97 266.15,24.87 JNGFF1.35
USB3_MTX_L_DRX_P4: length 17.1
  TOP w0.112: v6(258.12,27.49) 257.96,27.33 257.96,26.1 256.5,24.64 v7(255.75,24.64) 254.56,24.64 RN14.2
  BOTTOM w0.112: JNGFF1.37 266.65,25.31 265.58,26.38 263.71,26.38 263.03,27.06 260.73,27.06 260.41,26.74 258.29,26.74 257.97,27.06 257.97,27.33 257.96,27.33 v6(258.12,27.49)
USB3_PRX_C_RD_DTX_N3: length 1.7
  TOP w0.112: CI12.1 283.9,45.78 284.6,45.78 284.73,45.64 UI2.23
USB3_PRX_C_RD_DTX_P3: length 1.7
  TOP w0.112: UI2.22 284.74,46.14 284.58,45.98 283.93,45.98 CI11.1
USB3_PRX_DTX_N2: length 168.4
  IN1 w0.074: v4(101.47,50.96) 101.47,50.85 101.37,50.76 101.08,50.76 100.53,50.21 99.57,50.21 98.31,51.47 98.31,52.99 98.6,53.28 98.6,56.83 98.25,57.18 97.59,57.18 97.32,57.45 97.32,58.83 98.09,59.6 98.09,60.37 97.13,61.33 91.54,61.33 91.01,60.8 89.17,60.8 88.25,61.73 85.69,61.73 81.48,65.93 71.25,65.93 70.45,65.13 68.72,65.13 68.62,65.23 63.81,65.23 63.14,65.56 62.55,66.01 62.37,66.19 61.66,66.79 60.09,67.32 59.8,67.46 59.41,67.79 58.45,68.03 58.11,68.22 57.76,68.34 56.81,68.69 56.81,68.69 54.46,69.9 51.86,71.42 50.36,71.42 48.39,73.39 46.82,73.39 46.15,72.72 45.71,72.72 44.76,71.77 42.97,71.77 42.1,72.64 40.14,72.64 39.74,72.25 37.55,72.25 36,70.7 35.39,70.7 33.4,68.71 33.27,68.71 v4(33.14,68.84)
  IN3 w0.074: v5(101.23,50.73) v4(101.47,50.96) ; v5(16.47,5.92) 16.62,6.07 16.81,6.07 17.01,6.27 17.01,7.29 16.38,7.92 16.38,13.98 15.78,14.58 15.78,19.91 14.64,21.05 14.64,36.3 14.91,36.57 14.91,38.04 16.01,39.15 16.01,40.2 16.7,40.89 19.24,40.89 19.52,41.17 20.77,41.17 21.15,40.79 22.95,40.79 23.96,41.8 25.65,41.8 28.24,44.38 28.65,44.38 30.03,45.76 31.29,45.76 32.54,47.02 32.54,47.32 35.11,49.89 35.11,53.01 35.54,53.44 35.54,54.44 35.34,54.64 35.34,56.9 35.03,57.22 35.03,60.91 33.98,61.96 33.98,65.32 34.3,65.64 34.3,67.49 34.06,67.72 34.06,68.64 33.86,68.84 v4(33.14,68.84)
USB3_PRX_DTX_N3: length 230.5
  IN1 w0.074: v4(101.47,51.61) 101.47,51.71 101.34,51.84 101.14,51.84 101.06,51.76 101.06,51.36 100.78,51.08 100.09,51.08 99.76,51.4 99.76,55.55 100.13,55.92 102.18,55.92 102.88,56.62 103.54,56.62 103.89,56.98 104.57,56.98 104.72,57.13 106.55,57.13 106.78,57.36 111.52,57.36 114.14,54.74 114.14,53.2 114.83,52.51 114.83,51.81 117.21,49.43 117.21,46.03 118.03,45.21 118.03,43.96 118.58,43.41 119.72,43.41 119.78,43.36 120.36,42.78 121.91,42.78 121.99,42.78 126.24,38.53 126.6,38.53 134.13,31.1 136.18,28.78 137.66,27.25 138.24,26.59 138.25,26.58 138.63,26.2 139.57,25.37 139.93,25.07 139.93,25.07 141.65,23.76 143.77,22.32 145.86,20.98 146.35,20.75 147.7,20.05 147.74,20.03 148.14,19.84 148.38,19.73 148.39,19.72 148.61,19.62 149.52,19.27 150.46,18.92 150.82,18.81 151.19,18.71 152.67,18.27 155.15,17.63 157.48,17.08 158.01,16.96 175.77,16.96 180.98,22.16 190,22.16 190.55,22.71 195.67,22.71 201.96,29.01 203.71,29.01 210.37,35.67 210.37,36.24 213.4,39.26 216.98,39.26 218.34,40.63 226.43,40.63 227.06,40 228.6,40 229.17,40.57 241.03,40.57 242.74,38.87 248.27,38.87 250.04,37.1 267.98,37.1 268.34,37.46 281.11,37.46 282.2,38.54 282.2,43.54 283.56,44.9 283.56,45.7 283.48,45.77 283.31,45.77 v2(283.15,45.61)
  IN3 w0.074: v5(101.23,51.38) v4(101.47,51.61)
USB3_PRX_DTX_N4: length 195.3
  TOP w0.112: UN1.16 248.57,25.55 248.42,25.4 242.66,25.4 v7(237.46,30.6) 236.55,31.51 236.55,32.23 236.58,32.26 236.58,32.9 236.55,32.93 236.55,35.59 238.68,37.72 238.68,39.09 v2(238.79,39.21)
  IN1 w0.074: v4(100.54,52.26) 100.54,52.39 100.64,52.49 100.95,52.49 101.14,52.67 101.14,54.42 101.43,54.71 103.24,54.71 103.55,55.01 103.86,55.01 104.6,55.75 107.46,55.75 107.54,55.83 110.86,55.83 112.63,54.06 112.63,51.88 115.67,48.83 115.67,45.31 116.52,44.46 116.52,43.33 118.61,41.24 121.38,41.24 126.6,36.03 126.6,35.35 127.43,34.51 127.86,34.51 128.1,34.27 128.56,34.27 129.14,33.78 130.4,32.59 131.4,31.61 131.4,31.61 132.39,30.62 134.54,28.08 135.12,27.46 137.92,24.75 138.79,24.02 140.72,22.53 141.92,21.69 142.11,21.57 143.23,20.78 143.24,20.76 143.43,20.63 143.46,20.62 144.56,19.93 146.34,19 146.83,18.76 146.84,18.74 147.07,18.64 147.07,18.64 148.19,18.15 148.33,18.1 148.36,18.09 149.15,17.78 149.24,17.74 149.25,17.74 149.33,17.71 149.35,17.7 149.36,17.7 149.86,17.5 151.08,17.12 151.83,16.91 151.83,16.91 152.53,16.72 152.59,16.71 152.6,16.7 152.9,16.63 152.9,16.63 154.79,16.14 154.81,16.14 154.95,16.1 155.11,16.06 156.08,15.83 157.3,15.53 157.68,15.44 176.39,15.44 181.38,20.43 195.52,20.43 202.57,27.48 204.32,27.48 213.38,36.53 214.19,36.53 215.04,37.38 217.35,37.38 219.08,39.11 225.74,39.11 226.51,38.35 238.34,38.35 238.7,38.7 238.7,39.11 v2(238.79,39.21)
  IN3 w0.074: v5(100.31,52.03) v4(100.54,52.26)
USB3_PRX_DTX_P2: length 168.5
  IN1 w0.074: v4(101.47,50.37) 101.47,50.47 101.38,50.55 101.16,50.55 100.62,50.01 99.49,50.01 98.11,51.38 98.11,53.08 98.4,53.37 98.4,56.74 98.16,56.98 97.5,56.98 97.12,57.36 97.12,58.91 97.89,59.69 97.89,60.29 97.05,61.13 91.62,61.13 91.09,60.6 89.09,60.6 88.16,61.52 85.6,61.52 81.39,65.73 71.33,65.73 70.53,64.93 68.64,64.93 68.54,65.03 63.77,65.03 63.03,65.39 62.42,65.86 62.23,66.04 61.56,66.61 60.02,67.13 59.69,67.29 59.32,67.61 58.37,67.84 58.03,68.04 57.86,68.09 57.69,68.15 56.73,68.5 56.72,68.51 54.36,69.73 51.81,71.22 50.27,71.22 48.3,73.19 46.9,73.19 46.24,72.52 45.79,72.52 44.84,71.57 42.89,71.57 42.02,72.44 40.22,72.44 39.83,72.05 37.63,72.05 36.08,70.5 35.47,70.5 33.48,68.51 33.34,68.51 v4(33.16,68.32)
  IN3 w0.074: v5(101.23,50.08) 101.47,50.31 v4(101.47,50.37) ; v4(33.16,68.32) 33.2,68.32 33.39,68.13 33.49,68.13 33.57,68.21 33.57,68.57 33.64,68.64 33.77,68.64 33.86,68.55 33.86,67.64 34.1,67.4 34.1,65.73 33.78,65.41 33.78,61.88 34.83,60.83 34.83,57.13 35.14,56.82 35.14,54.56 35.34,54.36 35.34,53.52 34.91,53.09 34.91,49.97 32.34,47.41 32.34,47.1 31.2,45.97 29.95,45.97 28.56,44.58 28.15,44.58 25.57,42 23.88,42 22.87,40.99 21.24,40.99 20.85,41.37 19.44,41.37 19.16,41.09 16.62,41.09 15.81,40.28 15.81,39.23 14.71,38.13 14.71,36.65 14.44,36.38 14.44,20.96 15.58,19.82 15.58,14.5 16.18,13.89 16.18,7.83 16.81,7.21 16.81,6.35 16.73,6.27 16.57,6.27 16.47,6.37 v5(16.47,6.56)
USB3_PRX_DTX_P3: length 231
  IN1 w0.074: 139.8,24.91 139.57,25.11 139.43,25.22 ; 139.8,24.91 141.53,23.6 143.66,22.15 145.76,20.8 146.26,20.57 147.61,19.87 147.61,19.87 148.3,19.54 148.31,19.54 148.53,19.44 149.45,19.08 150.39,18.73 150.76,18.62 151.13,18.51 152.61,18.08 155.11,17.44 157.99,16.76 175.85,16.76 181.06,21.96 190.09,21.96 190.64,22.51 195.75,22.51 202.04,28.8 203.79,28.8 210.58,35.59 210.58,36.16 213.48,39.06 217.06,39.06 218.42,40.42 226.35,40.42 226.98,39.8 228.68,39.8 229.25,40.37 240.95,40.37 242.65,38.66 248.19,38.66 249.96,36.9 268.06,36.9 268.42,37.25 281.19,37.25 282.4,38.46 282.4,43.45 283.76,44.82 283.76,45.78 283.57,45.98 283.35,45.98 v2(283.15,46.18) ; 139.8,24.91 139.43,25.22 ; 139.43,25.22 138.5,26.05 138.49,26.05 138.11,26.43 138.09,26.45 138.09,26.46 137.51,27.12 136.03,28.64 133.99,30.96 126.52,38.33 126.15,38.33 121.91,42.58 120.27,42.58 119.64,43.21 118.5,43.21 117.83,43.88 117.83,45.12 117.01,45.94 117.01,49.35 114.63,51.73 114.63,52.42 113.94,53.12 113.94,54.66 111.44,57.16 106.86,57.16 106.63,56.93 104.8,56.93 104.66,56.78 103.98,56.78 103.62,56.42 102.96,56.42 102.27,55.72 100.22,55.72 99.96,55.47 99.96,51.48 100.17,51.28 100.69,51.28 100.86,51.45 100.86,51.85 101.05,52.04 101.35,52.04 101.47,52.16 v4(101.47,52.26)
  IN3 w0.074: v5(101.23,52.03) v4(101.47,52.26)
USB3_PRX_DTX_P4: length 195.3
  TOP w0.112: v2(238.38,39.21) 238.47,39.12 238.47,37.8 236.35,35.68 v7(236.35,32.59) 236.35,31.43 237.08,30.69 237.08,30.62 237.49,30.22 237.55,30.22 242.58,25.2 248.4,25.2 248.55,25.05 UN1.17
  IN1 w0.074: v2(238.38,39.21) 238.49,39.1 238.49,38.79 238.26,38.55 226.59,38.55 225.83,39.31 219,39.31 217.27,37.59 214.95,37.59 214.1,36.73 213.29,36.73 204.24,27.68 202.49,27.68 195.44,20.63 181.3,20.63 176.3,15.64 157.7,15.64 157.28,15.74 156.13,16.03 156.13,16.03 155.16,16.26 154.86,16.33 154.84,16.34 152.95,16.82 152.59,16.91 151.88,17.1 151.14,17.31 149.93,17.69 149.44,17.88 149.41,17.89 149.41,17.89 149.39,17.9 149.33,17.93 149.26,17.95 149.22,17.97 148.44,18.27 148.32,18.32 148.16,18.38 148.16,18.39 147.15,18.82 147.15,18.83 146.99,18.9 146.99,18.91 146.43,19.18 144.66,20.11 144.05,20.49 143.56,20.79 143.53,20.81 143.41,20.89 143.41,20.9 142.66,21.43 142.16,21.78 142.15,21.78 142.03,21.86 140.84,22.69 138.92,24.18 138.06,24.9 135.27,27.6 134.69,28.21 132.54,30.76 130.54,32.74 129.27,33.93 128.63,34.47 128.18,34.47 127.94,34.71 127.51,34.71 126.8,35.43 126.8,36.11 121.46,41.44 118.7,41.44 116.72,43.42 116.72,44.55 115.87,45.4 115.87,48.92 112.83,51.96 112.83,54.15 110.95,56.03 107.45,56.03 107.37,55.95 104.51,55.95 103.78,55.21 103.47,55.21 103.16,54.91 101.34,54.91 100.94,54.5 100.94,52.76 100.87,52.69 100.63,52.69 100.54,52.78 v4(100.54,52.91)
  IN3 w0.074: v5(100.31,52.68) v4(100.54,52.91)
USB3_PRX_L_DTX_N2: length 4.7
  BOTTOM w0.112: JUSB2.5 12.51,6.53 12.62,6.64 13.2,6.64 13.7,6.14 14.82,6.14 DI15.1 15.25,6.14 15.67,6.14 RI62.2
USB3_PRX_L_DTX_N3: length 7.5
  TOP w0.112: v2(300.05,55.44) 300.03,55.44 299.94,55.35 299.67,55.35 299.52,55.5 DI9.9 DI9.1 297.9,55.5 297.79,55.39 297.38,55.39 RI50.2
  IN1 w0.074: JUSB1.5 303.26,54.78 303.18,54.71 301.69,54.71 301.06,55.34 300.16,55.34 v2(300.05,55.44)
USB3_PRX_L_DTX_P2: length 4.7
  BOTTOM w0.112: JUSB2.6 12.51,6.95 12.62,6.84 13.29,6.84 13.78,6.34 14.82,6.34 DI17.1 15.25,6.34 15.67,6.34 RI61.2
USB3_PRX_L_DTX_P3: length 7.5
  TOP w0.112: v2(300.05,55.06) 300.03,55.06 299.94,55.15 299.64,55.15 299.49,55 DI9.8 DI9.2 297.9,55 297.71,55.19 297.31,55.19 RI51.2
  IN1 w0.074: JUSB1.6 303.26,54.44 303.18,54.51 301.6,54.51 300.98,55.14 300.13,55.14 v2(300.05,55.06)
USB3_PRX_RD_DTX_N3: length 15.1
  TOP w0.112: v2(294.11,52.67) 294.02,52.75 293.78,52.75 292.23,51.2 292.23,47.59 291.12,46.48 291.12,46.44 290.69,46.01 290.65,46.01 290.28,45.64 UI2.8
  IN1 w0.074: v2(294.11,52.67) 294.01,52.76 293.67,52.76 293.47,52.96 293.47,53.61 295.36,55.5 296.4,55.5 v2(296.54,55.64)
USB3_PRX_RD_DTX_P3: length 15
  TOP w0.112: UI2.9 289.81,46.14 289.92,46.03 289.92,45.92 290,45.84 290.19,45.84 v7(290.74,46.39) 292.02,47.67 292.02,51.28 293.7,52.96 293.95,52.96 294.1,53.12 v2(294.1,53.19)
  IN1 w0.074: v2(296.54,55.01) 296.54,55.2 296.44,55.3 295.45,55.3 293.67,53.53 293.67,53.05 293.76,52.96 294.03,52.96 294.1,53.04 v2(294.1,53.19)
USB3_PTX_C_DRX_N2: length 1.2
  BOTTOM w0.112: RI60.1 16.74,12.1 17.33,12.1 CI27.2
USB3_PTX_C_DRX_N3: length 1.1
  TOP w0.112: CI36.2 295.74,53.56 296.41,53.56 RI48.1
USB3_PTX_C_DRX_N4: length 2.4
  TOP w0.112: UN1.18 248.53,24.55 248.37,24.39 v7(247.68,24.39) 246.9,24.39 CN15.2
USB3_PTX_C_DRX_P2: length 1.2
  BOTTOM w0.112: CI26.2 17.38,12.31 16.76,12.31 RI59.1
USB3_PTX_C_DRX_P3: length 1.2
  TOP w0.112: CI35.2 295.71,53.76 296.25,53.76 RI49.1
USB3_PTX_C_DRX_P4: length 2.4
  TOP w0.112: CN14.2 246.88,24.18 247.36,24.18 247.39,24.15 247.97,24.15 248,24.18 248.36,24.18 248.5,24.05 UN1.19
USB3_PTX_C_RD_DRX_N3: length 1.7
  TOP w0.112: CI10.2 283.93,47.27 284.6,47.27 284.74,47.14 UI2.20
USB3_PTX_C_RD_DRX_P3: length 1.7
  TOP w0.112: CI9.2 283.9,47.48 284.57,47.48 284.74,47.64 UI2.19
USB3_PTX_DRX_N2: length 156.3
  IN1 w0.074: v4(99.96,58.81) 99.84,58.93 99.84,59.09 99.92,59.17 100.13,59.17 100.2,59.25 100.2,61.09 99.68,61.61 91.35,61.61 90.84,61.1 89.32,61.1 88.34,62.08 85.72,62.08 81.59,66.21 71.13,66.21 70.33,65.41 68.85,65.41 68.74,65.53 63.87,65.53 61.63,67.28 61.32,67.83 61.13,68.11 61.08,68.17 60.97,68.29 60.07,68.88 59.59,69.06 58.47,68.99 58.35,69.03 57.98,69.24 56.83,69.67 55.53,70.35 54.63,70.92 54.15,71.4 52.9,71.4 52.24,72.06 50.79,72.06 49.92,72.93 49.38,72.93 48.49,73.82 43.06,73.82 42.18,72.93 40.04,72.93 39.63,72.53 37.4,72.53 35.86,70.98 35.27,70.98 33.92,69.63 33.59,69.63 v4(33.44,69.48)
  IN3 w0.074: v4(33.44,69.48) 33.58,69.62 34.09,69.62 34.34,69.37 34.34,67.85 34.57,67.62 34.57,65.5 34.25,65.19 34.25,62.07 35.3,61.02 35.3,57.33 35.62,57.02 35.62,54.76 35.82,54.56 35.82,53.32 35.39,52.9 35.39,49.77 32.83,47.21 32.83,46.89 31.41,45.47 30.13,45.47 28.73,44.07 28.32,44.07 25.73,41.48 24.06,41.48 22.98,40.4 20.46,40.4 19.32,39.26 19.32,38.71 18.36,37.75 17.47,37.75 16.93,37.21 16,37.21 14.91,36.12 14.91,21.16 16.09,19.98 16.09,14.74 17.18,13.65 17.18,12.31 17.42,12.08 17.94,12.08 v5(18.12,11.89) ; v4(99.96,58.81) 99.96,58.76 v5(100.32,58.4)
  BOTTOM w0.076: UCPU1.CA2 101.1,55.24 101.1,56.19 101.36,56.45 101.36,57.29 100.98,57.67 100.85,57.67 100.43,58.1 100.43,58.27 100.32,58.39 v5(100.32,58.4)
USB3_PTX_DRX_N3: length 230.9
  TOP w0.112: v2(282.31,47.13) 282.43,47.25 282.97,47.25 CI10.1
  IN1 w0.074: v2(282.31,47.13) 282.47,47.29 282.6,47.29 282.71,47.18 282.71,46.89 282.64,46.82 282.64,44.87 281.71,43.94 281.71,38.74 280.91,37.94 268.12,37.94 267.86,37.68 250.42,37.68 248.43,39.68 243.02,39.68 241.46,41.24 228.92,41.24 228.33,40.66 227.5,40.66 226.38,41.78 219.31,41.78 218.84,41.31 218.09,41.31 216.7,39.92 213.1,39.92 209.7,36.53 209.7,35.93 203.44,29.66 201.94,29.66 195.66,23.39 190.3,23.39 189.73,22.82 180.96,22.82 175.57,17.44 158.08,17.44 155.15,18.13 154.12,18.39 153.98,18.43 152.67,18.77 152.65,18.78 150.48,19.47 149.12,19.99 148.78,20.14 148.78,20.14 148.45,20.27 148.44,20.29 148.11,20.43 145.86,21.59 143.23,23.34 143.22,23.35 142.53,23.8 141.75,24.37 140.44,25.39 139.77,25.96 139.03,26.67 138.04,27.57 137.79,27.84 137.79,27.85 137.74,27.91 137.51,28.11 136.69,29 136.64,29.06 134.54,31.45 133.99,32.01 133.98,32.02 126.87,39.01 126.55,39.01 122.16,43.41 120.85,43.41 119.61,44.65 119.61,47.43 118.07,48.96 118.07,50.08 117.41,50.74 117.41,51.6 116.93,52.08 116.93,53.11 116.38,53.65 116.38,56.69 114.84,58.23 110.45,58.23 110.05,57.84 106.52,57.84 106.31,57.62 104.37,57.62 104.16,57.41 103.44,57.41 103.15,57.12 102.69,57.12 101.99,56.42 101.88,56.42 101.81,56.48 101.81,56.83 101.73,56.92 101.61,56.92 101.52,56.83 101.52,56.51 101.41,56.41 101.03,56.41 100.93,56.51 100.93,56.73 101,56.8 101.1,56.8 v4(101.14,56.77)
  IN3 w0.074: v4(101.14,56.77) 101.02,56.89 v5(101.02,57.11)
  BOTTOM w0.076: UCPU1.BY4 101.06,54.01 101.06,54.6 100.92,54.74 100.92,54.79
  BOTTOM w0.112: 100.92,54.79 100.92,57.01 v5(101.02,57.11)
USB3_PTX_DRX_N4: length 190.6
  TOP w0.112: CN15.1 245.93,24.39 244.75,24.39 244.72,24.42 244.15,24.42 244.12,24.39 242.56,24.39 235.75,31.21 v7(235.75,34.93) 235.75,35.81 237.3,37.36 237.3,39.76 v2(237.42,39.87)
  IN1 w0.074: v4(100.58,54.78) 100.75,54.95 101.05,54.95 101.31,55.2 102.67,55.2 103.24,55.77 103.87,55.77 104.34,56.24 107,56.24 107.24,56.49 111.14,56.49 113.29,54.34 113.29,52.15 116.36,49.08 116.36,45.62 117.18,44.8 117.18,43.61 118.88,41.9 121.65,41.9 126.08,37.47 126.13,37.47 129.18,34.6 129.57,34.27 130.86,33.07 131.72,32.21 132.68,31.3 137.05,26.55 138.26,25.34 139.17,24.56 140.83,23.29 143.27,21.55 145.36,20.25 146.64,19.58 147.34,19.24 148.44,18.76 149.32,18.42 149.93,18.2 149.94,18.19 150.18,18.11 150.31,18.07 150.54,18 150.57,17.99 150.6,17.98 151.99,17.56 152,17.56 152.44,17.44 152.91,17.32 153.18,17.24 155.27,16.71 157.84,16.1 157.93,16.1 157.98,16.09 176.11,16.09 181.11,21.09 195.25,21.09 202.3,28.14 204.05,28.14 213.96,38.04 217.07,38.04 218.8,39.77 226.02,39.77 226.78,39.01 236.94,39.01 237.3,39.36 237.3,39.77 237.4,39.87 v2(237.42,39.87)
  IN3 w0.074: v4(100.58,54.78) 100.53,54.73 v5(100.24,54.73)
USB3_PTX_DRX_P2: length 156.3
  IN1 w0.074: v4(100.47,58.82) 100.4,58.89 100.4,61.17 99.77,61.81 91.27,61.81 90.75,61.3 89.41,61.3 88.42,62.28 85.81,62.28 81.68,66.41 71.04,66.41 70.25,65.61 68.93,65.61 68.82,65.73 63.94,65.73 61.79,67.41 61.49,67.94 61.19,68.36 61.18,68.36 61.1,68.45 60.17,69.06 59.62,69.26 58.5,69.19 58.44,69.21 58.06,69.43 56.92,69.85 55.63,70.52 54.76,71.08 54.23,71.6 52.98,71.6 52.33,72.26 50.87,72.26 50,73.13 49.47,73.13 48.58,74.02 42.98,74.02 42.09,73.13 39.95,73.13 39.55,72.73 37.32,72.73 35.77,71.18 35.19,71.18 33.84,69.83 33.59,69.83 v4(33.44,69.98)
  IN3 w0.074: v5(100.7,58.4) 100.7,58.48 100.47,58.71 v4(100.47,58.82) ; v4(33.44,69.98) 33.6,69.82 34.17,69.82 34.54,69.45 34.54,67.93 34.77,67.7 34.77,65.42 34.46,65.1 34.46,62.16 35.5,61.11 35.5,57.42 35.82,57.1 35.82,54.84 36.02,54.64 36.02,53.24 35.59,52.81 35.59,49.69 33.03,47.12 33.03,46.81 31.49,45.27 30.22,45.27 28.81,43.86 28.4,43.86 25.82,41.28 24.14,41.28 23.06,40.2 20.54,40.2 19.52,39.18 19.52,38.62 18.45,37.55 17.56,37.55 17.01,37 16.08,37 15.11,36.04 15.11,21.24 16.29,20.07 16.29,14.83 17.39,13.73 17.39,12.39 17.5,12.28 17.94,12.28 v5(18.12,12.46)
  BOTTOM w0.076: v5(100.7,58.4) 100.7,58.39 100.59,58.28 100.59,58.17 100.92,57.84 101.05,57.84 101.53,57.36 101.53,56.38 101.27,56.12 101.27,55.76 101.34,55.68 101.51,55.68 101.62,55.57 101.62,55.26 101.54,55.19 101.44,55.19 101.36,55.26 UCPU1.CA1
USB3_PTX_DRX_P3: length 235
  TOP w0.112: v2(282.31,47.56) 282.42,47.45 282.95,47.45 CI9.1
  IN1 w0.074: 142.41,23.64 143.1,23.19 143.11,23.18 145.76,21.42 ; 142.41,23.64 145.76,21.42 ; 142.41,23.64 141.63,24.21 140.31,25.23 139.63,25.81 138.89,26.52 137.89,27.43 137.65,27.71 137.65,27.71 137.5,27.85 137.5,27.85 137.37,27.96 136.48,28.92 136.48,28.93 134.39,31.31 133.84,31.87 133.82,31.89 133.82,31.89 126.79,38.81 126.47,38.81 122.07,43.2 120.77,43.2 119.41,44.56 119.41,47.34 117.87,48.88 117.87,50 117.21,50.66 117.21,51.52 116.73,52 116.73,53.02 116.18,53.57 116.18,56.61 114.76,58.03 110.53,58.03 110.14,57.64 106.61,57.64 106.39,57.42 104.46,57.42 104.24,57.21 103.52,57.21 103.23,56.92 102.77,56.92 102.06,56.21 100.94,56.21 100.73,56.42 100.73,56.62 100.59,56.75 v4(100.55,56.75) ; 145.76,21.42 148.02,20.25 148.29,20.13 148.3,20.11 148.69,19.96 148.81,19.91 149.04,19.81 150.41,19.28 152.59,18.59 152.61,18.58 153.93,18.24 154.07,18.2 155.1,17.93 158.06,17.23 175.65,17.23 181.04,22.62 189.81,22.62 190.38,23.19 195.75,23.19 202.02,29.46 203.52,29.46 209.9,35.84 209.9,36.44 213.18,39.72 216.79,39.72 218.17,41.11 218.92,41.11 219.39,41.58 226.29,41.58 227.41,40.46 228.41,40.46 229,41.04 241.37,41.04 242.94,39.48 248.34,39.48 250.34,37.48 267.95,37.48 268.21,37.74 280.99,37.74 281.91,38.66 281.91,43.86 282.84,44.78 282.84,46.74 282.91,46.81 282.91,47.27 282.69,47.49 282.38,47.49 v2(282.31,47.56)
  IN3 w0.074: v4(100.55,56.75) 100.66,56.85 v5(100.66,57.1)
  BOTTOM w0.076: UCPU1.BY3 100.8,54.2 100.72,54.12 100.61,54.12 100.51,54.22 100.51,54.54 100.71,54.74 100.71,54.79
  BOTTOM w0.112: v5(100.66,57.1) 100.71,57.05 100.71,54.79
USB3_PTX_DRX_P4: length 190.6
  TOP w0.112: CN14.1 245.95,24.19 v7(244.44,24.19) 242.48,24.19 235.55,31.12 235.55,34.6 235.5,34.64 235.5,35.32 235.55,35.36 235.55,35.89 237.1,37.45 237.1,39.75 v2(236.98,39.87)
  IN1 w0.074: v4(100.6,55.31) 100.76,55.15 100.97,55.15 101.23,55.4 102.59,55.4 103.16,55.97 103.78,55.97 104.25,56.44 106.92,56.44 107.16,56.69 111.23,56.69 113.49,54.43 113.49,52.23 116.56,49.16 116.56,45.71 117.38,44.89 117.38,43.69 118.97,42.1 121.74,42.1 126.16,37.67 126.21,37.67 129.31,34.75 129.71,34.42 131,33.21 131.86,32.36 132.83,31.45 137.19,26.69 138.4,25.49 139.3,24.72 140.95,23.45 143.39,21.72 145.46,20.43 146.73,19.76 147.43,19.42 148.52,18.95 149.39,18.61 150.07,18.36 150.08,18.36 150.25,18.3 150.37,18.26 150.6,18.19 150.63,18.18 150.65,18.17 152.05,17.75 152.27,17.69 152.49,17.63 152.96,17.51 153.24,17.43 155.32,16.9 157.87,16.3 157.95,16.3 158,16.29 176.03,16.29 181.03,21.29 195.17,21.29 202.22,28.34 203.97,28.34 213.88,38.25 216.99,38.25 218.72,39.97 226.1,39.97 226.86,39.21 236.86,39.21 237.1,39.45 237.1,39.76 v2(236.98,39.87)
  IN3 w0.074: v4(100.6,55.31) 100.53,55.38 v5(100.24,55.38)
USB3_PTX_L_DRX_N2: length 4.7
  BOTTOM w0.112: RI60.2 15.73,12.11 15.25,12.11 DI16.1 14.82,12.11 13.78,12.11 13.27,12.62 12.69,12.62 12.51,12.45 JUSB2.8
USB3_PTX_L_DRX_N3: length 11.7
  TOP w0.112: RI48.2 297.36,53.65 297.97,53.65 298.12,53.5 DI9.5 DI9.6 299.49,53.5 299.64,53.65 299.95,53.65 300.03,53.56 v2(300.06,53.56)
  IN1 w0.074: JUSB1.8 303.26,48.54 303.12,48.41 302.88,48.41 299.58,51.72 299.58,53.53 299.7,53.65 299.97,53.65 v2(300.06,53.56)
USB3_PTX_L_DRX_P2: length 4.7
  BOTTOM w0.112: RI59.2 15.73,12.31 15.25,12.31 DI18.1 14.82,12.31 13.87,12.31 13.35,12.83 12.69,12.83 12.51,13.01 JUSB2.9
USB3_PTX_L_DRX_P3: length 11.8
  TOP w0.112: v2(300.06,53.94) 300.03,53.94 299.95,53.85 299.64,53.85 299.5,54 DI9.7 DI9.4 298.09,54 297.94,53.85 297.33,53.85 RI49.2
  IN1 w0.074: JUSB1.9 303.26,48.08 303.13,48.21 302.8,48.21 299.38,51.63 299.38,53.61 299.61,53.85 299.97,53.85 v2(300.06,53.94)
USB3_PTX_RD_DRX_N3: length 10.4
  TOP w0.112: CI36.1 294.75,53.56 294.53,53.56 294.31,53.79 293.66,53.79 291.24,51.37 v7(291.24,50.51) 291.24,49.17 291.27,49.14 291.27,48.56 291.24,48.53 291.24,48.13 290.4,47.29 290.12,47.29 289.97,47.14 UI2.11
USB3_PTX_RD_DRX_P3: length 10.4
  TOP w0.112: CI35.1 294.79,53.77 294.62,53.77 294.39,53.99 293.58,53.99 291.04,51.45 291.04,50.83 291.01,50.8 291.01,50.23 291.04,50.19 v7(291.04,48.85) 291.04,48.21 290.32,47.49 290.13,47.49 289.97,47.64 UI2.12
USB20_N1: length 102.9
  IN1 w0.074: v4(28.43,63.86) 28.57,63.72 28.91,63.72 29.29,64.1 29.29,64.69 30.31,65.72 30.31,66.47 30.58,66.74 30.58,67.47 31.55,68.44 31.55,71.76 31.84,72.05 31.84,73.15 33.19,74.49 36.35,74.49 37.06,75.21 40.15,75.21 40.29,75.06 41.68,75.06 42.2,75.58 49.25,75.58 50.04,74.79 50.6,74.79 51.53,73.86 53.35,73.86 53.9,73.31 54.91,73.31 55.76,72.46 56.33,72.03 56.73,71.83 58.44,71.12 59.62,70.97 62.06,70.27 62.27,70.13 63.88,68.53 63.88,68.39 64.98,67.29 67.88,67.29 68.18,67.58 69.45,67.58 69.86,67.99 82.31,67.99 85.76,64.54 86.22,64.54 86.77,63.99 101.41,63.99 103.1,62.31 103.29,62.31 v4(103.32,62.34)
  IN3 w0.074: v5(103.68,62.21) 103.44,62.21 v4(103.32,62.34) ; v5(26.23,65.42) 26.53,64.92 26.62,64.83 26.62,64.5 27.34,63.78 28.35,63.78 v4(28.43,63.86)
  BOTTOM w0.076: v5(103.68,62.21) 103.68,62.17 103.99,61.86 103.99,61.38 103.84,61.24 v7(103.84,60.18) 103.84,58.89 104.88,57.85 104.88,56.24 104.27,55.63 104.27,55.35 104.19,55.13 104.21,54.93 104.26,54.84 104.26,54.61 104.08,54.34 104.08,53.9 104,53.82 103.88,53.82 103.8,53.89 UCPU1.CE3
USB20_N2: length 100.9
  IN1 w0.074: v4(104.29,62.67) 104.11,62.85 104.11,63.01 102.65,64.47 86.97,64.47 86.42,65.02 85.96,65.02 82.5,68.47 69.65,68.47 69.25,68.07 67.98,68.07 67.69,67.77 65.18,67.77 64.36,68.59 64.36,68.73 62.57,70.52 62.13,70.82 61.31,71.02 59.8,71.72 59.73,71.76 59.4,72.05 58.47,72.74 58.07,72.87 56.05,72.87 55.08,73.84 54.12,73.84 53.6,74.36 51.73,74.36 51.04,75.05 51.04,76.49 50.41,77.12 47.15,77.12 46.09,76.06 42,76.06 41.5,75.56 40.51,75.56 40.38,75.69 36.73,75.69 36.01,74.97 32.9,74.97 31.35,73.42 31.35,72.28 29.95,70.88 29.08,70.88 28.84,71.12 27.06,71.12 26.97,71.22 26.97,71.32 v4(27.11,71.47)
  IN3 w0.074: v5(27.02,71.14) 27.02,71.37 v4(27.11,71.47) ; v5(104.35,63.02) 104.33,63.01 104.33,62.72 v4(104.29,62.67)
  BOTTOM w0.076: 103.24,58.59 103.21,58.57 103.21,58.42 103.37,58.26 103.82,58.26 104.24,57.84 104.24,57.83 104.51,57.56 104.51,56.6 103.71,55.81 103.71,55.47 UCPU1.CE1 ; v5(27.02,71.14) 26.96,71.2 26.96,71.45 26.73,71.67 26.62,71.67 26.47,71.82 26.47,72.04 UT5.K5
  BOTTOM w0.112: v5(104.35,63.02) 104.53,63.02 104.65,62.91 104.65,62.78 104.56,62.69 104.1,62.69 103.93,62.52 103.49,62.52 103.24,62.27 103.24,58.59
