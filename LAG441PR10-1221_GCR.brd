# Allegro board LAG441PR10-1221_GCR.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.8VS_AUDIO: length 16.9
  TOP w0.356: 280.92,16.49 CA153.1 281.66,16.63 RA112.2
  TOP w0.508: RA13.2 282.57,16.71 RA112.2 ; RA11.1 275.94,25.36 275.69,25.36 274.88,24.55 274.88,22.09 v3(275.35,21.62) 276.33,20.64 276.33,19.18 277.84,17.67 RA15.1 279.93,17.48 280.92,16.49
+1.8VS_AUDIO_R: length 0.5
  TOP w0.102: 281.66,15.16 v1(281.18,15.16)
+1.8VS_R: length 0.8
  TOP w0.102: 223.66,49.32 v1(223.66,48.49)
+1.8VS_U16: length 2.5
  BOTTOM w0.102: RS3.2 v1(202.31,67.72)
  BOTTOM w0.254: RS3.2 202.13,68.6 201.81,68.27 U16.A2
+3.3V_BAT_LDO: length 469.3
  TOP w0.508: PR197.2 39.84,17.5 v2(40.04,17.3) PD105.2 43.61,17.3 45.57,15.34 45.57,11.65 46.43,10.79 48.55,10.79 49.33,11.56 52.56,11.56 52.6,11.6 101.73,11.6 101.93,11.4 101.93,10.44 102.51,9.86 119.39,9.86 121.44,11.91 121.44,13.61 124.21,16.38 124.34,16.38 124.65,16.69 128.26,16.69 130.23,14.72 130.23,13.14 130.4,12.97 144.54,12.97 146.53,12.44 150.4,11.49 153.65,11.49 153.73,11.47 185.09,11.47 186.26,12.64 v3(199.67,12.64) 201.83,12.64 v2(202.68,11.8) ; v2(65.14,74.14) 65.14,74.64 65.95,75.46 68.62,75.46 71.2,72.88 71.2,69.99 73.29,67.89 80.69,67.89 81.44,68.65 81.44,69.81 83.08,71.44 PR1500.1 ; DB3.2 307.28,7.9 304.79,10.38 301.87,10.38 301.41,10.84 v2(288.61,10.84) ; PR1502.1 v2(38.01,37.08) 38.75,37.08 39.56,36.26 PD1501.2 ; QE26.2 276.2,49.1 RE519.1 276.33,48.35 v6(276.53,48.15)
  IN1 w0.508: v4(36.61,37.28) 37.2,37.28 37.4,37.08 v2(38.01,37.08) ; v2(40.04,17.3) 40.04,17.23 v4(39.78,16.97) ; v2(65.14,74.14) 65.14,73.7 v4(65.16,73.68) ; v2(288.61,10.84) 288.15,10.84 288.15,10.84 279.36,10.84 v4(278.37,11.83) 253.72,11.83 251.74,9.85 222.01,9.85 220.99,10.86 203.61,10.86 v2(202.68,11.8)
  IN2 w0.508: v4(65.16,73.68) 65.16,73.08 62.78,70.7 57.05,70.7 56.56,71.19 52.13,71.19 51.4,70.46 49.31,70.46 48.87,70.03 48.1,70.03 47.04,68.97 47.04,68.54 46.61,68.1 46.61,66.83 45.6,65.82 45.35,65.82 43.37,63.84 43.37,63.12 43.53,62.96 43.53,62.03 43.78,61.79 43.78,61.05 43.42,60.69 42.58,60.69 41.58,59.69 41.58,56.78 41.5,56.7 41.5,54.52 40.24,53.25 40.24,52.46 40.61,52.08 40.61,50.93 39.83,50.15 39.83,49 38.87,48.05 38.87,45.09 36.62,42.83 36.62,37.28 v4(36.61,37.28) ; v4(278.37,11.83) 278.41,11.87 278.41,18.11 278.14,18.38 278.14,24.72 274.34,28.52 271.64,28.52 271.19,28.07 260.59,28.07 256.85,31.81 256.85,33.17 258.26,34.58 260.96,34.58 261.53,35.15 264.32,35.15 264.65,34.82 265.37,34.82 272.21,41.66 272.21,42.63 274.79,45.21 274.79,45.51 276.53,47.25 v6(276.53,48.15)
  IN3 w0.508: v4(36.61,37.28) 37.2,37.28 37.5,36.98 37.5,35.18 38.92,33.76 39.95,33.76 40.6,33.11 40.6,31.18 41.91,29.88 41.91,22.85 41.07,22.01 41.07,17.52 40.52,16.97 v4(39.78,16.97)
+3.3V_BAT_LDO_R: length 5.2
  TOP w0.127: v2(40.75,18.18) v3(42.02,18.18)
  IN1 w0.508: v4(38.94,18.02) 38.98,18.06 40.63,18.06 v2(40.75,18.18)
  IN3 w0.508: v5(38.99,18.57) 38.94,18.52 v4(38.94,18.02)
  BOTTOM w0.508: JBATT1.6 38.43,19.14 v5(38.99,18.57)
+3.3V_EC_PLL: length 6.7
  TOP w0.33: CE7.1 257.97,57.44 258.24,57.7 259.97,57.7 260.2,57.47 CE8.1 262.57,57.27 UE1.F1
  TOP w0.508: CE7.1 257.89,56.89 RE114.2
+3.3V_LDO_PD_A: length 40.5
  TOP w0.254: CT174.1 29.13,66.59 28.8,66.92 28.8,67.51 28.59,67.72 28.17,67.72 27.93,67.96 RT106.1
  TOP w0.305: v2(27.49,67.97) 27.5,67.97 RT106.1
  TOP w0.508: RT260.1 34.77,40.58 36.14,41.95 36.14,47.5 36.63,47.99 v1(36.63,52.96) 36.63,55.61 35.72,56.53 v6(34.74,56.53)
  IN1 w0.254: v4(25.99,68.86) 25.79,68.67 25.21,68.67 v2(25.12,68.76) ; v2(29.22,66.54) 29.04,66.72 v4(29.04,66.84)
  IN1 w0.305: v2(27.49,67.97) 27.49,68.38 v4(27.31,68.57) ; v4(25.99,68.86) 26,68.86 26.22,69.08 v2(26.29,69.08)
  IN1 w0.508: v2(26.12,63.49) 26.31,63.68 v4(26.31,63.88) ; v4(34.15,60.99) 34.57,61.41 v2(34.57,61.6)
  IN2 w0.305: v4(27.31,68.57) 27.31,68.06 27.01,67.77 26.75,67.77 26.57,67.94 26.57,67.94 26.31,68.2 26.31,68.2 26.05,68.45 26.05,68.45 25.99,68.52 v4(25.99,68.86)
  IN2 w0.381: v4(26.71,65.42) 27.22,65.93 28.48,65.93 28.85,66.3 28.85,66.66 v4(29.04,66.84)
  IN2 w0.508: v4(34.15,60.99) 34.74,60.39 v6(34.74,56.53) ; v4(27.7,62.9) 27.32,62.9 26.34,63.88 v4(26.31,63.88) 26.31,65.03 26.7,65.42 v4(26.71,65.42)
  IN3 w0.305: v4(29.04,66.84) 29.27,66.84 v5(29.4,66.97)
  BOTTOM w0.305: UT1.G1 29.34,66.92 v5(29.4,66.97)
  vias: v2(26.86,65.73) v2(28.11,62.87)
+3.3V_LDO_PD_B: length 25.3
  TOP w0.127: RT138.1 26.2,72.85 v2(26.17,72.88)
  TOP w0.254: v2(29.23,73.89) 27.98,75.14 RT123.1 27.51,75.36 27.51,75.61 v2(27.53,75.63) ; 24.94,75.91 24.34,76.51 23.14,76.51 22.97,76.35 22.38,76.35 21.41,77.31 v1(21.41,77.39) ; 24.94,75.91 24.94,76.14 25.42,76.61 25.42,76.61 25.44,76.63 26,76.63 26.26,76.37 RT125.1 ; 24.94,75.91 RT57.2 ; v2(24.51,70.58) 24.5,70.59 24.5,70.97 24.34,71.13 24.34,71.62 24.64,71.93 RT165.1
  IN1 w0.254: v4(29.48,73.64) 29.45,73.66 29.45,73.67 v2(29.23,73.89) ; v4(26.53,72.9) 26.51,72.88 v2(26.17,72.88) ; v2(27.53,75.63) 27.27,75.89 26.62,75.89 v2(26.31,76.19) ; v4(24.76,70.36) 24.73,70.36 v2(24.51,70.58)
  IN2 w0.381: 26.33,71 26.33,70.81 25.87,70.34 24.78,70.34 v4(24.76,70.36) ; 26.33,71 25.89,71.45 25.89,72.6 26.19,72.9 v4(26.53,72.9) ; 26.33,71 26.45,70.89 27.1,70.89 27.19,70.98 27.92,70.98 28.58,71.64 28.58,72.9 29.31,73.64 v4(29.48,73.64)
  IN3 w0.381: v4(29.48,73.64) 29.44,73.64 29.33,73.53 v5(29.15,73.53)
  BOTTOM w0.254: v5(29.15,73.53) 29.13,73.53 28.65,74 28.29,74 UT5.G1
+3.3V_TBT_FLASH: length 25.5
  TOP w0.127: v1(35.39,42.76) 34.39,41.76 RT260.2 RT261.2 32.96,41.5 RT44.1 32.9,41.71 34.01,42.82 UT3.8 34.01,43.71 33.52,44.2 29.93,44.2 29.77,44.36 29.77,46.68 29.64,46.81 29.64,49.72 30.02,50.1 30.33,50.1 30.62,50.38 CT51.1 RT47.1 30.91,50.17 30.91,48.55 31.17,48.28 33.14,48.28 33.37,48.51 33.37,49.63 33.16,49.84 RT46.1 RT45.1
+3.3V_VOUT_PD_A: length 0.7
  IN1 w0.061: v4(27.38,66.48) 27.57,66.29 v2(27.57,66.21)
  IN3 w0.061: v4(27.38,66.48) 27.39,66.48 27.67,66.48 v5(27.73,66.42)
+3.3V_VOUT_PD_B: length 1
  IN1 w0.061: v4(28.04,73.72) 27.7,73.38 v2(27.58,73.38)
  IN3 w0.061: v4(28.04,73.72) 28.01,73.72 v5(27.73,73.43)
+3.3V_VPS_TPM: length 26.9
  TOP w0.254: UZ6.22 44.57,36.08 44.28,36.36 44.28,36.85 CZ19.1 43.81,36.87 43.79,36.85 CZ20.1 43.03,36.85 CZ21.1 ; UZ6.14 48.49,33.89 48.83,34.23
  TOP w0.508: RZ38.2 47.45,38.24 RZ39.2 ; 48.83,34.23 49.08,34.49 v1(49.08,34.88) 49.08,35.55 49.89,36.35 51.57,36.35 52.08,36.86 52.08,37.48 v6(51.74,37.83) 51.74,37.96 49.18,40.52 RZ1413.2
  IN1 w0.508: v2(47.72,37.9) 47.72,37.47 v4(47.91,37.28) ; v2(42.97,37.07) 43,37.11 v4(43.76,37.11)
  IN3 w0.508: v4(43.76,37.11) 47.73,37.11 v4(47.91,37.28) 48.01,37.38 v5(48.01,37.93)
  BOTTOM w0.508: v6(51.74,37.83) 51.01,38.55 48.63,38.55 v5(48.01,37.93)
+3V_1.8V_HDA: length 101.6
  TOP w0.254: RC542.2 RC541.2
  TOP w0.508: RC119.1 v2(23.63,6.99) ; v6(98.84,39.29) 98.84,38.92 98.25,38.32 96.24,38.32 95.91,37.99 93.73,35.81 v3(84.21,35.81) v6(59.31,35.81)
  IN1 w0.254: v2(98.51,43.91) v4(98.69,43.51)
  IN1 w0.508: v4(46.34,24.38) 46.34,24.32 45.82,23.8 43.8,23.8 41.76,21.76 40.68,21.76 39.35,20.42 39.35,19.36 38.32,18.34 38.32,17.74 35.97,15.39 35.97,14.58 33.81,12.42 30.75,12.42 25.32,6.99 v2(23.63,6.99)
  IN2 w0.076: 102.3,42 102.27,41.98 102.27,41.67 102.32,41.62 ; 102.83,41.55 102.93,41.64 102.93,42.04 102.86,42.11 ; 101.59,41.65 101.61,41.67 101.61,42 ; 102.3,42.84 102.26,42.81 102.26,42.54 102.25,42.52 102.25,42.49 ; 100.95,42.51 100.98,42.54 100.98,42.84 ; 98.84,42.98 98.57,42.98 98.39,42.79 98.39,42.53 98.58,42.33 99.76,42.33 ; 101.61,42.82 101.61,42.49 ; 100.32,42.84 100.32,42.51
  IN2 w0.102: 99.66,42.84 99.66,42.59
  IN2 w0.127: 100.95,42 100.95,41.7 100.93,41.67
  IN3 w0.254: v5(98.46,43.28) v4(98.69,43.51)
  IN3 w0.508: v4(46.34,24.38) 47.44,24.38 47.69,24.63 49.81,24.63 50.32,25.14 50.32,30.75 51.04,31.46 v5(51.04,31.97)
  BOTTOM w0.508: v5(51.04,31.97) 52.81,33.74 57.24,33.74 v6(59.31,35.81)
+3V_5105: length 57.6
  TOP w0.203: 269.42,51.24 269.42,52.03 UE1.M9
  TOP w0.229: UE1.K2 263.42,54.01 263.02,53.6 262.32,53.6 262.13,53.41
  TOP w0.305: CE6.1 269.21,51.03 269.42,51.24
  TOP w0.33: 262.23,55.61 UE1.H1
  TOP w0.356: v2(260.43,53.49) v4(260.86,53.49) 261.19,53.16 261.87,53.16 262.13,53.41
  TOP w0.381: v2(268.55,56.13) 268.27,56.41 UE1.G8 ; CE10.1 274.38,57.96 RE183.2 ; v2(269.21,48.82) CE6.1
  TOP w0.508: CE10.1 273.98,57.23 v2(273.79,57.42) ; 262.23,55.61 261.94,55.9 CE9.1 RE114.1 v2(258.8,55.42)
  IN1 w0.381: v4(268.59,56.67) 268.55,56.64 v2(268.55,56.13) ; v2(260.43,53.49) v4(260.86,53.49)
  IN1 w0.508: v4(268.96,60.54) 268.96,60.6 267.17,62.38 v2(266.91,62.38) v4(264.96,62.38) ; v2(258.8,55.42) v4(259.18,55.42) ; v2(269.21,48.82) v4(269.21,49.32) ; v2(273.79,57.42) v4(273.35,57.42)
  IN2 w0.508: v4(260.86,53.49) 260.39,53.49 259.18,54.7 v4(259.18,55.42) ; v4(268.59,56.67) 270.23,56.67 271.16,57.6 273.18,57.6 v4(273.35,57.42)
  IN3 w0.508: v4(269.21,49.32) 268.71,49.32 268.32,49.7 268.32,50.36 267.97,50.72 266.06,50.72 265.38,51.4 262.26,51.4 261.79,51.87 261.79,52.87 262.15,53.23 262.15,53.64 261.69,54.1 261.22,54.1 260.86,53.74 v4(260.86,53.49) ; v4(268.96,60.54) 269.25,60.83 270.2,60.83 270.56,60.47 270.56,59.39 268.93,57.76 268.93,57.01 v4(268.59,56.67) ; v4(264.96,62.38) 264.96,62.08 259.18,56.3 v4(259.18,55.42)
+3V_FPR: length 37.2
  TOP w0.127: v6(310.64,63.11) v3(311.52,63.11)
  TOP w0.305: v2(296.68,69.49) Q14.5 ; Q15.5 v2(296.68,72.28)
  TOP w0.381: R221.1 310.64,63.1 v6(310.64,63.11) ; v2(296.3,68.17) R218.1
  IN1 w0.381: v2(296.3,68.17) 296.3,69.11 v2(296.68,69.49)
  IN1 w0.508: v2(296.3,68.17) 296.76,67.71 v4(297.42,67.71) ; v2(296.68,69.49) 296.89,69.69 v2(296.89,70.92) 296.89,72.08 v2(296.68,72.28)
  IN2 w0.381: v6(301.28,65.17) 302.42,65.17 304.43,63.16 309.18,63.16 309.24,63.11 v6(310.64,63.11)
  IN3 w0.381: v5(312.01,67.32) 312.01,64.14 310.98,63.11 v6(310.64,63.11)
  IN3 w0.508: v6(301.28,65.17) 301.03,65.42 299.58,65.42 297.42,67.58 v4(297.42,67.71)
  BOTTOM w0.508: R284.2 306.19,60.51 306.19,62.1 305.2,63.09 303.73,63.09 303.32,63.49 C18.1
+3V_FPR_R: length 4.2
  BOTTOM w0.127: QV12.1 305.27,61.96 v1(305.58,61.65)
  BOTTOM w0.508: R284.1 304.08,60.33 303.79,60.62 QV12.1
+3V_LDO: length 257.9
  TOP w0.381: PUB2.5 31.06,39.26 31.13,39.2 v2(31.69,39.2)
  TOP w0.457: PR160.1 15.98,55.75
  TOP w0.508: DB4.2 v3(102.7,20.05) v2(102.7,18.69) ; v2(30.15,76.98) 30.82,76.98 v2(30.83,76.97) ; v2(17.13,47.08) 17.13,49.8 16.34,50.59 16.34,55.39 15.98,55.75
  IN1 w0.381: v2(30.15,76.98) 29.63,76.98 29.16,77.45 29.16,77.82 28.63,78.35 21.58,78.35 20.6,77.36 18.32,77.36 15.61,74.65 v4(15.61,74.65)
  IN1 w0.508: v4(12.68,64.9) 12.84,64.73 v2(15.29,64.73) ; v4(7.9,44.68) 8.42,45.21 v2(8.42,45.29) 8.42,45.87 9.56,47.01 v2(11.98,47.01) v4(12.6,47.01) ; v2(31.69,39.2) 31.43,38.94 v4(31.43,38.65) ; v4(30.5,69.8) 30.49,69.81 v2(30.15,69.81) ; v2(30.83,76.97) 30.83,76.36 v4(30.96,76.23) ; v2(102.7,18.69) 102.35,18.69 101.81,19.23 100.13,19.23 99.93,19.04 98.06,19.04 97.12,18.1 97.12,17.54 96.03,16.46 96.03,15.91 95.21,15.09 95.21,14.01 93.82,12.63 58.47,12.63 58.2,12.9 v4(56.34,12.9) ; v2(17.18,69.42) v4(16.73,69.42) ; v4(17.46,46.75) v2(17.13,47.08)
  IN2 w0.508: v6(25.64,9.08) 25.11,8.55 19.15,8.55 17.09,10.61 15.11,10.61 14.5,11.22 14.5,13.23 15.75,14.48 15.75,17.19 15.63,17.31 15.63,21.15 13.13,23.66 13.13,26.64 16.13,29.64 16.13,31.1 17.01,31.98 v4(17.01,32.57) 14.9,34.68 14.9,39.6 13.14,41.36 8.43,41.36 7.9,41.89 v4(7.9,44.68) ; v4(12.6,47.01) 12.14,47.47 9.64,47.47 8.43,48.67 7.09,48.67 6.9,48.86 5.37,48.86 4.14,50.09 4.14,50.9 4.05,50.99 4.05,57.75 4.08,57.9 4.08,57.93 4.09,57.99 4.09,59.45 4.74,60.09 6.64,60.09 9.03,62.48 9.87,62.48 12.29,64.9 v4(12.68,64.9) 12.68,64.96 16.73,69.01 v4(16.73,69.42)
  IN3 w0.508: v4(16.73,69.42) 15.89,69.42 15.06,70.25 v5(15.06,70.36) v5(15.06,70.94) 15.06,74.11 v4(15.61,74.65) ; v4(56.34,12.9) 50.39,12.9 48.42,10.93 v5(47.69,10.93) ; v4(12.6,47.01) 14.19,47.01 14.45,46.75 v4(17.46,46.75) ; v4(30.5,69.8) 30.5,70.95 30.78,71.24 30.78,72.47 31.6,73.28 31.6,74.94 30.96,75.57 v4(30.96,76.23) ; v4(17.01,32.57) 17.84,33.4 17.84,35.26 18.52,35.93 21.13,35.93 21.75,36.56 21.75,37.1 22.01,37.36 23.41,37.36 24.19,38.14 24.87,38.14 25.21,37.8 28.54,37.8 29.39,38.65 v4(31.43,38.65)
  BOTTOM w0.508: v6(25.64,9.08) 29.5,12.95 34.77,12.95 36.79,10.93 v5(47.69,10.93)
+3V_LDOP: length 53.8
  TOP w0.254: PU102.6 21.8,44.48 21.35,44.03 20.75,44.03 20.44,43.72 PR178.1 20.05,43.5 19.93,43.62 PU101.6 19.04,43.62 18.86,43.8 18.86,43.96 PR184.1 18.63,44.5 PC130.1 v2(17.69,44.55)
  IN1 w0.508: v4(17.25,44.93) 17.63,44.55 v2(17.69,44.55)
  IN2 w0.508: v4(12.17,46) 12.17,46.39 11.74,46.82 9.42,46.82 8.67,46.07 7.71,46.07 7.23,46.55 7.23,47.57 6.51,48.28 5.14,48.28 3.57,49.85 3.57,50.67 2.69,51.54 2.69,55.84 3.48,56.62 3.48,57.81 3.51,57.96 3.51,57.98 3.52,58.05 3.52,61.29 5.37,63.14 9.56,63.14 12.03,65.6 12.51,65.6 14.07,67.17 14.07,67.88 13.74,68.21 v4(13.74,69.73)
  IN3 w0.508: v4(17.25,44.93) 17.23,44.91 16.63,44.91 15.92,45.63 12.55,45.63 v4(12.17,46) ; v4(13.74,69.73) 13.74,70.84 v5(13.47,71.11)
+3V_PCH: length 373.9
  TOP w0.254: v6(201.4,61.28) 202.16,62.05 202.16,64.76 202.7,65.31 207.58,65.31 208.74,66.47 222.64,66.47 v6(227.52,61.59) ; v6(50.41,37.44) 50.41,38.55 50.16,38.81 50.16,38.81 47.65,41.31 47.65,44.05 v6(47.49,44.21) ; v6(51.47,66.54) 51.47,66.69 51.1,67.06 RC225.1 ; RN106.1 RN116.1 254.11,46.48 254.11,47.73 254.25,47.87 v2(254.25,48.15)
  TOP w0.305: v6(103.69,28.44) 103.69,28.99 103.92,29.22 RC634.2 103.92,29.89 RC46.2 ; JAPS1.1 127.8,33.61 127.49,33.91 v6(127.49,34.03)
  TOP w0.356: RZ39.1 47.32,37.46 RZ19.1
  TOP w0.381: RC616.2 102.25,27.01 v2(102.25,26.6) ; v2(107.42,39.1) 108.72,39.1 109.1,39.48 RC41.1 ; 109.26,41.17 109.3,41.13 RC608.2 111.91,41.13 112.13,40.91 112.13,39.59 112.51,39.21 112.97,39.21 v6(112.98,39.2) ; RC560.1 105.79,40.53 v2(105.76,40.51)
  TOP w0.508: RZ39.1 49.06,37.06 49.44,37.44 v6(50.41,37.44) ; v2(103.02,13.32) 103.15,13.44 D203.2 102.73,13.94 102.5,13.71 RC628.2 101.88,13.99 101.88,25.63 102.25,26 v2(102.25,26.6)
  IN1 w0.254: v2(254.25,48.15) 254.25,47.78 254.15,47.68 252.65,47.68 v4(252.5,47.82) ; v6(47.49,44.21) 47.49,47.41 46.76,48.15 45.34,48.15 v4(44.37,49.12) ; v4(102.59,46.03) v2(102.4,45.71)
  IN1 w0.381: v4(102.45,26.13) 102.25,26.33 v2(102.25,26.6) 102.25,27.73 102.86,28.35 103.6,28.35 v6(103.69,28.44) ; v2(107.42,39.1) 106.81,39.1 106.36,39.55 105.68,40.23
  IN1 w0.508: v6(201.4,61.28) 201.4,59.48 203.1,57.78 203.1,42.62 196.22,35.74 194.69,35.74 194.69,35.74 194.4,35.74 193.41,34.75 190.78,34.75 190.35,34.32 v6(190.35,34.05) ; v4(102.42,12.32) 102.42,12.86 102.88,13.32 v2(103.02,13.32)
  IN2 w0.254: v4(45.36,67.53) 45.36,67.21 45.12,66.97 44.88,66.97 41.65,63.74 41.65,62.74 40.85,61.94 40.85,59.93 40.88,59.9 40.88,56.71 40.68,56.52 v4(40.68,54.97)
  IN2 w0.508: v6(127.49,34.03) 127.49,29.11 v6(128.04,28.57)
  IN3 w0.254: v5(103.01,41.6) v4(103.24,41.83) ; v5(102.36,41.6) v4(102.59,41.83) ; v5(100.41,41.6) v4(100.59,41.88) ; v5(102.36,45.8) v4(102.59,46.03) ; v4(44.37,49.12) 44.33,49.15 44.33,49.84 43.89,50.28 43.89,51.28 40.68,54.49 v4(40.68,54.97) 40.68,55.27 v5(40.48,55.47) ; v5(103.66,41.6) v4(103.89,41.83) ; v4(45.36,67.53) 46.41,66.48 51.41,66.48 v6(51.47,66.54) ; v5(103.01,42.44) v4(103.24,42.67) ; v6(227.52,61.59) 228.15,62.22 242.7,62.22 248.18,56.74 248.18,52.24 252.5,47.92 v4(252.5,47.82) ; v5(99.76,41.6) v4(99.99,41.83) ; v5(103.66,42.44) v4(103.89,42.67) ; v5(102.36,42.44) v4(102.59,42.67) ; v4(59.32,67.02) v5(58.76,67.02)
  IN3 w0.381: v4(118.6,31.79) v5(118.6,32.15) ; v5(106.11,26.96) v4(106.11,26.56)
  IN3 w0.508: v4(102.42,12.32) 100.17,12.32 99.85,12.64 96.3,12.64 95.98,12.32 60.23,12.32 56.4,16.15 56.4,22.3 56.28,22.42 56.28,28.75 55.4,29.63 55.4,32.46 v6(50.41,37.44)
  BOTTOM w0.127: 105.83,26.82 105.7,26.82 105.45,27.07 105.45,28.34 105.57,28.47 106.46,28.47 106.65,28.66 RC484.2
  BOTTOM w0.254: RT305.2 30.37,60.56 RT304.2 32.19,60.56 32.27,60.65 34.48,60.65 34.85,60.28 34.85,58.61 35.2,58.25 37.54,58.25 39.08,56.72 39.08,56.46 40.07,55.47 v5(40.48,55.47) ; v6(123.86,42.67) 123.95,42.75 RC582.1 ; v6(51.47,66.54) 51.98,66.03 53.36,66.03 54.35,67.02 v5(58.76,67.02) ; v6(114.21,52.13) 113.8,51.72 RC623.2 ; 103.67,28.44 103.64,28.47 103.58,28.47 RC29.2 ; RC551.2 RC81.2 RC118.2
  BOTTOM w0.305: 103.67,28.44 104.04,28.81 RC482.2 ; 103.67,28.44 v6(103.69,28.44) ; 103.67,28.44 103.67,29.66 103.92,29.91 RC118.2
  BOTTOM w0.356: RE473.1 115.71,52.79 115.73,52.76 R101.1
  BOTTOM w0.381: RC18.2 118.64,32.47 118.6,32.43 RC20.2
  BOTTOM w0.508: v6(115.28,52.15) 115.81,52.69 R101.1 ; v6(190.35,34.05) 190.04,34.05 187.65,31.67 185.05,31.67 173.79,20.41 164.76,20.41 161.74,20.68 156.47,21.48 154,22.04 151.08,23 147.6,24.61 145.67,25.86 143.75,25.86 RV69.1 141.18,26.93 141.12,26.87 137.56,26.87 136.85,26.94 136.18,27.17 135.18,27.63 134.25,28.57 v6(128.04,28.57)
  vias: v2(59.01,67.24) v2(104.27,42.82) v3(102.64,48.14) v4(104.12,42.22) v4(105.39,40.49) v6(113.7,47.82)
+3V_PCH_DSW: length 250.6
  TOP w0.254: v6(260.74,12.77) 261.44,13.47 v1(261.44,22.54) 261.44,30.73 261.9,31.18 261.9,32.65 260.76,33.79 260.76,33.81 260.25,34.31 259.69,34.31 259.03,34.97 259.03,35.34 258.02,36.35 258.02,39.6 259.76,41.34 259.76,42.16 259.96,42.35 CN57.1 260.26,43.62 ; v2(99.47,27.02) RC74.1 RC465.2
  TOP w0.381: v2(112.43,37.58) 110.77,37.58 108.98,35.79 107.51,35.79 107.32,35.99 106.02,35.99 105.79,35.76 100.67,35.76 v2(100.57,35.86)
  IN1 w0.254: v4(147.99,9.59) 147.89,9.59 146.85,10.64 146.73,10.73 145.88,11.12 145.72,11.16 145.72,11.16 145.18,11.3 134.38,11.3 132.67,13.01 132.67,14.22 128.71,18.18 125.23,18.18 122.6,20.81 121.43,20.81 119.85,22.39 119.35,22.39 118.71,23.03 113.47,23.03 112.66,22.22 108.44,22.22 107.94,22.72 107.94,23.99 106.48,25.45 102.24,25.45 100.42,27.27 ; 100.42,27.27 100.75,27.6 100.75,28.88 v4(100.9,29.03) ; 100.42,27.27 99.72,27.27 v2(99.47,27.02)
  IN1 w0.381: v4(99.5,36.98) 99.5,36.89 99.57,36.83 99.72,36.83 100.09,36.46 100.09,36.15 100.38,35.86 v2(100.57,35.86) 100.61,35.86 100.7,35.95 100.7,36.59 100.2,37.09 100.2,37.94 99.94,38.21 99.94,39.64 99.01,40.57 v2(98.84,40.57) ; v2(112.43,37.58) 112.48,37.58 v4(112.94,37.13)
  IN2 w0.381: v4(99.5,36.98) 99.53,36.98 99.96,36.54 99.96,35.27 99.63,34.94 99.63,32.82 100.34,32.11 100.34,29.6 v4(100.9,29.03)
  IN3 w0.254: v5(148.32,9.59) v4(147.99,9.59) ; v6(260.74,12.77) 259.22,11.25 252.53,11.25 251.08,9.8 221.75,9.8 220.75,10.8 186.45,10.8 185.33,9.67 v5(185.23,9.67) ; v4(100.9,29.03) 100.81,29.13 v5(100.81,29.39) ; v5(98.46,41.6) v4(98.68,41.85)
  IN3 w0.381: v4(112.94,37.13) 112.94,37.46 v5(112.92,37.48)
  BOTTOM w0.254: RC82.2 v5(100.81,29.39) ; v5(148.32,9.59) 185.14,9.59 v5(185.23,9.67)
  BOTTOM w0.381: v5(112.92,37.48) 113.5,37.48 116.23,40.21 116.23,42.3 RC604.1 RC424.1 RC394.1
  vias: v2(98.32,41.19) v4(98.04,40.97) v5(97.8,40.75)
+3V_PCH_DSW_R: length 3.4
  BOTTOM w0.381: RC424.2 114.65,43.62 114.29,43.99 v1(114.29,44.49) 115.09,45.29 QC3.1
+3V_PCH_R: length 1.8
  TOP w0.127: v1(127.06,29.34) 126.16,30.24 R59.1
+3V_SPI: length 1.2
  TOP w0.127: v1(103.35,11.12) 103.15,11.32 D203.1
  vias: v2(104.11,12.05) v4(104.51,11.87) v5(104.3,12.26) v5(104.63,12.26)
+3V_SSD: length 7.1
  TOP w0.127: R46.2 222.67,60.42 v3(222.57,60.32)
  BOTTOM w0.305: JNGFF2.12 v6(214.27,61.86) ; JNGFF2.18 214.1,60.36 ; 214.1,60.36 v6(214.12,60.34) ; 214.1,60.36 213.6,60.86 JNGFF2.16 ; v6(214.25,61.27) 214.15,61.36 JNGFF2.14
  vias: v2(212.53,55.39) v2(212.53,51.96) v3(214.32,45.04) v3(215.28,46.72) v6(213.95,64.64) v6(213.98,64.03) v6(213.97,47.26) v6(214.62,60.75) v6(214.6,47.26) v6(214.84,61.46)
+3V_TBT: length 7
  TOP w0.305: CT150.1 19.56,53.61 19.23,53.95 19.23,54.7 18.91,55.02 18.58,55.02
  IN1 w0.254: v4(18.62,56.61) 18.81,56.61 18.85,56.65 v2(18.96,56.65)
  IN1 w0.305: v4(21.4,53.81) 21.45,53.81 21.67,53.59 v2(21.67,53.59)
  IN3 w0.229: v5(21.63,53.57) v4(21.4,53.81)
  IN3 w0.254: v5(18.18,56.87) 18.36,56.87 v4(18.62,56.61)
  BOTTOM w0.203: UT2.B3 UT2.A3 UT2.A2 18.18,56.87 v5(18.18,56.87)
  vias: v3(17.51,56.33)
+3V_TBT_S0: length 4.1
  IN1 w0.203: v4(24.65,51.39) v5(24.88,51.62)
  IN3 w0.254: v5(24.88,51.62) v4(24.65,51.39)
  IN3 w0.457: v4(28.66,61.65) 29.2,61.12 v5(29.76,61.12)
  BOTTOM w0.381: RT13.2 29.08,59.96 29.08,59.96 29.08,60.66 29.54,61.12 v5(29.76,61.12)
  vias: v1(26.91,47.67) v2(26.19,47.61) v2(26.51,48.07) v2(26.77,48.07) v2(27.04,48.07) v4(26.51,47.73) v4(26.99,47.72)
+3V_WLAN: length 13.1
  TOP w0.254: RN77.1 219.07,27.49 218.52,26.93 218.52,26.89 218.72,26.89 219.39,26.22 RN78.1 220.82,26.22 v2(220.83,26.21) QN9.5 ; QN5.2 v2(210.16,26.21) ; QN9.2 v2(220.83,27.23)
  TOP w0.508: v2(213.28,28.16) 213.38,28.06 214.92,28.06 ; 217.63,26.93 218.52,26.93
  IN1 w0.254: v2(210.16,26.21) v2(210.16,27.23) 210.29,27.36 v2(211.49,27.36) ; v2(220.83,26.21) v2(220.83,27.23)
  IN1 w0.508: v2(213.28,28.16) 212.29,28.16 v2(211.49,27.36)
  vias: v2(217.59,30.5) v2(217.59,30.12) v2(217.6,29.81) v2(251.84,32.4) v2(252.26,32.4) v2(252.26,32.09) v3(215.24,34.71) v3(215.24,32.56) v3(216.14,30.5) v6(216.33,22.07) v6(216.7,41.04) v6(216.66,40.45) v6(216.76,21.71)
+3V_WWAN: length 114.8
  TOP w0.254: 257.48,35.55 257.71,35.32 258.51,35.32 258.65,35.18 258.65,34.82 259.5,33.97 RN7.1
  TOP w0.305: QN8.2 QN8.5 258.77,31.25 258.6,31.43 CN3.1
  TOP w0.356: 196.19,67.35 CS11.1 CN41.1 RN67.1
  TOP w0.381: RN74.2 270.93,30.79 v6(270.69,30.55)
  TOP w0.508: v6(228.23,61.61) 228.23,61.94 223.02,67.15 199.12,67.15 198.94,66.97 196.57,66.97 196.19,67.35 ; v2(252.53,29.74) 252.7,29.74 v3(254.52,31.56) 254.9,31.93 257.21,31.93
  IN1 w0.254: v2(269.72,34.98) 269.72,34.36 v4(269.98,34.11) 269.72,33.85 v2(269.72,33.38) ; v2(268.32,33.25) 268.07,33 v4(268.07,32.91)
  IN1 w0.508: v2(252.53,29.74) 252.53,27.6 249.39,24.47 234.96,24.47 232.29,27.13 v6(232.29,29.05)
  BOTTOM w0.508: v6(228.23,61.61) 228.97,60.88 228.97,50.63 227.47,49.14 227.47,45.65 226.91,45.09 226.91,40.32 232.29,34.93 v6(232.29,29.05)
  vias: v2(256.13,33.39) v2(256.37,33.52) v2(256.59,33.39) v2(257.66,33.55) v2(257.66,33.17) v2(257.97,33.36) v2(258.29,33.55) v2(258.29,33.17) v4(257.53,32.15) v4(258.04,32.15) v5(257.9,31.61) v5(258.4,31.61) v6(273.58,33.01) v6(274.09,32.76) v6(274.65,33.01)
+3VA_TBT: length 54.7
  IN1 w0.203: v4(22.05,60.33) 22.45,60.33 22.97,60.85 v2(22.97,61.29) ; v4(22.1,60.75) 22.58,61.23 v2(22.58,61.27)
  IN1 w0.229: v4(20.75,54.46) v5(20.98,54.22)
  IN1 w0.508: v2(49.07,33.05) 48.86,33.27 v4(48.63,33.27) ; v4(39.53,41.8) 34.96,37.23 31.32,37.23 30.35,38.19 28.04,38.19 v4(27.82,38.41)
  IN2 w0.508: v4(27.82,38.41) 27.82,39.64 30.45,42.27 30.45,47.29 30.01,47.73 30.01,56.6 v4(30.42,57)
  IN3 w0.229: v5(20.98,54.22) v4(20.75,54.46)
  IN3 w0.508: v4(48.63,33.27) 47.93,33.97 47.93,34.35 46.02,36.25 43.4,36.25 42.89,36.76 42.89,38.15 39.53,41.51 v4(39.53,41.8)
  BOTTOM w0.254: RT295.2 30.6,59.95 30.99,59.56 30.99,57.74 30.64,57.39 RT10.2
  vias: v3(22.88,60.8) v4(27.3,61.46) v4(27.6,61.75) v5(21.74,61.09) v5(21.75,59.97) v5(22.87,61.14) v5(25.47,61.22) v5(25.76,61.77) v5(26.05,61.21) v5(27.11,61.14) v5(27.8,60.04) v5(28.29,61.99) v5(28.55,62.08) v5(30.39,59.92) v5(30.35,57.34)
+3VA_TBT_LC: length 40.9
  TOP w0.102: CT148.1 v2(24.88,55.39)
  TOP w0.305: v2(29.97,42.36) 29.97,41.96 31.46,40.47 v1(32.42,40.47) 33.51,40.47 RT261.1
  IN1 w0.254: v4(24.65,55.11) v2(24.88,55.39) ; v2(29.97,42.36) 29.88,42.45 v4(29.88,42.82)
  IN2 w0.254: v4(29.88,42.82) 29.88,44.76 30.01,44.89 30.01,47.1 29.53,47.58 29.53,57.02 30.29,57.78 v4(30.38,57.78)
  IN2 w0.381: v4(25.12,59.57) 25.46,59.57 25.88,59.15 25.88,56.74 25.32,56.19 25.32,55.5 24.92,55.11 v4(24.65,55.11)
  IN3 w0.254: v5(24.88,54.87) v4(24.65,55.11)
  IN3 w0.305: 25.01,60.37 25.01,60.45 24.85,60.61 24.85,60.84 v5(24.55,61.14) 24.55,61.3 25.41,62.17 26.02,62.17 26.33,62.48 26.94,62.48 v5(27.11,62.31) 27.21,62.21 27.97,62.21 28.26,62.5 29.89,62.5 30.52,61.87 30.52,60.75 30.74,60.53 30.74,59.26 v5(29.89,58.41) 29.89,58.39 30.38,57.9 v4(30.38,57.78)
  BOTTOM w0.254: RT6.1 30.41,58.16 30.16,58.41 v5(29.89,58.41)
  vias: v5(25.1,59.97)
+3VALW: length 765.1
  TOP w0.254: RE105.2 RE138.1 RE131.2 ; PR137.1 33.37,60.23 v6(33.15,60) ; UI2.13 288.6,49.32 288.9,49.62 CI14.1 ; UI2.1 286.1,44.09 285.72,43.71 CI13.1 ; PR604.1 46.53,24.67 47.06,24.14 PC606.1
  TOP w0.305: v6(221.77,41.14) 221.68,41.05 RW19.2 ; RE522.2 268.62,47.57 RE516.2 ; RE487.2 v6(254.04,60.04)
  TOP w0.356: RE177.1 250.16,52.28 v6(250.16,52.65) 250.16,53.35 RE197.1 ; RK4.1 217.27,17.47 v2(217.35,17.39) ; RN70.1 RN108.1 v2(251.66,45.54) ; v2(98.85,18.09) 98.85,17.45 98.52,17.12 U11.5 ; v2(16.05,70.05) 16.07,70.04 16.61,70.04 PR128.1 ; v6(35.52,68.47) 35.53,68.46 PR102.1 36.19,68.52 38.48,68.52 PR138.1 ; v6(264.82,64.59) 264.82,64.53 264.9,64.46 RE104.2 ; RE124.2 275.3,49.8 275.54,50.04 275.54,50.83 275.42,50.95 RE120.2 ; v2(38.33,62.64) 38.26,62.58 PR107.1 ; RE497.2 RE192.1
  TOP w0.381: RE109.2 RE108.2 RE521.2 262.04,47.97 v2(262.03,47.96) 262.04,47.94 262.04,47.67 262.4,47.31 RE113.2 ; v2(277.47,56.7) 277.56,56.79 RE488.2 ; RE502.2 268.29,48.88 267.89,48.48 267.89,48 268.29,47.61 RE516.2 ; v2(287.63,42.14) RI74.2 RI76.2 286.36,41.89 v6(286.09,41.62) ; v2(274.97,61.36) RE126.2 RE525.1 ; v2(258.58,58.81) 258.57,58.81 258.57,58.21 RE503.2 ; v6(39.04,58.12) 38.84,58.12 38.2,58.76 PR139.1 ; RE200.1 277.09,54.1 276.71,54.48 275.09,54.48 RE116.2 ; RE200.1 277.47,53.61 278.15,54.3 RE142.2 RE488.2 ; RE200.1 277.09,53.56 276.58,53.05 RE518.1 275.82,52.09 RE489.2 RE119.2 RE120.2 ; CE11.1 277.27,59.66 277.83,60.22 277.83,61.62 277.58,61.87 v2(276.17,61.87) ; RE488.2 RE490.2 ; RA123.2 292.96,17.65 ; RE118.2 RE505.2 255.88,53.49 255.55,53.15 255.55,52.49 v2(255.53,52.48) ; v6(289.41,49.89) CI14.1 ; v2(265.91,48.41) RE141.2 ; RE535.2 RE124.2 ; CZ22.1 41.57,29.38 CZ23.1 41.59,28.68 RZ34.1 41.62,27.49 41.9,27.21 41.9,24.91 42.28,24.53 46.34,24.53 PR604.1 ; v2(270.48,47.57) RE522.2 ; v6(285.16,42.73) CI13.1
  TOP w0.457: v2(16.18,57.39) 16.18,56.85 15.67,56.34 PR169.1 15.04,56.34 14.59,55.88 PR174.1
  TOP w0.508: v2(280.17,13.63) 277.15,13.63 v2(276.47,12.95) ; 275.54,50.83 278.22,50.83 278.57,50.48 RI44.2 RI42.2 RI40.2 RI38.2 RI101.1 v6(288.26,51.07) ; 155.38,20.9 154.62,21.66 151.1,21.66 150.42,21.82 148.75,22.55 147,23.44 144.15,25.15 141.35,27.26 136.9,31.57 ; v6(228.15,42.31) 228.15,42.31 C85.1 228.13,42.97 U17.1 ; v6(44.83,67.52) 44.83,66.4 43.47,65.04 PR136.1 ; v6(80.76,68.87) 80.76,69.74 80.25,70.25 79.56,70.25 79.13,70.68 79.13,72.33 77.38,74.08 v2(77.38,75.71) ; RTCD3.2 304.9,4.34 CV27.1 304.58,6.05 304.36,6.28 304.36,9.47 v6(304.53,9.65) ; v6(40.8,52.69) 40.79,52.69 40.74,52.75 PR910.1 PR909.1 ; v2(270.48,47.57) 270.56,47.49 RE506.2 270.56,46.54 270.37,46.35 270.37,44.73 270.98,44.11 272.54,44.11 v6(274.2,45.78) ; v2(259.8,17.29) 257.96,17.29 251.34,10.67 244.77,10.67 244.17,11.27 QK2.3 242.71,12.13 RK6.1 242.54,11.51 241.97,10.94 RK5.1 241.4,11.75 241.52,11.87 v2(241.52,12.21) 240.91,12.21 240.52,12.59 240.52,13.39 242.54,15.41 RK12.1 242.89,16.24 243.05,16.07 QK5.3 ; v2(23.46,59.7) 23.48,59.67 23.48,59.19 23.66,59.01 RT49.1 ; RE535.2 275.41,48.71 v6(275.41,47.14) 273.43,47.14 RE497.2 ; v2(30.86,77.72) 30.78,77.81 RT146.1 ; v2(49.05,44.97) 49.2,44.83 49.2,42.42 RZ1413.1 ; v2(109.35,16.64) 109.35,19.92 v2(109.92,20.48) ; v2(30.62,70.62) 30.61,70.63 RT145.1 ; 292.96,17.65 292.66,17.34 290.67,17.34 287.59,14.26 287.59,12.31 v6(288.12,11.78) ; v6(271.9,66.82) 271.88,66.8 RE121.2 RE495.2 RE496.2 RE111.2 RE110.2 ; v6(118.55,44.14) 118.55,41.47 118.83,41.19 124.8,41.19 v6(126.53,42.92) ; PR908.1 43.78,53.21 v2(43.78,52.63) ; v6(129.38,51.22) 128.72,51.89 128.72,53.3 131.74,56.32 131.74,63.39 129.85,65.27 PR1104.1 122.42,66.63 120.71,64.93 116.86,64.93 v6(113.83,67.96) 110.45,67.96 109.77,68.65 109.77,70.2 108.2,71.76 108.2,75.21 107.99,75.43 107.62,75.8 99.34,75.8 98.35,74.81 97.65,73.12 97.04,72.37 95.1,70.43 90.57,70.43 87.53,73.48 87.53,74.72 v6(86.74,75.51)
  TOP w0.762: 131.61,41.46 134.58,38.61 135.5,36.89 136.9,31.57
  IN1 w0.254: v4(260,58.91) 259.84,59.07 v2(259.84,59.35) ; v2(277.27,58.88) 277.01,58.79 v4(276.9,58.57) ; v4(48.48,23.86) 48.48,23.74 48.22,23.49 47.86,23.49 47.28,23.73 v2(47.18,23.68) ; v2(43.78,52.63) 43.84,52.57 v4(44.46,52.57)
  IN1 w0.356: v2(16.05,70.05) 16.07,70.07 v4(16.54,70.07)
  IN1 w0.381: v2(31.05,52.34) 31.3,52.34 31.48,52.52 v4(31.48,52.52) ; v2(271.77,63.88) 271.78,63.87 v4(271.78,63.51) ; v2(33.77,52.38) 33.69,52.46 v4(33.38,52.46) ; v2(274.97,61.36) 275.11,61.36 275.62,61.87 v2(276.17,61.87) ; v4(266.48,49.15) 266.48,48.98 v2(265.91,48.41) ; v2(271.82,48.88) 271.79,48.85 270.53,48.85 v2(270.51,48.83) 270.51,47.59 v2(270.48,47.57) ; v4(258.14,58.53) 258.29,58.53 v2(258.58,58.81) ; v2(262.03,47.96) 261.61,47.96 v4(261.56,47.9) ; v2(261.03,36) v4(260.53,36) ; v2(38.33,62.64) v4(38.33,62.3)
  IN1 w0.508: v4(276.75,61.63) 276.53,61.63 276.28,61.87 v2(276.17,61.87) ; v2(241.52,12.21) 236.21,17.52 220.61,17.52 220.48,17.39 v2(217.35,17.39) ; v4(108.73,16.67) 108.79,16.67 109.32,16.67 v2(109.35,16.64) ; v4(256.14,52.62) 255.67,52.62 v2(255.53,52.48) ; v4(277.05,12.95) v2(276.47,12.95) 273.01,12.95 271.06,14.9 v2(271.06,14.92) 270.31,14.17 269.58,14.17 269.15,14.6 269.15,15.54 267.4,17.29 v2(259.8,17.29) ; v2(256.61,60.9) 256.7,60.8 v4(256.7,60.12) ; v2(23.46,59.7) 23.01,59.7 v4(22.96,59.65) ; v4(301.37,62.79) 299.06,60.49 297.21,60.49 295.72,59 293.27,59 v4(292.45,58.18) ; v2(98.85,18.09) 99.84,18.09 v4(100.32,18.57) ; v2(30.62,70.62) 30.87,70.38 v4(31.04,70.38) ; v4(16.51,57.73) v2(16.18,57.39) ; v2(30.86,77.72) v4(31.63,77.72) ; v4(252.25,45.43) 251.76,45.43 v2(251.66,45.54) ; v2(109.92,20.48) v4(109.57,20.48) ; v2(287.63,42.14) 288.05,41.73 288.55,41.73 288.9,42.08 v2(288.9,42.14) 288.9,42.68 288.89,42.69 v4(288.89,42.71) ; v4(78.02,75.58) 77.89,75.71 v2(77.38,75.71) ; v2(280.17,13.63) 281.65,12.16 283.22,12.16 283.62,12.55 284.83,12.55 285.63,11.75 288.1,11.75 v6(288.12,11.78) ; v4(45.47,50.02) 45.48,50.01 46.12,50.01 48.35,47.79 48.35,45.68 v2(49.05,44.97)
  IN2 w0.381: v4(31.63,77.72) 31,78.35 24.14,78.35 23.15,77.36 23.15,76.73 22.37,75.95 22.37,73.96 21.82,73.41 21.82,71.67 22.14,71.35 22.14,70.86 20.75,69.47
  IN2 w0.508: v6(289.41,49.89) 289.41,43.23 v4(288.89,42.71) ; v4(48.48,23.86) 48.3,23.68 45.61,23.68 43.51,25.77 39.67,25.77 39.21,26.24 36.59,26.24 32.8,30.02 32.8,34.1 35.21,36.51 35.21,36.79 35.52,37.1 35.52,41.63 v6(35.25,41.9) ; 128.26,49.52 128.26,48.23 128.82,47.67 130.23,47.67 130.74,47.16 130.74,45.36 130.03,44.64 130.03,43.41 130.28,43.16 ; 128.26,49.52 128.26,50.1 v6(129.38,51.22) ; 128.26,49.52 127.65,48.91 125.88,48.91 125.36,49.43 v4(122.81,49.43) 122.81,49.44 121.31,50.93 119.32,50.93 v6(119.16,51.09) 119.13,51.12 119.13,55.58 v6(119.52,55.97) ; v6(80.76,68.87) 82.46,67.16 82.46,63.44 81.69,62.67 76.47,62.67 74.13,60.33 66.21,60.33 v6(65.53,61.02) ; 18.45,69.47 17.76,70.17 16.64,70.17 v4(16.54,70.07) ; 18.45,69.47 20.75,69.47 ; 18.45,69.47 18.45,68.28 18.87,67.86 20.05,67.86 20.67,67.25 20.67,63.36 v4(20.02,62.71) 17.18,62.71 16.51,62.03 v4(16.51,57.73) ; v6(275.41,47.14) 275.41,46.98 v6(274.2,45.78) 273.51,45.78 271.36,43.63 271.36,41.73 266.99,37.35 261.74,37.35 260.55,36.16 260.55,36.02 v4(260.53,36) 260.39,35.86 257.78,35.86 256.95,35.02 255.08,35.02 254.56,34.5 254.56,33.38 255.15,32.78 255.15,31.3 255.68,30.78 255.68,28.75 256.16,28.27 258.71,28.27 260.06,26.92 271.66,26.92 272.11,27.37 273.37,27.37 273.85,26.89 273.85,25.9 274.71,25.04 276.73,25.04 277.47,24.3 277.47,13.37 v4(277.05,12.95) ; v4(50.52,71.79) 50.79,71.79 51.48,72.48 58.32,72.48 58.83,71.98 62.25,71.98 63.8,73.53 63.8,74.45 65.33,75.98 76.38,75.98 76.77,75.58 v4(78.02,75.58) 78.03,75.59 86.65,75.59 v6(86.74,75.51) ; v4(20.36,61.94) 20.58,61.72 20.58,59.98 20.95,59.61 22.92,59.61 v4(22.96,59.65) ; v4(276.75,61.63) 279.33,64.2 280.92,64.2 284.45,67.74 v6(284.45,68.47) ; v4(49.8,72.49) 49.27,72.49 48.63,71.85 47.54,71.85 47.03,71.34 47.03,70.76 46.49,70.22 45.61,70.22 44.66,69.28 44.66,67.69 v6(44.83,67.52)
  IN3 w0.254: v5(47.88,23.92) 48.42,23.92 v4(48.48,23.86)
  IN3 w0.381: v4(128.46,42.92) 128.69,42.69 v5(128.69,42.55)
  IN3 w0.457: v5(107.91,16.63) 107.95,16.67 v4(108.73,16.67)
  IN3 w0.508: v6(285.16,42.73) 285.38,42.73 286.09,42.02 v6(286.09,41.62) ; v5(35.5,13.66) 35.5,14.92 36.93,16.35 40.93,16.35 41.64,17.06 41.64,21.77 43.6,23.73 47.69,23.73 v5(47.88,23.92) ; v4(260.63,41.98) 260.58,41.93 260.58,36.05 v4(260.53,36) ; v4(100.68,18.07) 100.29,17.68 v5(100.29,17.54) ; v6(80.76,68.87) 81.18,68.45 81.18,66.9 82.8,65.27 83.45,65.27 v5(83.89,64.84) ; v4(20.02,62.71) 20.33,61.95 v4(20.36,61.94) ; v5(292.45,58.73) v4(292.45,58.18) 292.45,53.79 289.99,51.33 288.52,51.33 v6(288.26,51.07) 288.26,50.4 288.77,49.89 v6(289.41,49.89) ; v5(302.03,62.79) v4(301.37,62.79) ; v5(43.58,53) 43.78,53 44.21,52.57 v4(44.46,52.57) 44.46,50.56 45.01,50.01 45.46,50.01 v4(45.47,50.02) ; 17.82,69.23 17.82,69.61 17.36,70.07 v4(16.54,70.07) ; v4(109.57,20.48) 109.13,20.48 v5(109.03,20.38) ; v5(100.24,19.07) 100.32,18.99 v4(100.32,18.57) ; v4(122.81,49.43) v5(122.81,50.09)
  BOTTOM w0.254: PC813.1 119.28,56.22 v6(119.52,55.97) 119.62,55.87 119.62,55.35 119.96,55.01 PU800.15 ; PR1405.1 99.99,16.02 99.76,16.25 99.76,17.29 100.01,17.54 v5(100.29,17.54)
  BOTTOM w0.381: U33.5 285.1,69.32 R274.1 v6(284.45,68.47) ; v6(39.04,58.12) 39.45,58.12 PR902.1
  BOTTOM w0.508: v6(42.07,54.97) 42.07,54.95 41.91,54.79 PR937.1 ; v6(129.38,51.22) 129.37,51.21 PR1425.2 ; v6(113.83,67.96) 111.29,67.96 110.72,68.54 PR1009.1 ; v6(304.53,9.65) 303.34,10 302.27,10 301.59,10.27 300.36,10.92 290.17,10.92 289.3,11.78 v6(288.12,11.78) ; PR1414.1 125.92,43.28 126.28,42.92 v6(126.53,42.92) ; PR1403.2 v5(109.03,20.38) ; v6(119.16,51.09) 118.68,51.09 118.01,51.76 PR807.1 ; PR1423.2 123.07,50.35 v5(122.81,50.09) ; v5(35.5,13.66) 29.02,13.66 28.31,14.37 23.54,14.37 18.65,19.27
  vias: v2(125.45,28.53) v2(125.45,28.2) v2(254.1,42.08) v2(254.1,41.64) v2(254.1,41.26) v2(256.13,42.08) v2(256.13,41.61) v2(256.13,41.23) v2(256.45,41.61) v2(256.45,41.23) v2(261.02,41.76) v2(276.88,57.3) v3(191.67,38.06) v3(193.28,36.19) v3(195.35,37.27) v4(50.12,72.19) v4(125.79,28.53) v4(125.79,28.07) v4(253.69,42.07) v4(253.69,41.6) v4(253.69,41.15) v4(255.18,42.12) v4(255.61,42.16) v4(256.01,42.44) v4(256.51,42.5) v4(256.58,42.06) v5(17.66,68.73) v5(18.01,68.73) v6(43.12,72.52) v6(127.23,35.62) v6(127.65,35.18) v6(129.63,37.12) v6(130.02,36.71) v6(130.9,42.84) v6(130.91,42.27) v6(189.98,38) v6(189.98,37.44) v6(189.98,36.87) v6(189.99,36.31) v6(190.61,38) v6(190.59,37.44) v6(190.6,36.87) v6(190.61,36.3) v6(191.14,37.16) v6(191.14,36.56) v6(191.7,37.13) v6(191.71,36.57) v6(192.29,37.12) v6(192.29,36.54) v6(192.95,37.1) v6(193.59,37.1) v6(194.22,37.1) v6(194.32,37.69) v6(222.92,57.17) v6(223.18,57.68) v6(223.3,56.66) v6(223.56,57.17) v6(224.15,57.2) v6(240.17,69.46)
+3VALW_1117: length 30.3
  TOP w0.102: v1(240.7,9.76) 240,10.46 RK5.2
  TOP w0.254: UK1.4 234.95,20.08 ; v6(238.71,12.26) 238.62,12.34 UK1.37 ; UK1.24 229.34,12.34 v2(228.75,11.75)
  TOP w0.356: v6(234.85,21) 234.95,20.89 234.95,20.08 CK8.1
  TOP w0.508: RK5.2 239.75,11.19 CK10.1 239.24,11.73 v6(238.71,12.26)
  IN1 w0.508: v6(238.71,12.26) 238.39,11.94 233.85,11.94 233.6,11.69 228.82,11.69 v2(228.75,11.75)
  IN2 w0.508: v6(234.85,21) 234.85,19.65 239.27,15.23 239.27,12.62 238.91,12.26 v6(238.71,12.26)
+3VALW_PD_A: length 8.6
  TOP w0.381: RT149.2 CT171.1
  TOP w0.508: RT145.2 RT149.2
  IN1 w0.381: v2(29.04,69.18) v4(28.59,69.18) ; v2(29.15,65.83) 29.15,65.87 v4(29.39,66.11)
  IN2 w0.508: v4(28.59,69.18) 29.5,69.18 29.86,68.81 29.86,67.8 29.58,67.53 29.58,66.31 29.38,66.11 v4(29.39,66.11)
  IN3 w0.203: v4(28.59,69.18) 28.5,69.18 28.26,69.42 v5(28.23,69.42)
  IN3 w0.381: v5(28.98,66.11) v4(29.39,66.11)
  BOTTOM w0.203: v5(28.98,66.11) 28.92,66.11 28.62,66.42 UT1.H1
+3VALW_PD_B: length 13.3
  TOP w0.127: RT146.2 29.23,78.01 29.49,78.26 30.95,78.26 v1(31.41,77.81)
  TOP w0.508: CT183.1 RT161.2 RT146.2
  IN1 w0.254: v2(29.14,73.1) 29.37,73.1 v4(29.46,73.01)
  IN1 w0.508: v4(28.96,76.36) 29.04,76.28 v2(29.36,76.28)
  IN2 w0.508: v4(29.46,73.01) 30.66,73.01 31.17,73.51 31.17,74.63 29.44,76.36 v4(28.96,76.36)
  IN3 w0.254: v4(29.46,73.01) 29.19,73.01 29.14,73.05 v5(29.06,73.05)
  IN3 w0.508: v5(28.6,76.44) 28.67,76.36 v4(28.96,76.36)
  BOTTOM w0.254: UT5.H1 28.67,73.43 29.05,73.05 v5(29.06,73.05) ; UT5.B1 28.59,76.43 v5(28.6,76.44)
+3VALW_QV6: length 2.3
  TOP w0.127: QV6.3 64.27,62.41 63.25,63.43 RV45.2
+3VALW_TPM: length 4.2
  TOP w0.102: CZ16.1 v1(43.39,27.37)
  TOP w0.254: RZ34.2 42.59,28.59 CZ16.1 43.39,29.19 CZ15.1 43.57,29.37 UZ6.1
+3VALW_USH: length 1.7
  TOP w0.127: v1(271.51,18.62) 271.06,18.16 v6(271.06,18)
  TOP w0.508: RB36.2 271.06,17.21 v6(271.06,18)
+3VALWP: length 18.2
  TOP w0.102: v6(192.94,43.15) v3(192.19,43.15)
  IN1 w0.254: v6(192.94,43.15) 194.18,41.9 194.18,39.53 195.54,38.17 197.69,38.17 202.14,42.63 v6(202.14,43.15)
  BOTTOM w0.254: PR302.1 PC310.2 203.01,42.59 202.45,43.15 v6(202.14,43.15)
+3VS: length 737.1
  TOP w0.254: v2(253.88,54.92) 254.18,55.22 254.18,56.27 254.7,56.79 RE1.2 ; RC564.1 104.35,31.11 104.35,29.88 ; RC564.1 RC62.1 ; RC564.1 RC547.2 ; v2(53.13,66.07) 53.13,66.13 52.81,66.46 RC87.2 ; RC65.1 104.24,28.68 104.15,28.77 v2(104.15,28.82) 104.15,28.86 104.35,29.07 104.35,29.88 ; 104.35,29.88 104.37,29.86 RC58.1 RC530.1 105.61,29.86 106.27,30.52 106.59,30.52 RC620.2 106.65,30.31 107.01,29.95 RC38.2 ; RC555.2 105.62,42.77 105.17,43.22 RC556.2 104.77,43.39 v2(104.74,43.43) 104.43,43.43 102.95,44.91 102.95,45.79 103.19,46.03 104.14,46.03 105.03,45.14 107.8,45.14 108.13,45.47 108.13,48.07 107.84,48.35 ; RC1.1 RC3.1 ; RC67.1 RC63.1 106.91,41.03 v2(106.87,41.06) ; RV54.1 247.18,42.68 v6(247.24,42.74)
  TOP w0.305: RV50.1 246.04,42.96 246.33,43.25 246.93,43.25 247.24,42.94 v6(247.24,42.74) ; RC519.2 60.81,66.1 59.69,64.98 58.41,64.98 57.95,64.53 57.08,64.53 v2(56.9,64.35)
  TOP w0.381: v2(105.88,48.35) 107.84,48.35 108.17,48.68 RC585.2 v6(112.89,48.68) ; v2(103.29,49.55) 102.67,49.55 102.36,49.86 RC3.1
  TOP w0.406: UC10.5 96.61,15.41 96.07,14.88 96.07,13.39 95.8,13.11 RC433.1 95.4,12.88 95.35,12.93
  TOP w0.508: QK3.2 239.93,13.75 240.55,14.37 240.55,15.79 240.05,16.29 QK4.2 239.63,19.91 v6(242.52,22.8) ; v6(231.04,44.27) v6(231.04,51.68) 231.04,61.26 v6(228.93,63.37) ; v6(264.58,20.85) 265.62,19.81 v2(265.62,14.85) 268.93,11.54 RA126.1 ; v6(214.21,37.56) 213.82,37.17 213.82,30.18 v6(214.69,29.32) ; 95.35,12.93 94.06,12.93 93.64,12.52 56.65,12.52 55.51,13.66 55.51,13.77 55.51,28.47 v6(55.45,28.53) ; v6(249.27,32.53) 249.27,35.45 247.45,37.28 v6(247.42,37.28) ; v6(117.21,39.26) 117.8,39.86 117.8,42.64 112.89,47.55 v6(112.89,48.68) ; RV95.1 50.51,72.89 50.21,72.6 50.21,71.28 49.48,70.54 v2(48.56,70.54) ; RM98.1 13.4,37.74 v2(12.97,37.31) ; v2(44.49,40.98) 47.24,40.98 48.36,39.87 RZ38.1 49,38.75 v2(49,37.91)
  IN1 w0.254: v2(48.56,70.54) 48.4,70.71 v4(48.25,70.71) ; v2(53.14,66.07) 53.32,66.14 v4(53.53,66.05) ; v2(291.11,38.94) 290.66,39.39 v4(286.42,39.39) ; v2(106.87,41.06) 106.87,41.29 106.61,41.55 106.1,41.55 105.7,41.95 105.07,41.95 104.99,41.88 ; v4(103.21,28.82) 103.29,28.9 104.08,28.9 v2(104.15,28.82) ; v4(46.34,70.89) 46.81,70.89 v2(46.95,70.75) ; v2(104.05,40.51) 104.33,40.79 104.74,40.79 104.99,41.04 104.99,41.88 ; 104.99,41.88 104.74,42.13 v2(104.74,43.43)
  IN1 w0.305: v4(56.54,64.43) 56.56,64.44 v2(56.9,64.35)
  IN1 w0.381: v4(103.16,49.13) 103.22,49.07 104.51,49.07 105.24,48.33 105.85,48.33 v2(105.88,48.35) ; v4(262.44,35.98) v2(261.86,35.98)
  IN1 w0.508: v6(111.78,13.9) 111.33,14.35 106.26,14.35 104.34,16.27 99.36,16.27 99.23,16.41 99.21,16.41 v4(98.77,16.86) ; v4(38.49,49.18) 41.21,49.18 41.81,48.58 41.81,46.95 42.14,46.62 42.14,44.59 42.76,43.96 42.76,42.04 43.82,40.98 v2(44.49,40.98) ; v4(277.19,45.92) 277.19,44.75 276.59,44.14 275.89,44.14 272.09,40.34 265.63,40.34 265.23,40.75 265.23,41.02 v2(264.98,41.26) 264.8,41.07 v4(264.32,41.07) ; v2(256.27,54.31) 254.49,54.31 v2(253.88,54.92) 248.53,54.92 246.76,53.16 v4(245.17,53.16) ; v2(265.62,14.85) 265.68,14.92 v2(267.25,14.92) ; v2(49,37.91) 49,37.18 49.92,36.26 50.26,36.26 52.68,33.84 52.68,29.76 ; v2(103.29,49.55) 103.29,49.26 v4(103.16,49.13)
  IN2 w0.254: v4(103.21,28.82) 103.32,28.93 103.81,28.93 104.13,28.62 104.13,28.44 104.37,28.2 104.84,28.2 105.15,28.52 105.73,28.52 107.43,26.82 108.06,26.82 108.62,26.26 v4(108.62,24.53)
  IN2 w0.508: 200.32,34.51 201.83,36.02 203.25,36.02 204.49,34.78 ; 204.13,34.11 203.59,34.11 203.21,33.72 201.19,33.72 201.08,33.84 199.9,33.84 ; v6(122.29,31.66) 122.29,32.84 120.69,34.44 118.22,34.44 116.88,35.78 116.88,38.93 v6(117.21,39.26) ; v6(231.04,51.68) 243.7,51.68 v4(245.17,53.16) ; v6(264.58,20.85) 264.32,21.1 258.93,21.1 254.48,25.55 254.48,26.11 253.84,26.74 253.84,26.75 253.81,26.79 253.81,32.12 253.4,32.53 v6(249.27,32.53) ; 286.82,40.42 286.82,41.94 284.49,44.27 278.84,44.27 v4(277.19,45.92) ; v6(214.21,37.56) 213.18,36.52 208.76,36.52 207.76,35.53 205.73,35.53 ; v6(247.42,37.28) 254.85,37.28 257.56,39.99 263.24,39.99 v4(264.32,41.07) ; v4(46.34,70.89) 45.46,70.89 44.09,69.51 44.09,66.81 41.2,63.93 41.2,62.93 40.41,62.13 40.41,59.74 40.43,59.72 40.43,56.9 40.06,56.52 40.06,54.48 38.43,52.85 38.43,51.45 38.81,51.07 38.81,49.49 v4(38.49,49.18) ; 288.07,39.77 289.34,39.77 295.35,45.78 299.77,45.78 301.56,47.57 301.56,61.82 301.98,62.24 v4(301.98,63.71) ; v6(201.18,58.16) 197.9,58.16 197.42,58.64 197.42,62.27 198.58,63.43 200.48,63.43 204.09,67.04 220.17,67.04 223.84,63.37 v6(228.93,63.37)
  IN3 w0.254: v4(205.09,34.23) 205.09,34.14 204.75,33.79 v5(204.7,33.79) ; v5(60.96,62.35) 60.96,62.35 60.96,63.82 62.16,65.02 62.16,65.66 61.53,66.3 60.23,66.3 58.77,64.83 ; v5(102.91,28.36) 102.91,28.39 103.21,28.7 v4(103.21,28.82)
  IN3 w0.381: v5(136.41,21.05) v5(135.04,22.42)
  IN3 w0.508: v4(46.34,70.89) 47.61,70.89 47.79,70.71 v4(48.25,70.71) 48.55,70.71 51.35,67.9 52.58,67.9 53.33,67.15 53.33,66.25 v4(53.53,66.05) 53.74,66.26 54.37,66.26 v5(54.6,66.03) ; 231.06,44.24 246.28,44.24 247.24,43.27 v6(247.24,42.74) ; 231.06,44.24 v6(231.04,44.27) ; 231.06,44.24 227.99,44.24 223.85,40.1 218.45,40.1 216.07,37.72 214.37,37.72 v6(214.21,37.56) ; v5(189.29,15.45) 200.05,15.45 202.04,17.44 208.48,17.44 211.73,20.69 212.63,20.69 v5(214.3,22.35) ; 58.77,64.83 57.35,64.83 56.95,64.43 v4(56.54,64.43) 56.38,64.59 v5(56.38,66.03) ; v4(98.77,16.86) 99.01,17.1 v5(99.01,21.02) 99.47,21.02 v4(99.67,20.82) ; v4(264.32,41.07) 264.32,41 262.46,39.13 262.46,36 v4(262.44,35.98) ; v4(301.98,63.71) v5(301.98,64.29)
  BOTTOM w0.254: v5(102.91,28.36) 102.67,28.61 RC518.1 RC545.2 101.97,28.76 101.97,26.73 101.09,25.85 RC548.2 ; v5(17.17,21.72) v5(17.17,22.35) ; RC488.2 119.27,32.12 QC1.5 120.25,32.12 120.51,31.87 121.07,31.87 121.32,32.12 QC1.2 122.32,32.12 RC489.2 ; UC2.5 99.22,20.84 CC239.1 ; RC516.2 110.31,58.5 110.06,58.25 v6(109.7,58.25)
  BOTTOM w0.356: RC7.1 105.93,58.55 RC5.1
  BOTTOM w0.381: RC546.2 RC545.2 ; v6(122.29,31.66) 122.4,31.78 RC489.2 ; RE241.1 56.08,29.64 55.57,29.14 55.57,28.66 v6(55.45,28.53) ; RC618.2 117.58,27.92 v6(117.6,27.9) ; v6(105.47,59.08) 105.85,58.7 RC7.1
  BOTTOM w0.508: v5(214.3,22.35) 214.3,28.93 v6(214.69,29.32) ; v5(204.7,33.79) 203.92,33.01 203.92,29.86 203.67,29.61 R23.1 R24.1 ; v5(189.29,15.45) 189.29,13.93 188.16,12.79 R275.1 ; v6(247.42,37.28) 247.42,42.56 v6(247.24,42.74) ; v5(56.38,66.03) v5(54.6,66.03) ; v6(201.18,58.16) 201.18,58.81 200.79,59.2 R139.1 R140.1 ; v5(135.04,22.42) 135.04,23.03 135.57,23.56 RV94.1 ; v6(111.78,13.9) 114.72,16.83 121.52,16.83 123.46,18.78 131.88,18.78 132.69,19.59 134.27,19.59 134.6,19.92 135.28,19.92 v5(136.41,21.05) 138.43,23.07 147.91,23.07 150.57,21.84 150.63,21.81 150.83,21.75 153.66,20.81 155.78,20.34 156.23,20.24 158.89,19.83 159.04,19.78 160.4,19.59 160.65,19.52 162.21,19.33 162.46,19.29 162.47,19.3 163.12,19.22 164.72,19.14 174.36,19.14 185.55,30.33 188.36,30.33 190.64,32.6 ; 228.93,71.36 v6(228.93,63.37)
  vias: v2(17.15,22.36) v2(17.16,21.99) v2(17.56,22.25) v2(17.55,21.94) v2(18.68,25.28) v2(18.69,24.98) v2(18.98,25.28) v2(18.98,24.98) v2(21.64,61.46) v2(21.71,61.19) v2(21.95,61.46) v2(21.98,61.18) v2(31.9,27.84) v2(31.9,27.55) v2(32.27,27.84) v2(32.29,27.53) v2(37.54,27.9) v2(37.84,27.9) v2(38.14,27.89) v2(38.43,27.89) v2(41.57,31.16) v2(45.33,28.58) v2(204.51,33.42) v2(204.68,33.78) v2(204.88,33.96) v2(285.96,39.41) v2(285.96,39.16) v2(285.96,38.91) v3(203.47,33.7) v4(12.53,44.7) v4(12.92,45.04) v4(13.43,37.62) v4(13.44,37.02) v4(16.84,21.37) v4(16.93,63.47) v4(17.31,21.37) v4(17.51,63.46) v4(19.72,25.77) v4(19.73,25.34) v4(21.33,61.64) v4(21.82,61.81) v4(31.84,27.03) v4(32.29,27.05) v4(37.4,28.42) v4(38.06,28.42) v4(44.82,28.58) v4(52.93,29.05) v4(205.37,35.1) v4(205.4,34.59) v4(285.55,39.2) v4(286.42,38.88) v5(11.99,41.61) v5(12,41.33) v5(12.26,41.58) v5(12.28,41.28) v5(12.89,37.78) v5(12.89,37.52) v5(12.88,37.26) v5(13.16,37.81) v5(17.17,23.32) v5(18.91,25.41) v5(18.96,25.86) v5(19.28,25.85) v5(19.28,25.4) v6(191.6,33.84) v6(192.16,33.84)
+3VS_ALS: length 6.3
  BOTTOM w0.127: RV94.2 136.25,25.74 v3(136.89,25.1)
  BOTTOM w0.508: JCAM1.8 134.15,22.24 134.4,22.5 134.4,23.39 134.71,23.69 134.71,25.32 135.13,25.74 RV94.2
+3VS_AUDIO: length 70.1
  TOP w0.508: RA115.2 265.34,35.45 v2(266.04,35.45) ; RA9.1 275.96,24.49 275.53,24.06 275.53,22.37 276.99,20.9 v3(276.99,20.12) 276.99,19.42 277.98,18.43 v2(279.37,18.43) RA14.1
  IN1 w0.508: v2(296.52,16.11) v4(296.02,16.11) ; v2(266.04,35.45) 265.12,35.45 v4(265.09,35.48) ; v4(276.2,25.64) 276.2,25.08 276.18,25.07 276.18,25 v2(275.84,24.66) ; v2(279.37,18.43) 279.37,17.27 282.8,13.84 285.36,13.84 v4(286.24,12.95)
  IN2 w0.508: v4(276.2,25.64) 276.2,25.64 276.2,25.85 274.1,27.95 271.88,27.95 271.42,27.5 260.36,27.5 256.28,31.58 256.28,33.41 258.02,35.15 258.03,35.15 258.08,35.2 260.72,35.2 261.39,35.87 261.39,36.05 261.99,36.65 263.93,36.65 v4(265.09,35.48)
  IN3 w0.508: v4(286.24,12.95) 290.38,17.09 294.33,17.09 295.31,16.11 v4(296.02,16.11)
+3VS_AUDIO_R: length 2.1
  TOP w0.102: v1(263.89,40.3) 263.89,40.04 265.03,38.9 UA8.8
+3VS_CAM: length 157.2
  TOP w0.508: v3(43.86,55.82) 44.8,55.82 45.63,56.65 v3(45.63,57.03) CV33.1 CV32.1 CV34.1 47.42,58.15 CV31.1 48.73,57.98 RV76.2 48.73,57.17 49.88,56.02 51.41,56.02 v3(52.11,56.72) 52.87,57.48 v2(52.87,57.79)
  IN1 w0.508: v4(98.03,11.94) 96.38,13.59 v4(96.38,14.03) ; v4(53.61,58.72) 53.61,58.53 v2(52.87,57.79)
  IN2 w0.508: v4(53.61,58.72) 53.61,60.11 52.84,60.88 50.85,60.88 49.9,59.93 49.9,56.63 51.56,54.97 51.56,40.02 52.21,39.38 53.07,39.38 53.47,38.98 53.47,36.13 56.92,32.67 56.92,31.13 57.67,30.38 59.12,30.38 59.73,30.99 68.78,30.99 69.19,31.4 72.23,31.4 74.28,29.35 84.58,29.35 86.13,30.9 91.59,30.9 93.14,29.35 93.95,29.35 95.47,27.83 95.47,22.52 v4(96.06,21.94)
  IN3 w0.254: v4(53.61,58.72) 53.62,58.73 54.19,58.73 v5(54.19,58.73)
  IN3 w0.508: v4(96.06,21.94) 95.55,21.43 95.55,17.23 95.82,16.96 95.82,14.59 v4(96.38,14.03) ; v5(109.84,12.16) 109.84,11.78 109.14,11.08 98.89,11.08 v4(98.03,11.94) ; v5(123.74,22.57) 123.74,22.28 125.2,20.82 v5(125.2,19.55)
  BOTTOM w0.508: v5(125.2,19.55) 123.34,19.55 121.25,17.47 114.46,17.47 110.76,13.77 110.76,12.54 110.37,12.16 v5(109.84,12.16) ; v5(123.74,22.57) 123.74,23.01 124.99,24.26 129.26,24.26 130.98,22.54 JCAM1.9
+3VS_CAM_Q: length 21.2
  TOP w0.508: v2(60.45,56.57) v1(59.65,57.37) 58.79,58.23 54.01,58.23 53.34,58.89 52.2,58.89 51.7,58.39 51.7,57.51 50.83,56.65 50.15,56.65 49.8,57 49.8,58.84 49.16,59.48 RV76.1
  IN1 w0.508: v2(60.45,56.57) 61.16,56.57 v4(61.17,56.56)
  IN3 w0.508: v4(61.17,56.56) 61.43,56.56 v5(61.66,56.78)
  BOTTOM w0.508: v5(61.66,56.78) 61.95,57.07 61.95,59.7 QV1.1
+3VS_CR: length 7.8
  TOP w0.203: 293.69,38.03 UR1.27
  TOP w0.356: RR9.1 291.69,39.84 v6(291.93,40.08) ; CR4.1 293.06,39.59 RR11.2
  TOP w0.381: 293.69,38.03 293.5,38.23 293.5,39.29 293.61,39.4 CR4.1 293.61,39.86 293.92,40.16 293.92,40.38 CR3.1
  TOP w0.508: CR1.1 291.69,32.02 v2(291.57,31.9) ; v6(293.14,40.39) CR3.1
  IN1 w0.508: v6(291.93,40.08) 292.24,40.39 v6(293.14,40.39) ; v2(291.57,31.9) 291.57,32.21 v4(291.54,32.23)
  vias: v3(283.44,40.95) v6(284.24,41.29) v6(284.24,40.71) v6(284.82,41.29) v6(284.82,40.71)
+3VS_CR_R: length 0.6
  TOP w0.102: v1(287.06,36.63) 286.65,36.63 286.51,36.77
+3VS_R: length 1.1
  TOP w0.102: 199.52,33.88 v3(199.52,34.93)
+3VS_SENSOR: length 17
  TOP w0.127: v1(49.67,76.65) 49.74,76.65 50.51,75.89 RV95.2
  TOP w0.381: RV95.2 50.51,75.51 51.12,74.9 v2(52.16,74.9)
  IN1 w0.381: v2(52.16,74.9) 52.08,74.97 v4(51.68,74.97)
  IN2 w0.381: v4(50.05,75.3) 50.05,75.2 50.28,74.97 v4(51.68,74.97)
  IN3 w0.381: v5(41.12,76.09) 41.12,75.98 41.35,75.75 49.6,75.75 v4(50.05,75.3)
  BOTTOM w0.203: JEDP1.23 40.83,77.09 41.22,76.69 41.22,76.31 41.12,76.21 v5(41.12,76.09)
+3VS_SSD_R: length 2.1
  TOP w0.102: v1(222.49,58.6) 223.81,59.92 U8.8
+3VS_TP: length 25.7
  TOP w0.127: v6(189.29,18.13) v3(188.28,18.13)
  IN3 w0.508: v5(198.21,21.16) v5(197.4,21.16) 197.33,21.1 v5(194.16,21.1) 194.16,20.31 193.74,19.89 v5(193.66,19.89) v5(191.86,19.89)
  BOTTOM w0.254: Q13.2 194.28,21.22 v5(194.16,21.1) ; 197.78,19.2 197.75,19.23 197.75,20.25 RP15.1 198.03,20.64 198.21,20.82 v5(198.21,21.16) ; 197.78,19.2 Q3.2 ; 197.78,19.2 Q3.5 ; v5(197.4,21.16) 197.34,21.22 Q13.5 ; JTP1.1 191.12,19 191.26,19.13
  BOTTOM w0.508: R275.2 188.95,11.88 190.74,13.67 190.74,16.68 v6(189.29,18.13)
+3VS_TP_R:
  vias: v1(186.74,17.49)
+3VS_TPM: length 4
  TOP w0.102: RZ18.2 v1(46.28,27.43)
  TOP w0.254: RZ18.2 CZ17.1 47.18,28.7 CZ18.1 47.07,29.46 UZ6.8
+3VS_TS: length 14
  IN1 w0.254: v4(41.82,76.52) 41.81,76.53 41.34,76.06 v2(41.34,75.98)
  IN1 w0.381: v4(47.26,76.26) 47.56,76.26 47.69,76.38 v2(48,76.38)
  IN2 w0.508: v4(41.82,76.52) 41.82,75.62 41.06,74.86 38.96,74.86 37.22,76.6 v6(37.22,76.94)
  IN3 w0.508: v4(41.82,76.52) 42.08,76.26 v4(47.26,76.26)
  vias: v1(41,74.26)
+3VS_TS_R: length 1.4
  TOP w0.102: 46.72,73.39 46.06,72.73 v1(46.06,72.22)
+3VS_UN5: length 3.6
  TOP w0.127: RN85.1 262.13,37.14 RN83.1 RN84.1 260.35,36.8 CN58.1 UN5.5
+3VS_USH: length 3.2
  TOP w0.508: v2(268.01,18.81) 267.75,18.81 v1(267.27,18.33) RB38.2
  IN1 w0.508: v4(268.54,18.84) 268.52,18.81 v2(268.01,18.81)
  IN3 w0.508: v5(269.06,18.84) v4(268.54,18.84)
