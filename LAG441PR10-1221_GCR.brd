# Allegro board LAG441PR10-1221_GCR.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HDMI_TX_P0: length 1.5
  TOP w0.112: CM16.2 17.59,36.3 17.39,36.3 RM102.1 17,36.29 16.8,36.29 RM36.1
HDMI_TX_P1: length 1.5
  TOP w0.112: RM39.1 16.81,29.11 17.04,29.11 RM104.1 17.43,29.15 17.62,29.15 CM14.2
HDMI_TX_P2: length 1.4
  TOP w0.112: CM6.2 17.63,26.59 17.41,26.59 RM106.1 17.03,26.59 16.83,26.59 RM42.1
HOST_DEBUG_TX: length 52.5
  TOP w0.102: UE1.G11 v2(270.64,56.41)
  TOP w0.127: v6(233.07,70.3) 232.57,70.8 RE92.2 RE96.2 231.37,72.04 v1(231.02,71.7)
  IN1 w0.061: v2(270.64,56.41) 270.51,56.54 269.84,56.54 268.87,57.51 268.87,59.85 268.1,60.62 268.1,60.94 267,62.04 264.32,62.04 263.97,62.39 263.97,62.83 263.16,63.65 258.3,63.65 257.9,64.05 256.02,64.05 255.22,63.26 251.62,63.26 248.96,65.92 246.21,65.92 240.96,71.18 233.46,71.18 233.07,70.78 v6(233.07,70.3)
  BOTTOM w0.127: JDEG1.8 233.63,71.54 233.07,70.99 v6(233.07,70.3)
HOST_SD_WP#: length 215.5
  TOP w0.127: v1(107.73,31.48) RC38.1 107.31,30.54 107.22,30.45 v6(107.22,30.45)
  IN1 w0.061: v4(217.04,29.88) 217.04,29.74 217.37,29.41 217.8,29.41 218.46,30.07 219.58,30.07 220.68,31.16 225.87,31.16 226.49,30.53 230.29,30.53 231.06,29.76 231.06,27.43 234.55,23.94 250.94,23.94 251.93,24.93 253.12,24.93 253.95,25.76 253.95,27.15 254.99,28.19 259.01,28.19 261.89,31.08 268.27,31.08 268.53,31.34 270.19,31.34 273.46,34.6 281.77,34.6 283.41,36.24 283.41,38.16 285.28,40.02 288.44,40.02 290.24,41.82 v2(290.67,41.82)
  IN2 w0.061: v6(107.22,30.45) 107.68,30.45 107.99,30.14 110.83,30.14 115.86,25.11 116.33,25.11 118.58,22.86 125.46,22.86 125.92,23.32 127.89,23.32 128.41,23.84 139.88,23.84 141.66,22.06 144.18,22.06 148.45,17.8 154.21,17.8 154.48,17.53 177.31,17.53 189.39,29.61 197.98,29.61 198.34,29.25 212.95,29.25 213.6,29.91 213.93,29.91 217.01,29.91 v4(217.04,29.88)
  BOTTOM w0.127: UCPU1.CH35 105.64,33.86 105.93,33.57 105.93,32.61 106.87,31.67 106.87,30.8 v6(107.22,30.45)
HPOL_CONN: length 12.8
  TOP w0.381: LA3.2 293.94,24 v1(294.78,24.83) 294.93,24.99 CA47.1 295.54,25.8 DA5.2 v6(296.45,25.58)
  IN2 w0.381: JHP1.1 303.25,22.74 301.54,24.45 297.58,24.45 v6(296.45,25.58)
HPOR_CONN: length 21.2
  TOP w0.381: v6(299.61,15.68) 299.57,15.64 CA46.1 299.06,15.32 299.27,15.11 DA4.2 299.43,14.75 v1(300.48,13.7) 302.47,11.7 307.93,11.7 JHP1.2
  IN1 w0.381: v2(293.94,19.32) 294.32,18.94 298.74,18.94 299.61,18.07 v6(299.61,15.68)
HPOUT-L: length 12.8
  TOP w0.203: v6(287.98,20.97) 287.64,21.31 v1(287.64,21.75) 287.64,21.97 286.99,22.62 UA1.27
  TOP w0.381: CA9.1 288.61,20.34 v6(287.98,20.97) ; v6(290.36,25.62) 290.79,26.05 CA42.2
  IN1 w0.381: v6(287.98,20.97) 288.58,21.57 288.58,23.98 290.23,25.62 v6(290.36,25.62) 290.83,25.62 291.31,25.14 v2(291.31,23.77)
HPOUT-L_L: length 1.7
  TOP w0.381: CA45.1 292.45,24.26 292.23,24.03 RA30.2 LA3.1
HPOUT-R: length 12.5
  TOP w0.203: UA1.26 286.93,22.22 287.23,21.91 287.23,20.92 v1(287.71,20.44) 288.37,19.78 v6(288.37,19.73)
  TOP w0.381: v6(290.4,24.85) CA43.2 ; RA31.1 290.69,20.21 289.47,19.7 CA8.1 288.4,19.7 v6(288.37,19.73)
  IN1 w0.381: v6(288.37,19.73) 288.38,19.73 289.41,20.76 289.41,23.85 v6(290.4,24.85)
HPOUT-R_L: length 2.1
  TOP w0.381: LA4.1 293.09,19.4 292.42,20.07 CA44.1 291.77,20.34 RA31.2
HRESET_PD1: length 1.3
  TOP w0.127: RT160.1 25.69,68.3 25.99,68.01 26.05,68.01 v2(26.06,68.01)
  IN1 w0.061: v2(26.06,68.01) 25.86,68.09 v4(25.73,68.09)
  IN3 w0.061: v5(25.73,68.42) v4(25.73,68.09)
HRESET_PD2: length 1
  IN1 w0.061: v2(25.71,75.68) 25.94,75.9 25.94,75.92 25.94,75.92 25.94,75.92 v4(25.95,75.92)
  IN3 w0.061: v5(25.73,75.43) 25.73,75.67 25.82,75.77 25.82,75.86 25.88,75.92 25.94,75.92 25.94,75.92 v4(25.95,75.92)
I2C1_SCK_TP: length 108.3
  TOP w0.127: v2(194.05,21.74) 193.78,21.74 193.38,21.34 193.38,21.11 192.71,20.44 182.44,20.44 179.14,17.14 153.24,17.14 140.28,21.16 131.48,29.96 130.07,29.96 127.92,32.11 126.77,32.11 126.67,32.01 126.39,32.01 126.3,32.1 126.3,32.11 125.64,32.77 124.7,32.77 124.04,32.11 123.12,32.11 123.07,32.06 v2(123.07,31.97)
  IN1 w0.061: v4(106.67,48.66) 107.05,49.04 107.43,49.04 107.68,48.79 107.68,48.42 108.13,47.97 108.61,47.97 109.27,47.31 109.27,47.1 110.16,46.21 110.16,45.01 110.83,44.34 110.83,42.63 111.34,42.12 111.34,38.17 114.77,34.74 115.36,34.74 117.61,32.48 119.94,32.48 120.16,32.26 122.84,32.26 123.07,32.02 v2(123.07,31.97) ; v4(193.66,21.74) v2(194.05,21.74)
  IN3 w0.061: v4(193.66,21.74) 193.55,21.62 193.55,21.13 v5(193.59,21.1)
  IN3 w0.076: v5(106.44,48.43) v4(106.67,48.66)
I2C1_SDA_TP: length 107.4
  TOP w0.127: v2(192.73,21.74) 193.1,21.37 193.1,21.19 192.6,20.7 182.34,20.7 179.03,17.39 153.27,17.39 140.42,21.38 131.58,30.21 130.18,30.21 128.03,32.36 v1(126.53,32.36) 126.4,32.36 125.74,33.03 124.59,33.03 123.93,32.36 123.02,32.36 122.69,32.04 v2(122.69,31.97)
  IN1 w0.061: v2(192.73,21.74) v4(193.12,21.74) ; v2(122.69,31.97) 122.69,32.01 122.64,32.07 120.08,32.07 119.86,32.29 117.54,32.29 115.28,34.55 114.7,34.55 111.15,38.09 111.15,42.04 110.64,42.55 110.64,44.26 109.97,44.93 109.97,46.13 109.08,47.02 109.08,47.24 108.53,47.79 108.05,47.79 107.32,48.51 v4(107.32,48.66)
  IN3 w0.061: v5(192.82,21.55) 192.83,21.54 192.92,21.54 v4(193.12,21.74)
  IN3 w0.076: v5(107.09,48.43) v4(107.32,48.66)
  BOTTOM w0.127: RP14.1 191.87,21.23 192.2,21.55 v5(192.82,21.55)
I_ADP: length 309.9
  TOP w0.127: v2(270.64,60.42) 270.64,60.42 270.64,60.41 ; PR234.1 29.13,10.14 29.27,10.28 29.27,11.33 30.37,12.44 35.94,12.44 36.59,11.79 39.53,11.79 40.25,12.5 40.25,14.84 39.22,15.87 38.29,15.87 36.91,17.25 v1(36.91,18.03) v2(36.91,18.63)
  IN1 w0.061: v2(36.91,18.63) 36.88,18.65 v4(36.88,19.28) ; v2(270.64,60.42) 270.7,60.48 272.63,60.48 273.76,61.61 273.76,62.03 274.62,62.88 277.52,62.88 281.04,59.36 281.04,51.54 272.73,43.22 252.22,43.22 v4(252.17,43.27)
  IN2 w0.061: v4(252.17,43.27) 252.17,43.11 250.43,41.37 237.68,41.37 219.51,23.2 214.64,23.2 211.26,19.82 183.65,19.82 178.5,14.67 153.29,14.67 153.02,14.94 147.26,14.94 143.02,19.17 128.81,19.17 127.02,19.9 122.93,19.9 122.45,19.42 113.41,19.42 108.85,14.86 105.31,14.86 104.16,16.01 101,16.01 99.84,14.85 97.51,14.85 97.39,14.97 89.97,14.97 89.48,15.47 53.12,15.47 53.05,15.4 49.05,15.4 46.58,17.86 40.73,17.86 39.31,19.28 v4(36.88,19.28)
I_BATT: length 273.1
  TOP w0.127: PR233.1 28.3,9.62 29.08,9.62 29.54,10.09 29.54,11.24 30.48,12.18 35.84,12.18 36.48,11.54 39.74,11.54 v1(40.1,11.89) 40.5,12.29 40.5,14.95 39.33,16.12 38.39,16.12 37.24,17.28 37.24,18.91 v2(37.2,18.94) ; RE123.2 259.88,48 261.67,46.21 261.67,45.21 v2(261.07,44.61)
  IN1 w0.061: v2(37.2,18.94) 37.23,18.97 v4(37.23,19.66) ; v2(261.07,44.61) 260.85,44.83 v4(260.65,44.83)
  IN2 w0.061: v4(37.23,19.66) 37.47,19.41 39.36,19.41 40.78,17.99 46.63,17.99 49.1,15.52 52.99,15.52 53.06,15.59 90.93,15.59 91.39,15.13 97.41,15.13 97.56,14.98 99.79,14.98 100.94,16.14 104.21,16.14 105.36,14.99 108.8,14.99 113.36,19.55 122.4,19.55 122.87,20.02 127.05,20.02 128.83,19.3 143.08,19.3 147.31,15.06 153.07,15.06 153.34,14.8 178.45,14.8 183.59,19.95 211.21,19.95 214.59,23.32 219.45,23.32 237.63,41.5 250.27,41.5 251.79,43.02 251.79,43.44 252.19,43.85 253.04,43.85 253.59,44.41 255.68,44.41 256.3,45.03 260.46,45.03 v4(260.65,44.83)
I_BATT_R: length 11.5
  TOP w0.127: v2(260.49,50.82) 260.49,50.78 CE18.1 259.88,50.17 RE123.1
  IN1 w0.061: v2(265.05,54.81) 265.49,54.81 266.46,53.84 266.46,53.31 265.24,52.09 264.76,52.09 264.42,52.43 263.91,52.43 263.09,51.61 262.68,51.61 261.69,50.62 260.68,50.62 v2(260.49,50.82)
I_SYS: length 330.5
  TOP w0.127: v2(38.62,59.4) 38.62,59.15 39.04,58.73 PR934.1
  TOP w0.254: PR232.1 29.44,12.95 v2(29.44,13.57)
  IN1 w0.061: v2(29.44,13.57) 32.26,13.57 36.54,17.84 v4(36.54,18.91) ; v2(38.62,59.4) 38.62,59.74 v4(38.56,59.8) ; v4(268.28,51.96) 267.42,51.1 265.71,51.1 265.46,51.35 264.14,51.35 264.03,51.46 263.31,51.46 263.2,51.35 262.77,51.35 261.44,50.02 258.38,50.02 v2(257.82,50.58)
  IN2 w0.061: v4(268.28,51.96) 268.13,51.81 268.13,49.04 267.23,48.14 267.23,45.99 265.55,44.3 263.67,44.3 263.62,44.25 260.42,44.25 260.03,44.65 256.5,44.65 255.85,44 253.75,44 250.73,40.98 237.83,40.98 219.65,22.8 214.8,22.8 211.43,19.44 183.8,19.44 178.66,14.29 153.13,14.29 152.86,14.56 147.07,14.56 144.36,17.27 133.76,17.27 132.11,18.92 128.76,18.92 126.97,19.64 123.03,19.64 122.56,19.17 113.53,19.17 108.96,14.6 104.43,14.6 103.15,15.89 101.05,15.89 99.87,14.71 97.47,14.71 97.33,14.85 89.92,14.85 89.43,15.34 53.17,15.34 53.1,15.27 48.99,15.27 46.53,17.74 40.67,17.74 39.4,19.01 37.8,19.01 37.7,18.91 v4(36.54,18.91) 34.53,18.91 29.01,24.43 29.01,29.26 29.31,29.56 29.31,34.76 31.93,37.39 31.93,39.41 31.93,39.59 33.38,41.05 33.38,42.87 36.11,45.6 36.11,48.65 36.37,48.92 36.37,53 36.65,53.28 36.65,53.87 37.36,54.58 37.36,58.6 v4(38.56,59.8)
I_SYS_R: length 15.4
  TOP w0.127: v1(256.72,49.13) 257.25,49.66 RE125.1 258.22,50.06 RE148.1 258.52,49.47 258.7,49.29 CE19.1 v2(258.99,50.31)
  IN1 w0.061: v2(265.86,54.82) 265.91,54.82 266.61,54.11 266.61,53.29 265.26,51.94 264.74,51.94 264.37,52.31 263.96,52.31 263.14,51.49 262.73,51.49 261.66,50.42 259.05,50.42 258.99,50.36 v2(258.99,50.31)
IA1_B+: length 40.5
  TOP w0.508: PR900.1 41.14,61.59 v6(41.61,61.59)
  IN2 w0.508: 70.9,74.06 69.58,75.38 65.62,75.38 64.41,74.17 64.41,73.32 62.49,71.4 57.34,71.4 56.85,71.89 51.84,71.89 51.11,71.16 49.06,71.16 48.98,71.24 48.98,71.27 47.94,71.27 47.64,70.96 47.64,70.56 46.72,69.64 45.84,69.64 45.24,69.04 45.24,68.41 45.9,67.75 45.9,67.12 45.31,66.53 45.06,66.53 42.09,63.56 42.09,62.55 41.61,62.06 v6(41.61,61.59)
  vias: v2(72.05,73.17) v2(73.38,73.26) v2(73.75,73.26) v2(74.05,73.26) v4(71.44,73.55) v4(71.92,73.55) v4(72.42,73.43) v4(72.94,73.42) v4(73.93,73.65) v4(74.42,73.63) v5(71.41,72.98) v5(71.79,72.98) v5(73.38,73.36)
IA2_B+:
  vias: v2(113.22,71.89) v2(113.51,71.89) v2(113.79,71.88) v2(114.08,71.86) v4(111.87,71.79) v4(112.55,71.76) v5(111.53,71.77) v5(112.22,71.77) v5(112.88,71.77)
ILMT_1.0V: length 3.1
  BOTTOM w0.254: PU800.13 119.7,54.11 119.4,53.82 119.4,53.14 119.12,52.86 PR808.1 118.91,52.08 PR807.2
IMON_GT: length 2.7
  BOTTOM w0.203: PU900.22 49.71,57.29 PR941.2 50.14,58.55 PC910.2
IMON_IA: length 4
  BOTTOM w0.203: PU900.21 49.23,57.69 49.39,57.85 49.39,59.11 49.75,59.47 PC909.2 50.15,60.29 PR939.2
IMON_SA: length 2.6
  BOTTOM w0.203: PU900.23 50.09,56.89 PC911.2 50.14,56.84 PR942.2
IMVP_SMBCLK: length 342.5
  TOP w0.102: v2(267.41,57.23) 267.42,57.23 UE1.F7
  TOP w0.127: PR916.1 42.53,53.01 42.53,52.69 42.44,52.6 42.44,52.21 42.53,52.12 42.53,51.27 v2(42.37,51.1)
  IN1 w0.061: v4(268.21,63.8) 268.05,63.97 268.05,64.04 268.19,64.18 269.22,64.18 269.98,64.95 269.98,65.44 v2(270.12,65.58) ; v2(267.41,57.23) 267.23,57.41 v4(267.23,57.65) ; v4(42.37,51.45) v2(42.37,51.1)
  IN3 w0.061: v4(42.37,51.45) 42.57,51.66 42.57,51.92 39.98,54.52 39.98,55.96 41.17,57.15 41.17,59.8 40.53,60.44 40.53,66.18 41.2,66.85 41.2,68.03 40.06,69.17 40.06,71.75 40.59,72.28 40.59,73.47 41.75,74.64 49.07,74.64 49.52,74.2 51.17,74.2 52.29,73.08 59.54,73.08 59.93,72.69 61.71,72.69 63.02,74 63.02,75.55 64.08,76.61 68.73,76.61 70.9,74.44 76.27,74.44 76.66,74.06 76.66,72.38 77.52,71.52 77.52,69.38 77.32,69.18 77.32,68.55 79.04,66.82 80.36,66.82 84.66,62.52 88.25,62.52 91.56,65.83 100.18,65.83 102.16,67.82 108.38,67.82 108.82,67.37 112.18,67.37 117.17,62.38 117.17,61.01 119.67,58.51 119.67,56.84 120.09,56.42 120.09,53.2 121.76,51.53 124.65,51.53 125.46,52.34 126.12,52.34 126.75,51.72 126.75,50.56 127.44,49.86 127.44,48.94 129.21,47.17 130.14,47.17 131.09,46.22 131.09,45.73 129.9,44.54 129.9,42.04 133.13,38.82 139.45,31.12 140.03,30.5 141.09,29.42 arc(146.45,25.15) 152.68,22.3 154.72,21.66 158,21.03 159.35,20.9 164.72,20.9 165.93,21.04 166.86,21.19 168.63,21.55 170.97,22.17 171.2,22.24 172.23,22.61 173.13,22.98 174.05,23.34 174.64,23.61 176.23,24.41 177.72,25.31 177.92,25.44 179.4,26.4 180.59,27.24 180.76,27.37 181.16,27.73 181.17,27.74 181.81,28.32 185.03,31.55 186.95,32.56 187.13,32.69 187.95,33.45 189.93,35.43 193.58,35.43 194.29,36.14 195.06,36.14 198.83,39.9 199.46,39.9 202.62,43.06 202.62,63.51 203.97,64.86 205.02,64.86 207.16,67.01 213.13,67.01 213.96,66.19 245.2,66.19 249.53,61.86 262.9,61.86 264.45,63.42 266.48,63.42 267.38,64.32 267.82,64.32 268.04,64.1 268.04,63.97 v4(268.21,63.8) 268.04,63.63 268.04,63.46 266.81,62.22 266.81,59.17 266.67,59.04 266.67,58.68 266.81,58.54 266.81,58.07 v4(267.23,57.65)
IMVP_SMBDAT: length 339.1
  TOP w0.102: 266.64,60.41 266.73,60.41 v2(266.94,60.62)
  TOP w0.127: v2(42.98,51.12) 42.78,51.32 v1(42.78,52.36) 42.78,53.01 PR919.1
  IN1 w0.061: v4(266.35,60.78) 266.51,60.62 v2(266.94,60.62) ; v2(269.59,65.58) 269.79,65.38 269.79,65.03 269.14,64.37 268.11,64.37 267.85,64.11 267.85,63.97 v4(267.68,63.79) ; v4(42.95,51.47) 42.95,51.16 v2(42.98,51.12)
  IN3 w0.061: v4(42.95,51.47) 42.76,51.65 42.76,52 40.17,54.6 40.17,55.88 41.36,57.08 41.36,59.88 40.72,60.51 40.72,66.1 41.39,66.77 41.39,68.1 40.25,69.25 40.25,71.67 40.78,72.2 40.78,73.4 41.83,74.45 49,74.45 49.44,74.01 51.09,74.01 52.21,72.89 59.46,72.89 59.85,72.5 61.79,72.5 63.21,73.92 63.21,75.47 64.16,76.42 68.66,76.42 70.82,74.25 76.2,74.25 76.47,73.98 76.47,72.3 77.33,71.44 77.33,69.45 77.13,69.25 77.13,68.47 78.97,66.63 80.29,66.63 84.59,62.33 88.33,62.33 91.64,65.64 100.25,65.64 102.24,67.63 108.3,67.63 108.74,67.18 112.1,67.18 116.98,62.3 116.98,60.93 119.48,58.43 119.48,56.76 119.9,56.34 119.9,53.13 121.68,51.35 124.72,51.35 125.54,52.16 126.04,52.16 126.56,51.64 126.56,50.48 127.26,49.79 127.26,48.86 129.13,46.98 130.06,46.98 130.9,46.14 130.9,45.81 129.72,44.62 129.72,41.96 132.99,38.69 139.31,30.99 139.89,30.37 140.96,29.28 arc(146.35,24.99) 152.63,22.12 154.67,21.47 157.98,20.84 159.34,20.71 164.73,20.71 165.95,20.86 166.89,21.01 168.67,21.37 171.02,21.99 171.27,22.06 172.29,22.44 173.2,22.81 174.12,23.16 174.72,23.44 176.32,24.25 177.83,25.15 179.5,26.24 180.7,27.08 180.89,27.22 181.29,27.59 181.3,27.6 181.94,28.19 185.14,31.39 187.05,32.4 187.25,32.54 188.08,33.32 190,35.24 193.65,35.24 194.37,35.95 195.14,35.95 198.9,39.72 199.54,39.72 202.81,42.98 202.81,63.43 204.05,64.68 205.09,64.68 207.24,66.82 213.05,66.82 213.88,66 245.12,66 249.45,61.67 262.97,61.67 264.53,63.23 266.56,63.23 267.46,64.13 267.74,64.13 267.84,64.03 267.84,63.96 v4(267.68,63.79) 267.85,63.62 267.85,63.53 266.62,62.3 266.62,61 266.4,60.78 v4(266.35,60.78)
IMVP_VR_ADDR: length 2.4
  BOTTOM w0.203: PR931.2 47.62,54.07 PR930.2 47.92,54.9 47.59,55.23 PU900.25
IMVP_VR_IREF: length 3.4
  BOTTOM w0.127: PR936.2 50.15,54.69 v1(50.61,54.23)
  BOTTOM w0.203: PU900.24 48.82,56.49 50.12,55.2 PR936.2
IMVP_VR_ON: length 344.4
  TOP w0.102: RE499.1 267.44,49.52 UE1.N7
  TOP w0.127: R241.1 67.97,65.7 68.03,65.77 69.07,65.77 69.49,65.35 U10.1 70.7,65.35 70.92,65.13 70.92,63.97 71.62,63.27 71.62,60.88 67.94,57.2 62.15,57.2 60.79,55.84 59.11,55.84 57.56,57.39 54.46,57.39 v1(51.36,54.29) v2(50.11,53.04) ; v2(267.79,49.12) 267.45,49.46 RE499.1
  IN1 w0.061: v2(50.11,53.04) 50.11,52.92 49.27,52.08 45.34,52.08 44.78,51.52 44.64,51.52 43.34,50.21 37.03,50.21 v4(36.98,50.26) ; v4(267.26,49.14) 267.28,49.12 v2(267.79,49.12)
  IN2 w0.061: v4(36.98,50.26) 36.5,49.77 36.5,48.86 36.23,48.6 36.23,45.54 33.51,42.82 33.51,40.99 32.06,39.54 32.06,39.36 32.06,37.31 29.44,34.69 29.44,29.47 29.14,29.17 29.14,24.48 33.67,19.96 35.66,19.96 36.14,20.44 37.8,20.44 38.14,20.1 40.45,20.1 40.71,19.83 40.71,19.09 41.54,18.27 46.72,18.27 49.21,15.78 52.89,15.78 52.96,15.85 91.04,15.85 91.5,15.38 97.25,15.38 97.7,15.83 100.28,15.83 100.84,16.39 104.32,16.39 105.47,15.25 108.7,15.25 113.26,19.81 122.29,19.81 122.77,20.28 127.1,20.28 128.88,19.55 143.18,19.55 147.42,15.32 153.18,15.32 153.45,15.05 178.34,15.05 183.49,20.2 211.11,20.2 214.48,23.58 219.35,23.58 237.54,41.77 250.14,41.77 251.53,43.16 251.53,43.55 252.09,44.1 252.91,44.1 253.49,44.68 255.55,44.68 256.16,45.29 261.1,45.29 261.55,44.84 265,44.84 266.28,46.12 266.28,47.01 266.68,47.41 266.68,48.56 v4(267.26,49.14)
IMVP_VR_ON_EN: length 3.1
  BOTTOM w0.127: v1(40.05,56.04) 40.82,56.8 R243.2
  BOTTOM w0.203: R243.2 41.37,57.04 41.92,56.49 PU900.37
IMVP_VR_ON_P: length 46.1
  TOP w0.127: v1(62.37,67.94) 62.72,67.58 v2(62.83,67.58) ; v2(64.25,66.59) 64.45,66.39 U7.2 67.06,66.39 R242.1 R241.2 68.09,66.65 U10.4
  IN1 w0.061: v2(64.25,66.59) 64.15,66.59 v4(63.21,67.53) 62.88,67.53 v2(62.83,67.58)
  IN3 w0.061: v5(41.01,62.45) 41.01,65.83 41.83,66.66 41.83,68.32 44.82,71.3 48.44,71.3 51.49,68.25 52.92,68.25 53.37,67.8 58.82,67.8 59.09,68.07 59.09,68.36 59.3,68.57 59.71,68.57 59.89,68.38 61.28,68.38 61.58,68.09 62.02,68.09 62.42,67.69 63.04,67.69 v4(63.21,67.53)
  BOTTOM w0.127: R243.1 39.92,57.35 39.26,57.35 38.52,58.09 38.52,59.03 38.88,59.39 38.88,60.81 40.5,62.43 40.98,62.43 v5(41.01,62.45)
IMVP_VR_PE: length 5
  BOTTOM w0.127: v1(40.58,53.23) 41,53.65 PR937.2
  BOTTOM w0.203: 41,55.17 41.14,55.17 41.5,55.53 42.26,55.53 42.66,55.13 42.97,55.13 43.19,55.35 PU900.36
  BOTTOM w0.254: PR937.2 41,55.17 PR935.2
IMVP_VR_PG: length 92.8
  TOP w0.127: v1(94.75,12.4) v2(95.59,12.4) 96.2,12.4 96.38,12.58 RC433.2 96.61,13.11 UC10.1
  IN1 w0.061: v4(46.05,49.15) 46.32,49.15 47.88,47.59 47.88,40.52 48.57,39.83 50.32,39.83 52.71,37.43 52.71,35.95 55.38,33.28 55.38,30.05 55.99,29.44 55.99,28.2 55.85,28.05 55.85,25.31 55.4,24.86 55.4,13.04 56.73,11.71 94.9,11.71 v2(95.59,12.4)
  IN3 w0.061: v5(45.71,54.81) 45.71,53.08 46.42,52.36 46.42,50.86 46.05,50.49 v4(46.05,49.15)
  BOTTOM w0.127: v5(45.71,54.81) 45.59,54.93 PU900.30
IMVP_VR_PSYS: length 4.3
  TOP w0.127: PR934.2 39.98,59.64 PR932.2 40.86,59.65 PC905.2 41.71,59.67 v1(41.86,59.82) 42.14,60.1 v2(42.31,60.1)
  IN1 w0.061: v2(42.31,60.1) 42.79,60.1 v4(42.82,60.13)
  IN3 w0.061: v5(42.36,60.1) 42.8,60.1 v4(42.82,60.13)
IMVP_VR_SLP_S0#: length 6.7
  TOP w0.127: v1(38.91,53.8) 39.3,54.19 PR911.2 PR910.2 40.74,54.28 41.91,55.45 42.31,55.45 42.64,55.11 v2(43.11,55.11)
  IN1 w0.061: v2(43.11,55.11) 43.41,55.11 v4(43.44,55.15)
  IN3 w0.061: v5(43.25,54.87) 43.28,54.87 43.44,55.04 v4(43.44,55.15)
  BOTTOM w0.127: v5(43.25,54.87) 43.28,54.87 43.59,55.18 PU900.35
IMVP_VR_SMBCLK: length 4.5
  TOP w0.127: PR909.2 PR916.2 42.26,54.46 42.47,54.67 43.17,54.67 43.47,54.97 v2(44,54.97)
  IN1 w0.061: v2(44,54.97) 44.26,55.22 v4(44.26,55.25)
  IN3 w0.061: v4(44.26,55.25) 44.29,55.22 44.3,55.22 44.38,55.13 v5(44.38,54.9)
  BOTTOM w0.127: PU900.33 v5(44.38,54.9)
IMVP_VR_SMBDAT: length 3.7
  TOP w0.127: v2(44.74,54.97) 44.51,54.97 43.84,54.29 PR908.2 PR919.2
  IN1 w0.061: v2(44.74,54.97) 44.77,55 44.77,55.37 v4(44.78,55.38)
  IN3 w0.061: v5(44.79,54.92) 44.77,54.93 44.77,55.37 v4(44.78,55.38)
  BOTTOM w0.127: PU900.32 v5(44.79,54.92)
IMVP_VR_SVID_ALERT#: length 3.8
  TOP w0.127: PR926.2 45.98,54.43 v2(45.98,55.2) 45.71,55.47 v1(45.43,55.47)
  IN1 w0.061: v2(45.98,55.2) 45.99,55.2 45.99,55.76 v4(45.96,55.79)
  IN3 w0.061: v5(46.01,55) 45.97,55.03 45.97,55.78 v4(45.96,55.79)
  BOTTOM w0.127: PU900.29 45.99,55.02 v5(46.01,55)
IMVP_VR_SVID_ALERT#_R: length 1.6
  TOP w0.127: PR925.2 46.22,51.73 PR914.2 46.2,52.53 PR926.1
IMVP_VR_SVID_CLK: length 3.2
  TOP w0.127: PR923.2 47.75,55.05 v1(47.67,55.13) 47.55,55.25 v2(47.28,55.25)
  IN1 w0.061: v2(47.28,55.25) 47.04,55.49 v4(47.04,55.56)
  IN3 w0.061: v4(47.04,55.56) 46.7,55.21 46.7,55.03 v5(46.72,55.01)
  BOTTOM w0.127: PU900.27 46.79,55.07 v5(46.72,55.01)
IMVP_VR_SVID_CLK_R: length 1.7
  TOP w0.127: PR922.2 48.62,53.84 PR913.2 48.18,53.13 48.02,53.29 PR923.1
IMVP_VR_SVID_DATA: length 3.7
  TOP w0.127: PR928.2 46.99,54.59 v2(46.42,55.16) 46.42,55.74 v1(46.7,56.01)
  IN1 w0.061: v2(46.42,55.16) 46.41,55.16 v4(46.41,55.49)
  IN3 w0.061: v4(46.41,55.49) 46.41,55.07 46.37,55.02 v5(46.37,55)
  BOTTOM w0.127: v5(46.37,55) 46.38,55.02 PU900.28
IMVP_VR_SVID_DATA_R: length 1.5
  TOP w0.127: PR928.1 46.99,52.54 PR927.2 47.77,52.53 PR915.2
IMVP_VR_VDD18: length 2.8
  BOTTOM w0.203: PC901.1 45.49,54.07 PR901.1 46.33,54.13 47.19,54.99 PU900.26
IMVP_VR_VDD33: length 2.9
  BOTTOM w0.203: PU900.44 41.88,59.29 41.25,58.67 PC902.1
  BOTTOM w0.254: PC902.1 40.7,58.76 PR902.2
IMVP_VR_VINSEN: length 4
  TOP w0.127: PC900.1 39.13,60.43 PR905.1 40.89,60.43 PR900.2 42.05,60.45 v2(42.1,60.5)
  IN1 w0.061: v4(41.86,60.79) 42.1,60.55 v2(42.1,60.5)
  IN3 w0.061: v4(41.86,60.79) 42.09,60.56 v5(42.09,60.5)
  BOTTOM w0.127: PU900.47 42.1,60.49 v5(42.09,60.5)
IMVP_VR_VRHOT#: length 3.2
  TOP w0.127: PR912.2 45.43,54.21 PR920.2 44.65,54.38 v2(45.19,54.92)
  IN1 w0.061: v2(45.19,54.92) 45.19,55.13 v4(45.31,55.25)
  IN3 w0.061: v4(45.31,55.25) 45.19,55.13 v5(45.19,54.92)
  BOTTOM w0.127: PU900.31 v5(45.19,54.92)
INPUT3VSEL: length 2.4
  TOP w0.127: RC451.1 RC452.1 98.27,39.12 v2(98.31,39.08)
  IN1 w0.061: v2(98.31,39.08) v5(98.31,38.99)
  IN1 w0.076: v5(98.31,38.99) 98.6,38.7 v4(98.64,38.7)
  IN3 w0.076: v4(98.64,38.7) 98.6,38.7 v5(98.31,38.99)
INTRUDER#: length 3.7
  BOTTOM w0.127: UCPU1.BR35 97.8,33.75 97.8,32.54 98.27,32.07 RC78.1
ISH_ACC1_INT#: length 170.5
  TOP w0.127: v2(108.66,18.84) v3(107.95,18.84)
  IN1 w0.061: v4(109.17,18.84) v2(108.66,18.84)
  IN2 w0.061: v4(43.36,77.74) 43.36,77.11 46.49,73.98 46.49,72.76 45.49,71.76 45.25,71.76 42.07,68.58 42.07,66.93 40.14,65 40.14,63.32 39.37,62.55 39.37,59.66 37.86,58.15 37.86,54.37 37.28,53.79 37.28,50.92 37.66,50.54 37.66,49.97 37.33,49.64 37.33,49.16 37.25,49.07 37.25,45.74 34.05,42.54 34.05,41.06 34.37,40.74 34.37,37.57 34.06,37.27 34.06,37.05 29.94,32.93 29.94,29.22 29.65,28.92 29.65,24.71 33.89,20.46 35.45,20.46 35.93,20.94 38.01,20.94 38.35,20.6 40.66,20.6 41.22,20.04 41.22,19.3 41.74,18.78 46.97,18.78 49.47,16.28 51.58,16.28 52.21,16.91 53.1,16.91 53.5,16.51 91.28,16.51 91.78,16.01 96.98,16.01 98.39,17.42 100.1,17.42 100.33,17.19 104.58,17.19 105.52,18.12 108.45,18.12 v4(109.17,18.84)
  IN3 w0.061: v4(43.36,77.74) 43.36,77.36 v5(43.31,77.31) ; v4(109.17,18.84) 109.17,19.18 108.23,20.12 106.72,20.12 105.2,21.64 105.2,25.2 105.11,25.3 103.76,25.3 101.99,27.06 101.99,27.81 101.45,28.35 v5(101.45,29.39)
  BOTTOM w0.076: 101.13,31.46 101.13,29.71 v5(101.45,29.39)
  BOTTOM w0.127: JEDP1.29 43.22,77.39 v5(43.31,77.31) ; 101.13,31.46 100.92,31.67 100.92,33.73 UCPU1.BW35
ISH_ACC2_INT#: length 184.8
  TOP w0.127: UV5.12 248.6,39.89 v1(248.89,40.19) 249.43,40.72 249.43,42.63 248.41,43.64 v6(248.41,44.4)
  IN2 w0.061: v4(101.28,28.03) 101.28,28.52 101.67,28.91 102.15,28.91 103.03,29.78 105.3,29.78 106.14,28.95 110.58,28.95 115.48,24.05 115.95,24.05 118.88,21.12 122.09,21.12 122.67,21.71 125.92,21.71 126.37,22.15 129.01,22.15 130.01,21.14 131.35,21.14 131.69,21.48 133.51,21.48 134.63,22.6 139.48,22.6 141.16,20.92 143.71,20.92 147.97,16.65 153.74,16.65 154,16.39 177.78,16.39 189.86,28.47 197.51,28.47 197.86,28.11 206.69,28.11 208.08,26.72 215.82,26.72 220.28,31.18 220.95,31.18 228.77,39.01 231.48,39.01 237.06,44.58 248.23,44.58 v6(248.41,44.4)
  IN3 w0.061: v5(100.61,34.7) 100.61,34.45 100.26,34.1 100.26,31.58 101.23,30.62 101.23,29.79 101.19,29.75 101.19,29.32 101.23,29.28 101.23,28.09 v4(101.28,28.03) 101.28,27.86 v5(101.48,27.65)
  BOTTOM w0.127: RC548.1 100.99,26.43 101.48,26.93 v5(101.48,27.65)
ISH_ALS_INT#: length 50.1
  TOP w0.127: v2(110.11,18.84) v3(110.11,19.63)
  IN1 w0.061: v4(109.68,18.84) v2(110.11,18.84)
  IN3 w0.061: v5(123.32,23.34) 123.32,22.17 123.99,21.49 123.99,20.42 123.41,19.83 121.71,19.83 119.46,17.59 114.33,17.59 114.08,17.33 110.7,17.33 109.68,18.35 v4(109.68,18.84) 108.28,20.24 106.77,20.24 106.1,20.91 106.1,21.95 105.45,22.6 105.45,25.3 105.21,25.54 103.86,25.54 102.24,27.16 102.24,27.98 102.14,28.08 102.14,28.66 101.94,28.86 101.94,29.32 v5(102.02,29.39)
  BOTTOM w0.076: UCPU1.CA36 101.67,33.24 101.67,33.03 101.56,32.85 101.56,32.47 101.83,32.2 101.83,31.88 101.76,31.82 101.76,29.65 v5(102.02,29.39)
  BOTTOM w0.127: JCAM1.11 131.06,23.14 129.37,24.82 124.8,24.82 v5(123.32,23.34)
ISH_I2C0_SCL: length 194.5
  TOP w0.127: RV53.1 247.85,42.32 247.85,43.15 247.21,43.8 245.57,43.8 v1(245.31,43.54) 245.09,43.32 241.94,43.32 241.83,43.43 241.33,43.43 241.22,43.32 238.17,43.32 235.92,41.07 235.92,37.44 230.54,32.06 230.54,27.36 229.97,26.79 229.97,24.47 v2(229.91,24.4)
  IN1 w0.061: v2(229.91,24.4) 230.01,24.3 230.01,23.87 229.86,23.72 218.15,23.72 217.36,22.93 214.78,22.93 207.28,15.42 203.61,15.42 203.35,15.68 200.67,15.68 197.29,12.3 185.76,12.3 185.06,11.6 179.65,11.6 178.79,10.74 156.74,10.74 156.01,10.87 155.17,11.11 147.97,12.78 147.74,12.88 146.71,13.26 146.7,13.27 141.15,15.32 139.2,15.32 137.6,16.92 136.17,16.92 132.82,20.28 132.82,21.14 131.9,22.05 130.6,22.05 v4(130.33,22.32) ; v2(105.76,43.34) 105.89,43.34 v4(106.05,43.51)
  IN3 w0.061: v5(127.33,23.21) 127.79,23.21 128.12,22.88 129.2,22.88 129.93,22.14 130.15,22.14 v4(130.33,22.32) ; v5(119.04,20.99) 119.04,20.79 119.1,20.72 120.19,20.72 120.7,20.21 123.25,20.21 123.42,20.38 123.42,20.53 v5(123.33,20.62) 123.42,20.71 123.42,21.43 121.98,22.87 118.77,22.87 117.88,23.76 116.6,23.76 115.28,25.07 115.28,25.79 112.91,28.15 111.82,28.15 108.45,31.52 108.45,32.6 107.82,33.23 107.82,33.46 106.44,34.84 106.44,37.4 106.03,37.82 106.03,38.82 107.06,39.86 107.06,40.93 107.19,41.06 107.19,41.66 107,41.85 105.43,41.85 105.03,42.25 105.03,42.96 105.25,43.17 105.72,43.17 v5(105.79,43.24) v4(106.05,43.51)
  BOTTOM w0.127: v5(123.33,20.62) 123.39,20.68 123.39,21.33 124.88,22.82 127.03,22.82 127.33,23.11 v5(127.33,23.21)
ISH_I2C0_SCL_EDP: length 169.5
  IN2 w0.061: v4(116.67,21.37) 116.71,21.37 116.87,21.53 116.87,21.77 116.74,21.91 113.7,21.91 110.98,19.19 109.07,19.19 108.22,18.33 105.39,18.33 104.42,17.37 100.4,17.37 100.17,17.6 98.32,17.6 96.86,16.14 91.83,16.14 91.33,16.64 53.56,16.64 53.16,17.04 52.14,17.04 51.51,16.41 49.52,16.41 47.03,18.91 41.89,18.91 41.34,19.45 41.34,20.12 40.73,20.73 38.43,20.73 38.09,21.06 35.88,21.06 35.4,20.59 33.95,20.59 29.78,24.76 29.78,28.87 30.07,29.16 30.07,32.88 34.19,37 34.19,37.21 34.5,37.52 34.5,40.8 34.18,41.12 34.18,42.49 37.37,45.68 37.37,49.02 37.46,49.1 37.46,49.59 37.78,49.92 37.78,50.59 37.4,50.97 37.4,53.39 37.4,53.39 37.4,53.41 39.01,55.02 39.01,56.94 38.29,57.66 38.29,58.39 39.51,59.62 39.51,62.51 40.29,63.28 40.29,64.93 42.24,66.89 42.24,68.57 45.3,71.63 45.61,71.63 46.64,72.65 46.64,72.97 49.62,75.95 49.81,75.95 49.94,76.08 49.94,76.12 v4(49.76,76.29)
  IN3 w0.061: v4(116.67,21.37) 116.86,21.17 116.86,20.8 116.81,20.75 116.63,20.75 v5(116.5,20.87) ; v4(49.76,76.29) 49.96,76.48 49.96,76.6 49.88,76.68 48.48,76.68 48.4,76.6 42.31,76.6 v5(41.73,77.18)
  BOTTOM w0.127: RV62.2 118.22,20.76 118.07,20.76 117.81,21.01 DV4.1 117.48,21.01 117.25,20.78 116.59,20.78 v5(116.5,20.87) ; v5(41.73,77.18) 41.73,77.33 41.63,77.43 JEDP1.25
ISH_I2C0_SCL_R: length 2.6
  TOP w0.127: v1(248.87,41.94) 248.56,41.64 RV53.2 247.75,41.04 247.36,40.65 UV5.1
ISH_I2C0_SDA: length 188.1
  TOP w0.127: v2(230.29,24.4) 230.22,24.47 230.22,26.68 230.8,27.26 230.8,31.96 236.18,37.34 236.18,40.97 238.27,43.06 v1(241.6,43.06) 245.24,43.06 245.46,42.84 RV52.1 ; RC555.1 v2(107.02,42.77)
  IN1 w0.061: v2(107.02,42.77) 107.29,42.5 v4(107.35,42.5) ; v2(230.29,24.4) 230.2,24.31 230.2,23.79 229.94,23.54 218.23,23.54 217.44,22.74 214.86,22.74 207.35,15.24 203.53,15.24 203.28,15.49 200.75,15.49 197.37,12.11 185.84,12.11 185.14,11.41 179.72,11.41 178.86,10.55 156.73,10.55 156.34,10.62 156.34,10.62 155.97,10.68 155.12,10.93 147.92,12.6 147.9,12.61 147.67,12.71 146.66,13.08 146.64,13.09 141.12,15.13 139.12,15.13 137.52,16.73 136.09,16.73 132.63,20.2 132.63,21.06 131.83,21.86 130.4,21.86 v4(130.33,21.79)
  IN3 w0.061: v5(107.09,42.2) 107.09,42.03 107.38,41.74 107.38,40.98 107.25,40.86 107.25,39.78 106.22,38.75 106.22,37.89 106.63,37.48 106.63,34.92 108.01,33.53 108.01,33.31 108.64,32.68 108.64,31.6 111.9,28.34 112.99,28.34 115.47,25.86 115.47,25.15 116.67,23.95 117.96,23.95 118.85,23.06 122.06,23.06 123.61,21.51 123.61,20.72 v5(123.71,20.62) 123.61,20.52 123.61,20.3 123.33,20.02 120.62,20.02 120.11,20.54 119.1,20.54 119.04,20.48 v5(119.04,20.28) ; v4(130.33,21.79) 130.16,21.95 129.85,21.95 129.12,22.69 127.86,22.69 v5(127.64,22.91)
  IN3 w0.076: v5(107.09,42.2) 107.32,42.44 107.32,42.46 v4(107.35,42.5)
  BOTTOM w0.127: v5(127.64,22.91) 127.49,22.91 127.14,22.56 124.98,22.56 123.65,21.22 123.65,20.68 v5(123.71,20.62)
ISH_I2C0_SDA_EDP: length 169.6
  IN2 w0.061: v4(117.22,21.35) 117.04,21.53 117.04,21.84 116.8,22.08 113.64,22.08 110.91,19.35 109,19.35 108.15,18.5 105.32,18.5 104.35,17.53 100.47,17.53 100.24,17.76 98.25,17.76 96.79,16.3 91.9,16.3 91.4,16.8 53.62,16.8 53.22,17.2 52.07,17.2 51.44,16.57 49.59,16.57 47.09,19.07 41.96,19.07 41.51,19.52 41.51,20.18 40.8,20.89 38.5,20.89 38.16,21.23 35.81,21.23 35.33,20.75 34.02,20.75 29.94,24.83 29.94,28.8 30.23,29.1 30.23,32.81 34.35,36.93 34.35,37.15 34.66,37.45 34.66,40.86 34.34,41.18 34.34,42.42 37.54,45.62 37.54,48.95 37.62,49.04 37.62,49.52 37.95,49.85 37.95,50.66 37.57,51.04 37.57,53.32 39.17,54.93 39.17,57.01 38.45,57.73 38.45,58.33 39.67,59.55 39.67,62.44 40.45,63.21 40.45,64.86 42.4,66.82 42.4,68.51 45.37,71.47 45.68,71.47 46.8,72.58 46.8,72.9 49.69,75.79 49.87,75.79 50.1,76.01 50.1,76.1 v4(50.29,76.29)
  IN3 w0.061: v4(117.22,21.35) 117.03,21.17 117.03,20.73 116.88,20.58 116.62,20.58 v5(116.5,20.47) ; v5(42.09,77.19) 42.09,77.05 42.37,76.77 48.34,76.77 48.41,76.84 49.95,76.84 50.12,76.67 50.12,76.45 v4(50.29,76.29)
  BOTTOM w0.127: v5(42.09,77.19) 42.09,77.41 42.03,77.47 JEDP1.26 ; RV63.2 118.2,20.53 118.01,20.53 117.8,20.32 DV5.1 117.5,20.32 117.27,20.55 116.59,20.55 v5(116.5,20.47)
ISH_I2C0_SDA_R: length 2.6
  TOP w0.127: v1(244.22,41.64) RV52.2 245.46,41.09 245.86,40.7 UV5.4
ISH_I2C1_SCL: length 196.2
  IN1 w0.076: v4(106.67,42.44) 106.52,42.44 106.43,42.35 106.43,42.19 106.54,42.08 107.22,42.08 107.75,41.55 107.94,41.55 108.27,41.22 108.45,41.22 108.85,40.82 108.85,40.1 109.41,39.54 109.41,38.49 114.03,33.87 114.03,32.8 114.87,31.96 116.31,31.96 117.2,31.06 117.9,31.06 118.1,31.26 123.29,31.26 123.63,31.6 125.4,31.6 126.47,30.54 127.78,30.54 130.04,28.27 130.32,27.85 131.18,26.8 132.04,25.76 132.74,24.98 134,23.69 135.49,22.37 141.03,18.05 144.38,16.14 145.58,15.56 147.32,14.82 149.54,14.01 150.22,13.82 155.28,12.59 156.48,12.26 156.95,12.16 177.93,12.16 182.11,16.34 198.73,16.34 201.08,18.69 206.59,18.69 209.47,21.58 209.47,24.45 212.55,27.53 213.63,27.53 215.33,29.23 215.33,30.42 218.43,33.52 223.66,33.52 223.89,33.75 224.51,33.75 224.73,33.53 224.73,33.33 v4(224.91,33.15)
  IN3 w0.061: v4(224.91,33.15) 224.9,33.17 v5(224.9,33.61)
  IN3 w0.076: v5(106.44,42.2) v4(106.67,42.44)
  BOTTOM w0.127: v5(224.9,33.61) 224.73,33.77 224.73,39.27 217.37,46.63 217.37,63.55 214.03,66.88 203.56,66.88 v7(203.32,66.64) 202.51,65.83 201.23,65.83 201.05,66.01 RS11.2
ISH_I2C1_SDA: length 196.3
  IN1 w0.076: v4(224.37,33.15) 224.53,33.31 224.53,33.44 224.42,33.55 223.97,33.55 223.74,33.32 218.51,33.32 215.53,30.34 215.53,29.14 213.71,27.32 212.64,27.32 209.68,24.36 209.68,21.49 206.67,18.49 201.17,18.49 198.81,16.13 182.19,16.13 178.02,11.96 156.93,11.96 156.43,12.06 155.23,12.39 150.16,13.62 149.47,13.82 147.25,14.63 145.5,15.38 144.29,15.96 140.92,17.88 135.36,22.21 133.86,23.54 132.59,24.84 131.88,25.62 130.16,27.73 129.88,28.14 127.69,30.33 126.38,30.33 125.32,31.4 123.72,31.4 123.37,31.06 118.18,31.06 117.98,30.86 117.12,30.86 116.22,31.75 114.79,31.75 113.83,32.71 113.83,33.78 109.21,38.41 109.21,39.46 108.65,40.02 108.65,40.73 108.37,41.01 108.19,41.01 107.86,41.34 107.67,41.34 107.13,41.88 106.45,41.88 106.23,42.1 106.23,42.35 106.15,42.44 v4(106.02,42.44)
  IN3 w0.061: v5(224.37,33.62) 224.35,33.6 224.35,33.17 v4(224.37,33.15)
  IN3 w0.076: v5(105.79,42.2) v4(106.02,42.44)
  BOTTOM w0.127: RS12.2 200.48,66.22 201.13,65.58 v7(202.25,65.58) 202.61,65.58 203.67,66.63 213.93,66.63 217.11,63.44 217.11,46.53 224.48,39.16 224.48,33.73 v5(224.37,33.62)
ISH_LID_CL#_NB: length 282.8
  TOP w0.127: v6(281.35,46.63) 280.99,46.27 274.06,46.27 272.66,44.87 DE7.2 271.45,45.43 v2(270.86,46.03) ; v2(107.8,36.35) 108.95,36.35 110.73,38.12 115.98,38.12 117.02,37.09 117.02,36.07 118.4,34.69 120.32,34.69 124.8,39.17 126.34,39.17 v1(126.82,39.66) 127.07,39.91 v2(127.07,40.39) ; v6(110.88,53.76) 110.82,53.7 105.39,53.7 105.17,53.47 RC633.1
  IN1 w0.061: v4(126.5,40.15) 126.83,40.15 v2(127.07,40.39) ; v4(107.42,36.74) 107.8,36.37 v2(107.8,36.35) ; v4(220.42,45.51) 223.81,45.51 225.48,47.18 235.23,47.18 236.13,48.08 240.11,48.08 240.34,47.85 249.04,47.85 249.9,47 255.79,47 256.24,46.54 260.72,46.54 261.68,45.58 263.17,45.58 263.52,45.94 266.78,45.94 267.65,46.8 269.34,46.8 269.72,47.19 270.36,47.19 270.86,46.69 v2(270.86,46.03)
  IN2 w0.061: v4(220.42,45.51) 217.23,45.51 213.63,41.91 207.64,41.91 205.99,40.26 205.99,39.13 205.24,38.38 197.16,38.38 193.81,35.03 190.03,35.03 189.19,34.19 189.19,33.91 175.98,20.69 155.86,20.69 155.6,20.95 149.76,20.95 145.49,25.21 143.09,25.21 133.29,35.02 130.5,35.02 127.2,38.31 127.2,39.45 v4(126.5,40.15) 126.15,40.5 124.87,40.5 122.04,43.34 121.05,43.34 119.67,44.72 119.67,47.62 119.12,48.17 116.15,48.17 113.94,50.38 112.59,50.38 110.88,52.09 v6(110.88,53.76)
  IN3 w0.061: v5(107.06,36.73) 107.08,36.74 v4(107.42,36.74) ; v5(285.98,71.45) 285.8,71.45 280.97,66.63 280.97,47.01 v6(281.35,46.63)
  BOTTOM w0.127: v6(110.88,53.76) 110.88,55.47 113.02,57.6 113.62,57.6 114.22,58.2 114.22,60.64 113.08,61.78 110.86,61.78 110.66,61.58 DC6.1 ; UCPU1.CA34 102.6,34.7 103.11,35.2 103.11,35.55 103.63,36.07 106.63,36.07 106.83,36.28 106.83,36.5 v5(107.06,36.73)
ISH_LID_CL#_TAB: length 224.1
  TOP w0.127: RC634.1 103.19,29.22 103.19,28.39 103.04,28.24 v2(102.01,28.24) ; DE8.2 v2(278.91,60.07) 278.91,59.97 v1(278.69,59.75)
  IN1 w0.061: v4(276.9,59.77) 277.2,60.07 v2(278.91,60.07) ; v2(102.01,28.24) 102.01,28.32 v4(101.77,28.56) ; v4(105.79,21.81) 105.79,21.28 106.4,20.66 108.67,20.66 109.36,19.98 112.64,19.98 113.58,20.91 119.14,20.91 120.85,19.21 121.96,19.21 123.07,18.09 v4(123.07,16.33)
  IN2 w0.061: v4(276.9,59.77) 273.73,56.6 273.73,55.46 273.73,55.46 273.73,54.4 273.74,54.39 273.74,47.72 269,42.98 267.85,42.98 266.57,41.7 266.57,41.08 264.71,39.21 258.94,39.21 256.29,36.56 236.83,36.56 217.85,17.58 217.84,17.58 217.72,17.46 212.79,17.46 210.55,15.22 203.3,15.22 201.82,13.73 200.54,13.73 200.05,14.23 182.06,14.23 179.72,11.88 152.13,11.88 151.87,12.14 132.6,12.14 130.79,13.95 130.79,14.56 129,16.35 126.85,17.23 124.23,17.23 123.33,16.33 v4(123.07,16.33)
  IN3 w0.061: v4(105.79,21.81) 105.32,22.27 105.32,25.25 105.16,25.42 103.81,25.42 102.12,27.11 102.12,27.89 101.77,28.23 v4(101.77,28.56) 101.7,28.63 101.7,29.53 101.37,29.86 101.37,30.68 100.55,31.5 100.55,32.69 v5(100.61,32.75)
ISH_NB_MODE#: length 225
  TOP w0.127: v1(267.71,46.79) 267.39,47.12 v2(267.39,47.62) ; QN12.6 v2(272.85,29.51)
  IN1 w0.061: v2(267.39,47.62) 267.12,47.89 264.68,47.89 v4(263.96,47.16) ; v4(262.19,29) 262.25,29.06 272.41,29.06 v2(272.85,29.51)
  IN2 w0.061: v4(263.96,47.16) 263.96,46.77 263.1,45.91 261.74,45.91 261.44,46.21 247.46,46.21 246.75,45.5 234.18,45.5 220.63,31.95 219.94,31.95 217.27,29.27 216.13,29.27 215.74,29.66 213.71,29.66 213.05,29 198.23,29 197.88,29.36 189.49,29.36 177.41,17.28 154.37,17.28 154.11,17.54 148.34,17.54 144.08,21.81 141.55,21.81 139.87,23.49 129.65,23.49 129.2,23.04 126,23.04 125.57,22.61 118.48,22.61 116.27,24.82 115.79,24.82 110.9,29.71 107.34,29.71 105.29,31.75 101.73,31.75 v4(101.26,32.23)
  IN3 w0.061: v4(101.26,32.23) 101.26,32.53 v5(101.23,32.56) ; v4(263.96,47.16) 263.96,46.41 264.55,45.81 264.55,43.64 265.98,42.21 265.98,41.55 265.59,41.15 265.59,36.55 265.88,36.26 265.88,32.55 264.32,30.99 263.61,30.99 263.1,30.49 263.1,29.47 262.63,29 v4(262.19,29)
  BOTTOM w0.076: v5(101.23,32.56) 101.23,32.57 101.35,32.81 101.46,33 101.47,33.05 101.47,33.68 101.83,34.03 UCPU1.CA35
  BOTTOM w0.127: RC549.1 101.45,32.16 101.23,32.38 v5(101.23,32.56)
ISH_P_SENSOR_INT#: length 41.9
  TOP w0.127: v2(103.44,33.12) v1(103.44,32.59) 103.44,32.39 103.76,32.07 RC547.1
  IN1 w0.061: v4(100.8,33.98) 100.8,33.83 101.1,33.52 101.71,33.52 102.11,33.13 103.39,33.13 103.4,33.12 v2(103.44,33.12)
  IN2 w0.061: v4(100.8,33.98) 100.8,33.55 102.22,32.13 106.72,32.13 108.33,30.52 111.25,30.52 115.85,25.93 116.1,25.93 118.79,23.24 125.3,23.24 125.94,23.88 v4(126.71,23.88)
  IN3 w0.061: v4(100.8,33.98) 100.88,33.9 100.88,33.66 v5(100.62,33.4) ; v4(126.71,23.88) 127,23.59 v5(127,23.58)
  BOTTOM w0.127: JCAM1.5 130.09,21.34 127.85,23.58 v5(127,23.58)
ISH_TABLE_MODE#: length 195.4
  TOP w0.127: UE1.J8 268.24,54.74 267.82,54.32 267.82,52.22 v2(267.61,52.01)
  IN1 w0.061: v2(267.61,52.01) 267.61,51.87 267.47,51.72 267.12,51.72 266.82,51.43 v4(266.14,51.43)
  IN2 w0.061: v4(266.14,51.43) 265.54,50.82 265.54,48.14 263.18,45.78 263.15,45.78 263.14,45.77 261.69,45.77 261.38,46.09 247.52,46.09 246.8,45.37 234.24,45.37 220.68,31.82 219.99,31.82 216.92,28.75 198.13,28.75 197.77,29.1 189.6,29.1 177.52,17.02 154.27,17.02 154,17.29 148.24,17.29 143.97,21.55 141.45,21.55 139.77,23.23 129.76,23.23 129.31,22.78 126.1,22.78 125.67,22.35 118.37,22.35 116.16,24.56 115.69,24.56 110.8,29.45 106.35,29.45 104.68,31.12 102.59,31.12 v4(102.42,31.29)
  IN3 w0.061: v5(102.08,30.6) 102.08,31.07 102.3,31.29 v4(102.42,31.29)
  BOTTOM w0.127: UCPU1.CA37 102.08,32.49 v5(102.08,30.6) RC551.1
JACK_PLUG: length 48.1
  TOP w0.127: v2(278.34,30) 278.34,31.02 v1(278.19,31.17)
  IN1 w0.254: v2(278.34,30) 278.34,28.94 277.75,28.34 277.75,25.75 278.34,25.15 278.34,16.31 281.44,13.21 285.01,13.21 285.96,12.26 289.38,12.26 290.5,11.14 298.62,11.14 299.13,11.66 299.13,13.01 v2(299.3,13.18) 300.93,13.18 302.5,11.6 305.41,11.6 306,12.19 JHP1.6
JACK_PLUG#: length 9.1
  TOP w0.127: UA1.48 281.3,27.47 281.16,27.61 279.83,27.61 279.61,27.83 278.04,27.83 277.89,27.98 277.89,28.77 278.2,29.09 RA29.1 278.41,29.03 RA22.1 CA36.1 279.73,29.03 279.93,29.23 v1(279.93,31.2)
JD2: length 3.4
  TOP w0.127: RA124.2 279.59,28.39 v1(279.89,28.09) 280.11,27.87 281.28,27.87 281.7,27.44 UA1.47
JHP1_GND: length 4.8
  TOP w0.381: JHP1.7 305.4,22.02 304.28,23.14 303.39,23.14 303,23.54 v1(303,23.81) RA125.2
JTAG_CLK: length 44
  TOP w0.076: v2(267.04,59.81) 267.21,59.98 267.87,59.98 UE1.C8
  TOP w0.127: v5(236.31,69.1) 236.31,69.11 237.27,70.07 v1(237.27,71.05) RE210.2
  IN1 w0.061: v2(267.04,59.81) 266.95,59.72 265.83,59.72 264.87,60.68 263.04,60.68 262.74,60.98 261.97,60.98 261.06,61.9 256.23,61.9 255.81,61.48 250,61.48 247.59,63.88 240.71,63.88 236.31,68.27 v4(236.31,68.64) v5(236.31,69.1)
  IN3 w0.061: v5(236.31,69.1) v4(236.31,68.64)
  BOTTOM w0.127: JDEG1.4 235.63,71.68 235.67,71.63 235.67,71.19 236.31,70.55 v5(236.31,69.1)
JTAG_RST#: length 6.8
  TOP w0.127: UE1.G13 273.65,56.41 273.77,56.53 CE26.1 274.36,56.28 274.48,56.15 275.72,56.15 CLEC1.1 276.14,56.11 RE164.1 RE162.2 277.47,55.35 v1(277.68,55.14)
JTAG_TDI: length 45.4
  TOP w0.127: UE1.E9 268.86,58.01 268.45,57.6 268.2,57.6 v2(268.19,57.61) ; RE212.2 v1(238.48,70.55) 238.48,69.91 v5(237.65,69.07)
  IN1 w0.061: v2(268.19,57.61) 268.06,57.74 268.06,59.45 267.19,60.32 266.03,60.32 265.36,60.98 263.54,60.98 262.93,61.58 262.36,61.58 261.42,62.53 255.97,62.53 255.56,62.12 250.3,62.12 247.91,64.51 241.32,64.51 237.65,68.19 v4(237.65,68.64) v5(237.65,69.07)
  IN3 w0.061: v5(237.65,69.07) v4(237.65,68.64)
  BOTTOM w0.127: JDEG1.2 236.63,71.43 237.36,70.69 237.36,69.36 v5(237.65,69.07)
JTAG_TDO: length 47.1
  TOP w0.127: RE209.2 236.7,70.29 235.78,69.37 v2(235.78,69.11) 235.78,68.78 236.46,68.1 v1(237.21,68.1) ; UE1.F6 266.63,57.22 v2(266.62,57.22)
  IN1 w0.061: v2(235.78,69.11) 235.78,68.64 v4(235.78,68.64) 235.78,68.15 240.49,63.44 247.35,63.44 249.77,61.02 255.97,61.02 256.41,61.45 260.85,61.45 261.78,60.53 264.81,60.53 266,59.34 266,58.91 266.34,58.57 266.58,58.57 266.79,58.36 266.79,58.21 266.89,58.11 266.89,57.71 266.62,57.44 v2(266.62,57.22)
  IN3 w0.061: v5(235.78,69.1) v4(235.78,68.64)
  BOTTOM w0.127: JDEG1.5 235.13,71.01 235.78,70.36 v5(235.78,69.1)
JTAG_TMS: length 41.1
  TOP w0.127: UE1.C5 265.84,59.91 v2(265.91,59.99) ; RE211.2 237.91,69.99 v1(237.45,69.53) v5(237.01,69.09)
  IN1 w0.061: v5(237.01,69.09) v4(237.01,68.64) 237.01,68.22 240.91,64.32 247.83,64.32 250.22,61.93 255.64,61.93 256.04,62.34 261.34,62.34 262.28,61.4 262.85,61.4 263.42,60.83 265.07,60.83 v2(265.91,59.99)
  IN3 w0.061: v5(237.01,69.09) v4(237.01,68.64)
  BOTTOM w0.127: JDEG1.3 236.13,71.46 237.01,70.58 v5(237.01,69.09)
KB_ADDR: length 3.5
  TOP w0.127: UK1.28 232.45,10.43 RK8.2 232.33,10.01 232.19,9.87 230.83,9.87 v1(230.61,10.1)
KB_BL_DET: length 35
  TOP w0.127: v6(216.4,16.99) 216.4,17.97 216.9,18.47 RK4.2 ; v6(238.04,12.99) 237.68,13.34 UK1.39 ; v6(221.25,16.69) v3(221.25,17.67)
  IN1 w0.061: v6(216.4,16.99) 216.7,16.69 v6(221.25,16.69)
  BOTTOM w0.127: v6(216.4,16.99) 215.85,16.43 214.36,16.43 213.96,16.83 JBL1.4 ; v6(221.25,16.69) 221.25,15.11 221.72,14.64 223.61,14.64 224.53,13.71 224.53,11.91 225.49,10.95 236.43,10.95 238.04,12.57 v6(238.04,12.99)
KB_DET#: length 177
  TOP w0.127: v5(108.06,39.85) 108.5,40.28 RC41.2 ; v6(227.98,41.13) v1(227.18,41.13)
  IN1 w0.061: v5(108.06,39.85) 108.06,39.68 v4(108.22,39.52)
  IN2 w0.061: v4(108.22,39.52) 108.86,38.88 108.86,35.73 114.78,29.8 116.29,29.8 117.98,28.12 117.98,27.53 119.74,25.77 121.2,25.77 121.61,25.36 122.9,25.36 123.58,24.69 125.39,24.69 125.75,25.05 130.87,25.05 131.56,25.74 139.7,25.74 142.16,23.27 144.69,23.27 148.95,19.01 154.74,19.01 155.01,18.75 176.8,18.75 188.88,30.82 198.49,30.82 198.84,30.47 210.97,30.47 211.48,30.98 215.79,30.98 225.94,41.13 v6(227.98,41.13)
  IN3 w0.061: v5(108.06,39.85) 108.06,39.68 v4(108.22,39.52)
  BOTTOM w0.127: v6(227.98,41.13) 229.04,41.13 234.71,35.46 234.71,33.19 249.33,18.58 JKB1.1 ; v5(108.06,39.85) 107.96,39.95 107.27,39.95 UCPU1.CK25
KB_LED_PWM: length 34.6
  TOP w0.127: QK1.2 213.91,15.6 213.08,15.6 212.83,15.35 v1(212.83,14.59) v6(213.33,14.08) ; UK1.40 237.75,13.84 v6(238.61,12.97)
  BOTTOM w0.127: v6(238.61,12.97) 238.61,12.78 236.53,10.7 225.38,10.7 224.28,11.8 224.28,13.56 223.74,14.1 220.84,14.1 219.98,13.25 214.16,13.25 v6(213.33,14.08)
KB_LED_PWM#: length 6.2
  TOP w0.127: v3(211.85,16.19) 213.08,16.19
  TOP w0.508: v6(214.53,16.98) 214.74,17.19 QK1.1 215.37,16.6 215.06,16.3 213.19,16.3 213.08,16.19
  BOTTOM w0.508: JBL1.3 214.96,17.41 v6(214.53,16.98)
KB_TEST: length 3.4
  TOP w0.127: TK1.1 233.59,9.85 233.45,9.99 RK9.2 232.95,10.8 UK1.29
KSI0: length 22.9
  TOP w0.127: UK1.18 229.53,15.34 229.48,15.4 227.89,15.4 v6(227.49,15.79) 227.46,15.83 v1(224.81,15.83)
  BOTTOM w0.127: JKB1.9 242.93,16.83 241.91,15.82 237.77,15.82 237.49,15.54 229.31,15.54 229.12,15.34 227.94,15.34 v6(227.49,15.79)
KSI1: length 23.6
  TOP w0.127: UK1.20 227.98,14.34 v6(227.52,14.81) 226.64,14.81 v1(226.38,15.07)
  BOTTOM w0.127: JKB1.7 244.53,16.72 243.11,15.31 237.98,15.31 236.88,14.21 228.11,14.21 v6(227.52,14.81)
KSI2: length 23.9
  TOP w0.127: UK1.23 229.61,12.84 229.45,12.68 v6(228.78,12.68) 227.89,12.68 v1(227.02,11.82)
  BOTTOM w0.127: v6(228.78,12.68) 230.21,12.68 231.24,13.7 237.09,13.7 238.19,14.8 244.45,14.8 246.12,16.48 JKB1.5
KSI3: length 19.1
  TOP w0.127: UK1.19 v6(229.03,14.84) 228.24,14.84 v1(228.04,15.04)
  BOTTOM w0.127: JKB1.8 243.73,16.82 242.47,15.56 237.87,15.56 236.78,14.47 229.41,14.47 v6(229.03,14.84)
KSI4: length 22
  TOP w0.127: UK1.25 230.95,12.24 v6(231.06,12.34) ; v6(246.46,15.46) v1(247.18,15.46)
  BOTTOM w0.127: v6(231.06,12.34) 231.42,12.7 232.09,12.7 232.33,12.94 233.08,12.94 233.96,12.05 236.45,12.05 237.1,12.7 237.1,13.35 238.25,14.5 245.5,14.5 v6(246.46,15.46) 246.93,15.92 JKB1.4
KSI5: length 25
  TOP w0.127: v1(225.47,12.57) 226.4,12.57 226.95,13.12 v6(228.1,13.12) 229.34,13.12 229.57,13.34 UK1.22
  BOTTOM w0.127: v6(228.1,13.12) 228.24,13.26 230.43,13.26 231.13,13.96 236.99,13.96 238.08,15.05 243.88,15.05 245.33,16.5 JKB1.6
KSI6: length 23.4
  TOP w0.127: v1(248.42,14.2) 247.73,14.9 v6(247.73,15.47) ; UK1.26 231.45,12.11 v6(231.65,12.31)
  BOTTOM w0.127: v6(231.65,12.31) 232.09,12.31 232.47,12.69 232.97,12.69 233.86,11.8 236.55,11.8 237.35,12.6 237.35,13.24 238.33,14.22 246.65,14.22 247.73,15.3 v6(247.73,15.47) JKB1.3
KSI7: length 22.7
  TOP w0.127: v6(232.71,12.26) 232.26,12.26 231.95,11.95 UK1.27 ; v6(248.53,15.49) 249.03,15.49 v1(249.26,15.72)
  BOTTOM w0.127: v6(232.71,12.26) 233.42,11.54 236.66,11.54 237.6,12.49 237.6,13.14 238.44,13.97 247.01,13.97 v6(248.53,15.49) JKB1.2
KSO00: length 14.5
  TOP w0.127: UK1.11 231.45,20.73 v6(231.13,21.05) 231.13,21.5 v1(231.53,21.9)
  BOTTOM w0.127: v6(231.13,21.05) 232.14,22.06 236.64,22.06 237.21,21.49 237.21,20.47 235.72,18.98 JKB1.18
KSO01: length 17.5
  TOP w0.127: v6(230.66,22.37) 229.31,21.03 v1(229.31,19.87) 229.31,18.24 229.71,17.84 UK1.13
  BOTTOM w0.127: v6(230.66,22.37) 230.86,22.57 237,22.57 238.09,21.49 238.09,19.39 237.33,18.63 JKB1.16
KSO02: length 14.6
  TOP w0.127: v6(230.47,21.05) 230.95,20.57 v1(230.95,20.3) UK1.12
  BOTTOM w0.127: JKB1.17 236.53,19.41 237.47,20.36 237.47,21.69 236.84,22.32 231.74,22.32 v6(230.47,21.05)
KSO03: length 19.1
  TOP w0.127: v6(229.95,22.4) v1(229.21,21.66) 228.92,21.37 228.92,18.1 229.68,17.34 UK1.14
  BOTTOM w0.127: JKB1.15 238.13,18.96 238.37,19.2 238.37,21.57 237.11,22.83 230.37,22.83 v6(229.95,22.4)
KSO04: length 16.6
  TOP w0.127: v6(228.32,16.65) v1(228.9,16.65) 229.2,16.34 UK1.16
  BOTTOM w0.127: JKB1.11 241.33,16.8 240.85,16.32 237.56,16.32 237.32,16.08 228.88,16.08 v6(228.32,16.65)
KSO05: length 19.2
  TOP w0.127: UK1.17 228.4,15.84 v6(228.36,15.81) 227.89,16.27 227.29,16.27 v1(226.66,16.91)
  BOTTOM w0.127: JKB1.10 242.12,16.91 241.28,16.07 237.66,16.07 237.4,15.81 v6(228.36,15.81)
KSO06: length 22.5
  TOP w0.127: UK1.15 229.48,16.84 228.27,18.05 v1(228.27,18.51) v6(228.27,21.1)
  BOTTOM w0.127: v6(228.27,21.1) 228.27,22.15 229.45,23.34 237.32,23.34 239.73,20.93 JKB1.13
KSO11: length 15
  TOP w0.127: UK1.5 234.45,19.12 233.98,19.59 233.98,22.09 234.69,22.8 v1(238.8,22.8) v6(239.94,22.8)
  BOTTOM w0.127: v6(239.94,22.8) 240.53,22.22 JKB1.12
KSO12: length 21.2
  TOP w0.127: v6(229.26,22.4) 229.89,23.03 v1(230.21,23.03) 231.44,23.03 231.95,22.52 UK1.10
  BOTTOM w0.127: v6(229.26,22.4) 229.94,23.08 237.21,23.08 238.93,21.37 JKB1.14
KSO13: length 19.8
  TOP w0.127: v6(227.02,20.02) v1(227.02,21.18) 227.02,23.27 227.43,23.68 232.02,23.68 233.45,22.24 UK1.7
  BOTTOM w0.127: JKB1.24 230.93,18.76 229.12,20.57 227.57,20.57 v6(227.02,20.02)
KSO14: length 19.7
  TOP w0.127: v6(226.38,20.01) 226.38,23.25 227.1,23.97 232.27,23.97 v1(233.02,23.22) 233.73,22.51 233.73,19.36 233.95,19.14 UK1.6
  BOTTOM w0.127: v6(226.38,20.01) 226.81,19.58 228.32,19.58 229.33,18.57 JKB1.26
KSO15: length 16.4
  TOP w0.127: v6(227.65,20.04) 227.65,23.05 v1(227.73,23.13) 227.97,23.37 231.8,23.37 233.2,21.97 233.2,19.47 232.95,19.23 UK1.8
  BOTTOM w0.127: JKB1.25 230.13,18.55 228.63,20.04 v6(227.65,20.04)
KSO16: length 5.8
  TOP w0.127: UK1.9 232.45,19.6 v6(232.71,19.86) 232.71,20.42 v1(232.83,20.54)
  BOTTOM w0.127: JKB1.19 234.93,19.17 234.24,19.86 v6(232.71,19.86)
KSO17: length 10.3
  TOP w0.127: UK1.3 235.45,20.95 v6(235.52,21.02) 235.52,21.41 v1(235.05,21.88)
  BOTTOM w0.127: v6(235.52,21.02) 235.12,21.42 232.86,21.42 232.06,20.62 232.06,19.28 232.53,18.82 JKB1.22
KSO18: length 11.7
  TOP w0.127: v1(236.83,21.89) 236.55,21.89 236.13,21.47 v6(236.13,21.04) 235.95,20.86 UK1.2
  BOTTOM w0.127: JKB1.23 231.73,18.7 231.81,18.79 231.81,20.73 232.83,21.75 235.42,21.75 v6(236.13,21.04)
KSO19: length 10.3
  TOP w0.127: v6(236.74,21.06) v1(236.74,20.06) 236.45,19.77 UK1.1
  BOTTOM w0.127: JKB1.21 233.33,18.57 232.32,19.57 232.32,20.31 232.55,20.54 236.5,20.54 236.74,20.78 v6(236.74,21.06)
KSO20: length 7.9
  TOP w0.127: v1(239.01,17.68) 239.01,17.46 v6(238.47,16.91) 238.03,17.34 UK1.47
  BOTTOM w0.127: JKB1.20 234.13,17.25 234.86,16.51 236.96,16.51 237.36,16.91 v6(238.47,16.91)
LAN_WAKE#: length 202.5
  TOP w0.102: v2(264.64,52.57) 264.62,52.6 264.62,52.67 264.24,53.05 UE1.L3
  IN1 w0.061: v2(98.85,27.57) 99.24,27.96 99.85,27.96 100.32,28.43 100.32,29.2 101.24,30.13 101.24,31.27 100.93,31.58 v4(100.93,31.62) 100.62,31.92 100.62,33.5 99.6,34.51 99.6,35.36 v4(99.46,35.51) ; v4(265.12,52.44) 264.78,52.44 v2(264.64,52.57)
  IN2 w0.061: v4(100.93,31.62) 102.22,30.32 105.3,30.32 106.3,29.33 110.74,29.33 115.63,24.44 116.11,24.44 118.32,22.23 125.72,22.23 126.16,22.66 129.36,22.66 129.81,23.11 139.71,23.11 141.39,21.43 143.92,21.43 148.18,17.16 153.95,17.16 154.21,16.9 177.57,16.9 189.65,28.97 197.72,28.97 198.07,28.62 216.97,28.62 220.05,31.69 220.74,31.69 234.29,45.24 246.85,45.24 247.57,45.96 261.33,45.96 261.64,45.65 263.24,45.65 265.71,48.12 265.71,50.51 266.47,51.27 266.47,52 266.03,52.44 v4(265.12,52.44)
  IN3 w0.076: v5(99.22,35.74) v4(99.46,35.51)
LCD_CBL_DET#: length 182.6
  IN1 w0.061: v4(106.55,21.81) 106.55,22.12 v2(106.45,22.22)
  IN2 w0.061: v4(106.55,21.81) 106.26,21.81 105.84,21.39 103.27,21.39 101.23,19.36 97.48,19.36 95.31,17.18 53.81,17.18 53.41,17.58 51.91,17.58 51.28,16.95 49.75,16.95 47.25,19.45 42.12,19.45 41.89,19.68 41.89,20.35 40.96,21.27 38.71,21.27 38.37,21.61 35.65,21.61 35.17,21.13 34.17,21.13 30.32,24.98 30.32,28.62 30.61,28.92 30.61,32.65 34.73,36.77 34.73,36.99 35.04,37.3 35.04,41.02 34.72,41.34 34.72,42.25 37.92,45.45 37.92,48.8 38.01,48.89 38.01,49.38 38.33,49.69 38.33,50.87 37.95,51.25 37.95,53.05 39.58,54.68 39.58,56.72 39.96,57.1 39.96,59.52 39.93,59.55 39.93,62.33 40.72,63.12 40.72,64.14 43.19,66.62 43.19,69.12 45.32,71.24 45.73,71.24 46.93,72.43 46.93,72.85 49.74,75.66 50.37,75.66 v4(50.46,75.75)
  IN3 w0.061: v4(106.55,21.81) 106.92,22.18 106.92,25.91 107.47,26.46 107.47,26.87 v5(107.48,26.88) 108.39,27.79 108.39,30.46 107.49,31.36 106.63,31.36 106.02,31.97 106.02,33.79 105.78,34.03 105.78,35.11 106.07,35.4 106.07,37.24 105.59,37.72 105.59,38.9 105.93,39.24 105.93,40.46 105.51,40.88 105.02,40.88 104.86,41.05 104.86,41.91 104.67,42.1 104.67,43.64 104.24,44.06 104.24,46.21 104.16,46.28 104.16,46.61 104.24,46.69 104.24,48.18 v5(104.49,48.43) ; v5(44.13,77.03) 44.27,76.89 48.29,76.89 48.37,76.97 50.23,76.97 50.6,76.6 50.6,75.89 v4(50.46,75.75)
  BOTTOM w0.127: JEDP1.32 44.43,77.32 v5(44.13,77.03)
LCD_SELF_TEST: length 151.7
  TOP w0.127: v2(267.42,45.84) RV87.1 v1(267.42,44.32)
  IN1 w0.061: v2(267.42,45.84) 266.93,45.34 v4(265.02,45.34)
  IN2 w0.061: v4(265.02,45.34) 264.64,44.96 261.61,44.96 261.16,45.41 256.1,45.41 255.5,44.81 253.44,44.81 252.86,44.23 252.04,44.23 251.38,43.58 251.38,43.23 250.05,41.9 237.49,41.9 219.3,23.7 214.43,23.7 211.05,20.33 183.43,20.33 178.29,15.18 153.5,15.18 153.23,15.45 147.47,15.45 143.24,19.68 133.97,19.68 v4(133.77,19.88)
  IN3 w0.061: v5(133.21,20.44) v4(133.77,19.88)
  BOTTOM w0.127: JCAM1.2 v5(133.21,20.44)
