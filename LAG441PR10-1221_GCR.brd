# Allegro board LAG441PR10-1221_GCR.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LCD_TST: length 18.4
  TOP w0.127: UE1.M2 263.31,52.54 v2(263.31,52.74) ; v1(268.92,45.32) 268.4,45.84 RV86.1 v2(268.01,46.34)
  IN1 w0.061: v4(268.45,46.23) 268.11,46.23 v2(268.01,46.34) ; v2(263.31,52.74) 263.08,52.52 v4(263.08,52.43)
  IN2 w0.061: v4(263.08,52.43) 263.16,52.43 265.06,54.32 265.53,54.32 266.34,53.51 268.83,53.51 270.2,52.14 270.2,48.9 268.45,47.15 v4(268.45,46.23)
LCD_VCC_TEST_EN: length 357.8
  TOP w0.102: v2(262.65,58.01) 262.65,58.01 UE1.E1
  TOP w0.127: v2(41.64,71.32) 41.64,72.26 42.41,73.04 44.99,73.04 45.24,72.79 45.24,71.26 v1(45.21,71.23) 44.64,70.66 DV1.3
  IN1 w0.061: v4(262.31,57.75) 262.58,58.01 v2(262.65,58.01) ; v2(41.64,71.32) 41.83,71.13 v4(41.83,70.97)
  IN2 w0.061: v4(262.31,57.75) 262.31,57.49 262.93,56.88 264.22,56.88 266.47,54.63 267.28,54.63 267.93,55.28 269.44,55.28 269.71,55.01 269.71,54.35 269.94,54.12 271.16,54.12 271.91,53.37 271.91,47.33 268.57,43.99 267.34,43.99 266.25,42.91 264.28,42.91 262.34,40.97 257.16,40.97 255.36,39.18 238.01,39.18 217.31,18.48 212.27,18.48 211.96,18.17 202.66,18.17 201.06,16.57 182.79,16.57 179.24,13.02 152.6,13.02 152.35,13.27 133.75,13.27 133.21,13.81 133.21,16.01 131.58,17.65 128.5,17.65 126.72,18.37 123.56,18.37 123.09,17.9 114.06,17.9 109.49,13.33 103.84,13.33 103.53,13.64 101.17,13.64 100.97,13.44 97.29,13.44 96.83,12.98 57.94,12.98 56.87,14.05 53.68,14.05 53.54,13.91 52.92,13.91 52.43,13.41 49.05,13.41 46,16.46 40.63,16.46 40.18,16 28.76,16 27.38,17.39 26.7,17.39 26.28,17.39 24.14,19.53 24.14,22.39 24.44,22.68 25.01,22.68 25.22,22.68 27.93,25.4 27.93,29.71 28.22,30.01 28.22,35.21 30.29,37.28 30.29,39.49 32.3,41.5 32.3,43.34 34.45,45.49 34.45,48.53 35.29,49.36 35.29,53.46 35.55,53.73 35.55,54.33 36.4,55.17 36.4,62.66 36.68,62.94 36.68,63.27 38.82,65.4 38.82,67.96 v4(41.83,70.97)
LCDVDD_MONITOR: length 4.5
  TOP w0.127: v1(68.55,61.41) 67.58,62.39 RV47.1 68.25,64.41 QV7.2
LDO2_CAP: length 3
  TOP w0.203: UA1.21 284.5,20.01 284.8,19.72 285.48,19.72 CA18.1
LDO3_CAP: length 2.7
  TOP w0.203: UA1.19 283.7,19.97 v1(283.56,19.83) 283.16,19.42 CA19.1
LDO_1.0V: length 0.9
  TOP w0.127: v6(121.41,56.47) 120.85,57.03 v3(120.85,57.18)
LDO_IN: length 8.2
  BOTTOM w0.356: CT201.1 14.81,67.63 15.35,68.18 15.35,69.39 14.95,69.79 RT296.1
  BOTTOM w0.508: DT47.1 DT49.1 DT48.1 CT201.1 13.48,67.63 UT16.1
LED_MASK#: length 19.1
  TOP w0.127: UE1.A12 271.74,61.21 272.09,61.55 272.57,61.55 273.83,62.81 274.28,62.81 274.93,63.46 278.26,63.46 v1(282.57,67.77) 283.24,68.44 v6(283.75,68.44)
  BOTTOM w0.127: v6(283.75,68.44) 283.75,69.41 284.24,69.91 R274.2 284.45,70.58 U33.1
LID_CL#_NB: length 294.3
  TOP w0.127: RE193.1 271.14,47.58 271.14,46.88 DE7.1 271.89,46.13 273.32,46.13 273.81,46.61 v2(274.6,46.61)
  IN1 w0.061: v2(274.6,46.61) 274.3,46.61 271.41,43.72 257.83,43.72 v4(257.43,44.13)
  IN2 w0.061: v4(122.31,16.35) 121.83,16.83 115.29,16.83 111.93,13.47 111.19,13.47 110.02,12.3 104.12,12.3 103.74,11.93 99.75,11.93 99.25,12.43 97.71,12.43 97.21,11.93 56.42,11.93 55.78,12.58 53.02,12.58 52.85,12.4 48.18,12.4 47.92,12.66 44.58,12.66 43.71,11.8 38.43,11.8 35.79,14.44 29.02,14.44 28.83,14.64 28.21,14.64 v4(27.89,14.32) ; v4(199.78,33.05) 199.97,32.86 203.49,32.86 203.96,33.33 209.75,33.33 209.94,33.52 213.32,33.52 220.64,40.84 220.64,41.33 222.92,43.62 227.1,43.62 231.84,48.35 246.62,48.35 247.69,49.42 v4(247.94,49.42)
  IN3 w0.061: v4(199.78,33.05) 199.72,33.11 v5(199.45,33.11) ; v4(122.31,16.35) 122.31,16.88 v5(122.5,17.07) ; v4(257.43,44.13) 251.79,44.13 247.94,47.98 v4(247.94,49.42) ; v5(27.61,13.79) 27.61,14.04 v4(27.89,14.32)
  BOTTOM w0.127: v5(27.61,13.79) 27.55,13.72 23.56,13.72 18.7,18.59 17.99,18.59 17.77,18.81 ULID1.B2 ; v5(122.5,17.07) 122.55,17.02 122.88,17.02 123.29,17.26 123.37,17.44 124.59,17.94 125.62,18.08 130.1,18.08 130.1,18.08 132.17,18.08 132.98,18.89 134.56,18.89 134.89,19.22 135.59,19.22 138.74,22.37 147.74,22.37 150.46,21.11 150.85,20.95 151.02,20.95 153.57,20.11 153.58,20.12 156.1,19.55 158.73,19.15 158.88,19.1 160.26,18.9 160.63,18.8 162.81,18.53 164.7,18.44 174.85,18.44 185.59,29.18 189.55,29.18 192.87,32.49 192.87,34.71 193.75,35.59 195.31,35.59 v1(196.07,34.84) 197.53,33.37 199.2,33.37 v5(199.45,33.11)
LID_CL#_TAB: length 311.2
  TOP w0.127: DE8.1 277.21,60.51 v2(277,60.29) 277,60.28 276.88,60.15 RE484.1
  IN1 w0.061: v4(257.95,44.16) 258.27,43.85 271.36,43.85 280.56,53.04 280.56,58.84 279.04,60.36 277.07,60.36 v2(277,60.29)
  IN2 w0.061: v4(121.8,16.37) 121.46,16.71 115.34,16.71 111.98,13.35 111.24,13.35 110.07,12.18 104.17,12.18 103.8,11.8 99.69,11.8 99.2,12.3 97.76,12.3 97.26,11.8 56.19,11.8 55.61,12.38 53.14,12.38 52.97,12.21 48.34,12.21 47.8,11.67 38.38,11.67 35.73,14.32 v4(28.49,14.32) ; v4(200.29,33.2) 200.51,32.99 203.44,32.99 203.91,33.46 209.7,33.46 209.89,33.65 213.27,33.65 220.51,40.89 220.51,41.38 222.87,43.74 227.05,43.74 231.78,48.48 246.26,48.48 247.71,49.93 v4(247.97,49.93)
  IN3 w0.061: v5(27.98,13.7) 28.49,14.21 v4(28.49,14.32) ; v4(121.8,16.37) 121.8,16.86 122.29,17.34 v5(122.73,17.34) ; v4(257.95,44.16) 257.94,44.16 257.57,44.53 251.56,44.53 248.35,47.75 248.35,49.55 v4(247.97,49.93) ; v5(199.82,33.5) 200,33.5 v4(200.29,33.2)
  BOTTOM w0.127: v5(199.82,33.5) 199.69,33.62 197.94,33.62 195.72,35.84 193.65,35.84 192.62,34.81 192.62,32.6 189.45,29.43 185.49,29.43 174.75,18.69 164.7,18.69 162.89,18.78 162.59,18.82 162.15,18.88 160.6,19.07 160.31,19.15 158.94,19.35 158.78,19.4 156.15,19.8 153.55,20.38 151.14,21.18 151.06,21.2 150.92,21.2 150.61,21.33 150.39,21.43 149.66,21.77 147.82,22.62 138.63,22.62 135.48,19.47 134.78,19.47 134.45,19.14 132.88,19.14 132.07,18.33 130,18.33 129.99,18.33 125.6,18.33 124.28,18.15 123.22,17.72 122.85,17.34 v5(122.73,17.34) ; ULID1.A2 17.57,20.39 17.32,20.14 v1(17.32,19.04) 17.32,18.78 17.77,18.33 18.59,18.33 23.46,13.47 27.75,13.47 v5(27.98,13.7)
LID_CL_SIO#: length 7.5
  TOP w0.102: UE1.N11 270.64,50.68 271.12,50.2 CE37.1
  TOP w0.127: CE37.1 271.25,49.46 271.47,49.24 271.47,48.54 RE193.2 271.75,48.19 ; 271.75,48.19 RE192.2 ; 271.75,48.19 271.46,47.9 271.46,47.3 271.57,47.19 272.25,47.19 v3(272.91,46.54)
LID_CL_SIO_TAB#: length 5.4
  TOP w0.102: 272.55,58.39 271.82,58.39 UE1.E12
  TOP w0.127: 272.55,58.39 273.74,59.58 CE115.1 v2(274.38,60.15)
  IN1 w0.061: v2(275.59,60.15) v2(274.38,60.15)
LIMT_1.2V_DDR: length 4.1
  TOP w0.127: v6(45.92,26.01) 45.26,26.01 v1(44.96,26.31)
  TOP w0.254: PR604.2 46.06,26.01 v6(45.92,26.01)
  BOTTOM w0.254: PU600.17 47.28,25.72 47.05,25.49 PR607.1 46.44,25.49 v6(45.92,26.01)
LINE2-L: length 3.4
  TOP w0.203: UA1.36 286.89,26.22 287.18,26.51 v1(287.6,26.51) 287.68,26.51 288.14,26.05 CA42.1
LINE2-R: length 3.6
  TOP w0.203: UA1.35 286.89,25.82 286.96,25.89 287.82,25.89 288.12,25.58 288.75,25.58 289.48,24.85 CA43.1
LP_PRIM_CORE: length 2.3
  BOTTOM w0.254: PR1415.2 PR1414.2 125.85,44.24 PU1401.6
LP_VCCIO: length 3.1
  BOTTOM w0.203: PR1430.2 PR1401.2 PR1400.2 101.43,19.07 101.89,19.52 PU1400.6
LX_1.0V: length 3.8
  TOP w0.127: v1(127.48,60.04) 124.9,57.46 v6(124.76,57.46)
LX_1.2V_DDR: length 1.3
  TOP w0.127: 47.23,19.82 47.23,18.95 v1(46.93,18.65)
  vias: v6(47.28,20.39)
LX_1.8VPRIM: length 0.7
  TOP w0.127: v6(112.46,23.46) v1(112.46,22.75)
LX_CORE1:
  vias: v6(80.23,74.85) v6(80.8,74.86)
LX_CORE2:
  vias: v1(107.14,69.75) v6(106.26,70.73) v6(106.84,70.73)
LX_GT:
  vias: v6(45.51,49.18) v6(45.52,48.62)
LX_PRIM_CORE: length 0.8
  TOP w0.127: v1(122.71,48.3) 122.69,48.29 v6(121.96,48.29)
LX_SA:
  vias: v6(129.02,63.35)
M2280_DEVSLP: length 158.3
  TOP w0.127: v6(221.14,41.17) 221.6,41.62 v1(223.26,41.62) ; v6(213.99,55.34) 213.94,55.39 RN23.1
  IN2 w0.061: v6(221.14,41.17) 213.37,33.39 209.99,33.39 209.21,32.61 197.56,32.61 196.79,31.84 188.42,31.84 176.36,19.77 155.42,19.77 155.16,20.03 149.37,20.03 145.11,24.29 142.59,24.29 132.81,34.06 130.01,34.06 121.66,42.42 120.67,42.42 119.56,43.53 118.65,43.53 117.04,45.14 117.04,45.87 113.57,49.33 109.03,49.33 108.82,49.55 108.51,49.55 108.13,49.92 v4(108.13,50.36)
  IN3 w0.061: v4(108.13,50.36) 108.13,50.69 v5(108.14,50.69)
  BOTTOM w0.127: v5(108.14,50.69) 107.77,51.06 UCPU1.CM8 ; JNGFF2.38 213.97,55.36 v6(213.99,55.34) 213.99,54.78 216.52,52.25 216.52,44.67 220.02,41.17 v6(221.14,41.17)
M2280_PCIE_SATA#: length 133.9
  TOP w0.127: RN26.1 206.06,48.15 206.51,47.69 v1(206.51,45.12) 206.51,33.85 205.27,32.61 v2(203.88,32.61)
  IN1 w0.061: v4(108.62,49.94) 109.05,49.51 v2(109.05,49.27) ; v4(204.18,33.01) 203.88,32.72 v2(203.88,32.61)
  IN2 w0.061: v4(108.62,49.94) 109.06,49.5 113.59,49.5 117.17,45.92 117.17,45.21 117.87,44.51 118.76,44.51 120.72,42.54 121.71,42.54 130.07,34.19 132.87,34.19 142.64,24.42 145.16,24.42 149.43,20.15 155.22,20.15 155.47,19.9 176.31,19.9 188.37,31.97 196.74,31.97 197.51,32.73 203.9,32.73 v4(204.18,33.01)
  IN3 w0.061: v5(109.04,49.76) 108.8,49.76 v4(108.62,49.94)
M_BIST: length 152.1
  TOP w0.102: UE1.N8 267.89,51.26 267.89,50.31 v2(267.84,50.26)
  IN1 w0.061: v2(267.84,50.26) 267.71,50.13 v4(267.46,50.13)
  IN2 w0.061: v4(197.9,26.51) 206.18,26.51 208.49,24.2 215.29,24.2 218.3,27.21 219.67,27.21 221.72,29.26 224.13,29.26 237.28,42.41 248.6,42.41 250.67,44.48 252.75,44.48 253.34,45.07 255.4,45.07 255.87,45.54 261.21,45.54 261.66,45.09 264.44,45.09 264.59,45.24 264.59,46.64 265.97,48.02 265.97,48.12 265.97,49.88 266.58,50.49 267.1,50.49 v4(267.46,50.13)
  IN3 w0.061: v4(197.9,26.51) 198.18,26.51 198.99,27.32 v5(198.99,27.52)
  BOTTOM w0.127: R271.1 143.2,20.57 145.93,20.57 146.61,19.88 147.61,19.88 148.31,19.18 149.31,19.18 149.77,18.73 153.12,18.73 154.56,17.29 175.61,17.29 v1(186,27.68) 186.41,28.09 189.92,28.09 191.89,30.06 196.29,30.06 197.2,29.14 197.2,28.19 197.88,27.52 v5(198.99,27.52)
M_BIST_R: length 48.9
  TOP w0.127: v2(121.03,16.81) 121.21,16.99 121.21,18.09 123.96,20.84 123.96,23.41 128.04,27.49 R283.2
  IN1 w0.061: v4(121.27,16.3) 121.03,16.54 v2(121.03,16.81)
  IN3 w0.061: v5(121.27,15.82) v4(121.27,16.3)
  BOTTOM w0.127: v5(121.27,15.82) 121.81,15.82 123.69,16.91 123.71,16.96 123.96,17.06 123.98,17.07 124.67,17.35 124.99,17.48 125.66,17.57 129.5,17.57 130.17,16.9 R272.2 130.86,16.9 131.34,17.38 132.69,17.38 132.86,17.54 134.29,17.54 135.2,18.46 137.22,18.46 137.83,17.85 139.96,17.85 140.49,18.38 141.46,18.38 142.15,19.07 R271.2 142.15,20.39 142.97,21.21 v1(143.36,21.21) 143.53,21.38 D481.2 145.49,21.38 146.64,20.22 C92.1 149.73,20.22 149.93,20.02 QZ21.2
ME_EN: length 3.1
  TOP w0.127: SW3.2 24.64,5.76 24.9,6.03 RC511.2 RC512.2 25.59,7.28 v1(25.89,7.59)
ME_FWP: length 282.9
  TOP w0.102: UE1.G12 271.44,56.4 v2(271.43,56.4)
  TOP w0.127: v2(41.08,12.15) 41.08,11.94 38.78,9.65 30.24,9.65 v1(27.88,7.28) 27.09,6.5 RC512.1 26.17,5.53 SW3.3
  IN1 w0.061: v2(41.08,12.15) 41.03,12.2 v4(41.03,12.54) ; v2(271.43,56.4) 271.43,56.73 v4(271.46,56.76)
  IN2 w0.061: v4(271.46,56.76) 271.46,56.14 271.84,55.76 271.84,55.75 273.36,54.24 273.36,47.88 268.85,43.36 267.6,43.36 266.51,42.28 265.39,42.28 264.7,41.59 263.85,41.59 262.61,40.34 257.42,40.34 255.62,38.55 238.27,38.55 217.57,17.85 212.54,17.85 212.22,17.54 202.92,17.54 201.32,15.94 183.05,15.94 179.5,12.39 152.34,12.39 152.09,12.64 133.49,12.64 132.58,13.55 132.58,15.75 131.32,17.02 128.38,17.02 126.72,17.69 123.77,17.69 123.35,17.27 114.32,17.27 109.75,12.7 103.58,12.7 103.27,13.01 101.49,13.01 101.28,12.81 97.55,12.81 97.09,12.35 57.68,12.35 56.63,13.4 53.92,13.4 53.8,13.28 53.18,13.28 52.69,12.78 48.34,12.78 48.08,13.04 44.42,13.04 44.26,12.88 41.38,12.88 v4(41.03,12.54)
MEC_XTAL1: length 4.2
  TOP w0.127: UE1.A1 262.6,61.25 262.6,62.43 CE31.1 261.63,64.64 YE1.1
MEC_XTAL2: length 2.5
  TOP w0.127: UE1.A3 264.01,61.44 264.01,61.44 263.78,61.67 263.78,62.92 264.17,63.31 RE179.1
MEC_XTAL2_R: length 2.6
  TOP w0.127: RE179.2 CE32.1 262.9,63.64 263.86,64.59 YE1.2
MEDIACARD_IRQ#: length 223.8
  TOP w0.127: v2(105.07,42.39) 105.07,42.6 RC17.2 ; v6(236.76,47.52) 236.76,46.8 v1(236.71,46.75) ; v6(291.5,43.22) 291.63,43.1 291.63,40.99 292.33,40.3 292.33,39.62 RR8.1
  IN1 w0.061: v6(269.4,46.26) 269.02,46.64 267.66,46.64 266.83,45.82 263.64,45.82 263.24,45.42 261.62,45.42 260.62,46.42 256.19,46.42 255.74,46.87 249.85,46.87 248.99,47.73 240.29,47.73 240.06,47.96 237.19,47.96 v6(236.76,47.52) ; v2(105.07,42.39) 105.12,42.44 v4(105.4,42.44)
  IN2 w0.061: v6(281.35,46.07) 284.2,46.07 286.76,43.51 286.76,42.77 287.31,42.22 290.5,42.22 v6(291.5,43.22) ; v6(236.76,47.52) 236.4,47.88 232.1,47.88 220.42,36.19 218.83,36.19 216.01,33.38 216.01,32.96 215.02,31.97 199.43,31.97 198.67,31.2 188.72,31.2 176.65,19.13 155.17,19.13 154.9,19.39 149.11,19.39 144.85,23.66 144.35,23.66 142.32,23.66 139.86,26.12 131.4,26.12 130.71,25.43 125.59,25.43 125.23,25.07 123.74,25.07 123.06,25.74 121.77,25.74 120.76,26.75 119.94,26.75 118.83,27.85 118.83,28.44 116.64,30.63 115.13,30.63 112.85,32.91 112.85,33.53 112.09,34.29 112.09,38.21 109,41.29 109,41.9 108.04,42.87 105.93,42.87 105.55,42.49 105.45,42.49 v4(105.4,42.44)
  IN3 w0.061: v5(105.4,42.79) 105.4,42.44 v4(105.4,42.44)
  BOTTOM w0.127: UCPU1.CG20 105.14,43.07 105.4,42.81 v5(105.4,42.79) ; v6(269.4,46.26) 269.59,46.45 278.08,46.45 278.46,46.07 v6(281.35,46.07)
MEM_CONFIG0: length 3.9
  BOTTOM w0.127: RH51.2 112.85,42.55 112.53,42.87 111.95,42.87 111.68,42.61 RH52.1 111.25,42.53 110.65,43.12 109.98,43.12 UCPU1.CR20
MEM_CONFIG1: length 6.3
  BOTTOM w0.127: RH53.2 112.85,41.86 112.53,42.19 112.01,42.19 111.68,41.86 RH54.1 110.49,41.84 109.84,42.49 108.44,42.49 108.12,42.81 108.12,43.12 UCPU1.CM20
MEM_CONFIG2: length 4.8
  BOTTOM w0.127: RH55.2 112.85,43.23 112.53,43.56 112.01,43.56 111.68,43.23 RH56.1 111.41,43.21 110.9,43.73 109.05,43.73 UCPU1.CN19
MEM_CONFIG3: length 5.4
  BOTTOM w0.127: RH57.2 112.85,43.92 112.53,44.24 112.01,44.24 111.68,43.92 RH58.1 111.43,43.9 110.99,44.34 108.35,44.34 UCPU1.CM19
MEM_CONFIG4: length 5.1
  BOTTOM w0.102: RH60.1 111.4,44.87 109.95,44.87 109.85,44.98 108.89,44.98 108.53,44.63 UCPU1.CN18
  BOTTOM w0.127: RH59.2 112.85,44.6 112.53,44.93 112.01,44.93 111.91,44.83 111.91,44.81 RH60.1
MEM_INTERLEAVED: length 2.2
  TOP w0.127: RC584.1 104.03,50.06 104.57,50.06 RC583.1 104.59,50.66 v1(104.84,50.91)
  IN1 w0.061: v4(104.24,50.31) 104.04,50.11 v2(103.96,50.1)
  IN3 w0.076: v5(104,50.08) v4(104.24,50.31)
MEM_SMBCLK: length 27.7
  IN1 w0.061: v4(117.54,31.79) 117.51,31.77 117.31,31.77 114.9,34.18 114.53,34.18 110.77,37.94 110.77,41.89 110.27,42.39 110.27,44.11 108.44,45.94 108.44,46.44 107.77,47.11 106.94,47.11 106.87,47.19 106.87,47.25 106.91,47.3 v4(107.32,47.63)
  IN3 w0.061: v4(117.54,31.79) 117.54,32.2 v5(117.56,32.23)
  IN3 w0.076: v5(107.09,47.39) v4(107.32,47.63)
  BOTTOM w0.127: RC388.1 120.78,33 120.4,32.62 QC1.6 119.45,32.62 RC18.1 119.23,33.33 118.81,33.75 v1(118.62,33.75) 118.3,33.75 117.56,33.01 v5(117.56,32.23)
MEM_SMBDATA: length 31
  IN1 w0.061: v4(118.07,31.79) 117.71,31.43 117.39,31.43 117.36,31.46 117.35,31.46 114.82,33.99 114.45,33.99 110.58,37.87 110.58,41.81 110.09,42.31 110.09,44.03 108.26,45.86 108.26,46.36 107.69,46.92 106.7,46.92 106.64,47 106.55,47.01 v4(106.02,46.59)
  IN3 w0.061: v5(118.02,32.21) 118.07,32.16 v4(118.07,31.79)
  IN3 w0.076: v5(105.79,46.35) v4(106.02,46.59)
  BOTTOM w0.127: QC1.3 121.34,31.62 120.92,31.2 118.24,31.2 118.02,31.42 RC387.1 118.16,31.72 118.16,32.07 v5(118.02,32.21) 118,32.21 117.69,31.91 117.4,31.91 117.25,32.06 v1(117.25,34.16)
MIC2-VREFO-L: length 3.4
  TOP w0.203: RA33.1 288.77,20.97 288.01,21.74 288.01,22.07 287.06,23.02 UA1.28
MIC2-VREFO-R: length 3.6
  TOP w0.203: UA1.29 287.14,23.42 287.26,23.3 287.26,23.3 287.64,22.92 288.17,22.92 v1(288.19,22.9) 288.47,22.62 288.47,21.98 288.84,21.61 RA34.1
MIPI_CLK: length 146.8
  TOP w0.127: v6(256.71,68.47) v1(256.71,69.14)
  IN2 w0.061: v6(256.71,68.47) 256.71,65.42 257.06,65.07 257.06,64.99 260.62,61.44 270.68,61.44 270.76,61.35 271.27,61.35 272.42,62.51 273.8,62.51 276.54,65.24 v6(276.54,66.75)
  IN3 w0.061: v5(199.77,71.79) 199.93,71.62 206.16,71.62 206.22,71.68 v5(206.22,71.88) 206.77,72.43 219.39,72.43 221.08,74.12 224.25,74.12 224.87,74.74 239.22,74.74 243.03,70.92 251.78,70.92 255.03,67.67 256.44,67.67 256.71,67.94 v6(256.71,68.47) ; v5(279.58,35.02) 279.14,35.45 279.14,51.78 278,52.93 278,64.66 276.54,66.12 v6(276.54,66.75)
  BOTTOM w0.051: v5(199.77,71.79) 199.71,71.79 199.43,72.07 JLTE2.2
  BOTTOM w0.127: JLTE1.4 206.23,71.88 v5(206.22,71.88) ; v6(256.71,68.47) 255.61,69.56 246.35,69.56 T149.1 ; v5(279.58,35.02) 279.93,35.02 280.14,34.82 280.14,34.37 279.81,34.05 273.56,34.05 271.9,32.39 JNGFF1.58
MIPI_DATA: length 142.4
  TOP w0.127: v6(256.27,68.02) v1(256.27,67.09)
  IN2 w0.061: v6(256.27,68.02) 256.27,65.68 256.93,65.02 256.93,64.94 260.57,61.31 270.62,61.31 270.71,61.22 271.32,61.22 272.48,62.38 273.85,62.38 276.89,65.42 v6(276.89,66.29)
  IN3 w0.061: v6(256.27,68.02) 255.09,68.02 252.06,71.04 243.08,71.04 239.27,74.86 224.82,74.86 224.2,74.24 221.03,74.24 219.35,72.56 206.54,72.56 v5(205.86,71.88) 205.29,72.45 200.55,72.45 v5(200.07,71.97) ; v6(276.89,66.29) 278.12,65.07 278.12,52.98 279.27,51.83 279.27,35.71 279.86,35.12 279.86,34.92 v5(279.58,34.64)
  BOTTOM w0.127: JNGFF1.56 271.4,32.25 273.49,34.35 279.28,34.35 v5(279.58,34.64) ; v5(205.86,71.88) 205.88,71.9 JLTE1.5 ; v6(256.27,68.02) 255.11,69.18 T150.1 ; JLTE2.1 199.78,72.2 200.01,71.96 200.06,71.96 200.06,71.97 v5(200.07,71.97)
MODE_PRIM_CORE: length 2.2
  TOP w0.127: v2(125.17,46.2) v3(126.47,46.2)
  IN1 w0.254: v4(125.22,46.74) 125.22,46.25 v2(125.17,46.2)
  IN3 w0.254: v5(125.55,46.74) 125.22,46.74 v4(125.22,46.74)
MODE_VCCIO: length 3.2
  BOTTOM w0.254: PU1400.7 103.6,20.2 103.44,20.35 102.44,20.35 101.43,21.35 PR1408.1
MONO_IN: length 6.8
  TOP w0.127: UA1.34 287,25.42 287.13,25.56 287.54,25.56 v1(287.87,25.23) 287.97,25.13 v6(288.43,25.13) ; CA1.2 v6(291.87,25.72)
  BOTTOM w0.127: v6(288.43,25.13) 289.48,26.18 291.41,26.18 v6(291.87,25.72)
MSCLK: length 51.3
  TOP w0.102: UE1.H10 269.41,56.03 v2(269.41,56.05)
  TOP w0.127: v6(234.31,70.29) 234.81,69.79 235.43,69.79 235.88,70.24 v1(235.88,71.18) 235.88,71.23 235.48,71.62 RE97.1 RE91.2
  IN1 w0.061: v2(269.41,56.05) 269.41,56.64 268.66,57.39 268.66,59.52 267.71,60.47 267.71,60.74 266.8,61.65 264.08,61.65 263.57,62.16 262.63,62.16 261.7,63.09 255.74,63.09 255.41,62.76 250.57,62.76 248.23,65.1 245.97,65.1 240.83,70.24 235.83,70.24 235.25,69.67 234.3,69.67 234.12,69.85 234.12,70.09 v6(234.31,70.29)
  BOTTOM w0.127: JDEG1.6 234.63,71.77 234.5,71.65 234.5,71.25 234.15,70.89 234.15,70.45 v6(234.31,70.29)
MSDATA: length 51.1
  TOP w0.127: RE94.2 RE95.1 v6(233.73,70.29) 233.32,69.88 231.18,69.88 v1(230.92,70.14)
  IN1 w0.061: v6(233.73,70.29) 233.93,70.09 233.93,69.77 234.22,69.48 235.33,69.48 235.9,70.05 240.75,70.05 245.89,64.91 248.15,64.91 250.49,62.57 255.49,62.57 255.82,62.9 261.62,62.9 262.55,61.97 263.5,61.97 264,61.47 266.72,61.47 267.52,60.66 267.52,60.39 268.48,59.44 268.48,57.27 269.04,56.71 v2(269.04,56.41)
  BOTTOM w0.127: JDEG1.7 234.13,71.81 234.25,71.68 234.25,71.35 233.89,71 233.89,70.45 v6(233.73,70.29)
NB_MODE#: length 12.7
  TOP w0.102: v2(267.05,55.42) 267.05,55.23 UE1.J6
  IN1 w0.061: v2(267.05,55.42) 267.17,55.3 268.01,55.3 268.34,54.97 268.34,54.37 268.68,54.03 269.79,54.03 270.5,53.32 270.5,51.19 270.15,50.84 269.32,50.84 268.25,49.77 268.25,48.43 267.97,48.15 v2(267.44,48.15)
NB_MUTE#: length 56
  TOP w0.127: v2(265.26,63.06) 265.26,61.68 265.2,61.62 265.2,61.37 UE1.A4 ; RA120.1 RA117.2 275.67,26.88 DA27.1 274.98,28.33 274.98,29.27 278.21,32.49 v1(278.21,33.36) v2(278.21,34.28)
  IN1 w0.061: v4(276.64,63.66) 276.05,64.24 275.36,64.24 273.34,62.22 272.02,62.22 271.15,61.36 268.81,61.36 267.39,62.78 265.54,62.78 v2(265.26,63.06) ; v4(277.82,34.28) v2(278.21,34.28)
  IN3 w0.061: v4(276.64,63.66) 277.23,63.06 277.23,52.39 278.32,51.3 278.32,34.78 v4(277.82,34.28)
NFC_ACTIVITY_STATUS#: length 90.3
  IN3 w0.061: v5(267.3,16.34) 266.97,16.02 254.09,16.02 249.37,11.3 224.92,11.3 224.22,12.01 221.54,12.01 221.16,11.63 202.34,11.63 v5(202.04,11.93)
  BOTTOM w0.127: v5(202.04,11.93) 199.72,11.93 198.98,12.67 v1(198.98,13.99) 198.98,17.7 199.6,18.32 199.6,20.68 197.1,23.18 194.88,23.18 194.54,22.84 RP12.1 194.54,21.82 194.64,21.72 Q13.3 ; v5(267.3,16.34) 267.3,17.08 266.06,18.32 JUSH1.25
NFC_STATUS#: length 12.6
  IN1 w0.061: v4(198.85,21.25) v2(199.48,21.25)
  IN3 w0.061: v5(197.84,21.66) 198.44,21.66 v4(198.85,21.25)
  BOTTOM w0.127: Q13.4 197.37,21.72 RP9.2 ; RP9.2 197.75,21.75 v5(197.84,21.66) 197.84,20.96 197.15,20.28 196.51,20.28 195.68,19.45 DP2.1 194.63,18.14 JTP1.8 ; RP9.2 197.4,22.17 197.06,22.5 RP16.2 196.32,22.78 196.21,22.88 195.21,22.88 195.12,22.79 RP12.2
NGFF_CONFIG_0: length 62.4
  TOP w0.127: v1(248.33,50.44) 248.71,50.06 v6(248.71,49.57) ; RE502.1 268.58,50.59 268.48,50.69 268.48,50.95 v2(268.25,51.17) 268.3,51.22 268.65,51.22 UE1.N9
  IN1 w0.061: v6(248.71,49.57) 249.53,50.39 251,50.39 251.74,49.65 261.59,49.65 262.92,50.99 263.35,50.99 263.46,51.1 263.88,51.1 263.99,50.99 265.08,50.99 265.33,50.73 267.58,50.73 268.02,51.17 v2(268.25,51.17)
  BOTTOM w0.127: JNGFF1.21 262.65,23.37 262.28,23 255.89,23 255.12,23.77 255.12,26.71 254.65,27.18 254.65,28.77 253.53,29.9 252.98,29.9 251.38,31.5 251.38,33.28 249.22,35.45 249.22,49.07 v6(248.71,49.57)
NGFF_CONFIG_1: length 75.8
  TOP w0.127: UE1.M10 270.3,51.94 270.3,51.34 v2(270.23,51.28) 270.23,50.45 270.55,50.13 RE504.1 ; v6(254.99,30.21) v1(253.19,28.41) 252.33,27.55 UN1.9
  IN1 w0.061: v6(249.61,49.55) 249.99,49.17 250.42,49.17 250.48,49.23 258.23,49.23 259.21,48.25 264.84,48.25 266.05,49.46 267.77,49.46 269.29,50.98 270.01,50.98 270.23,51.2 v2(270.23,51.28)
  BOTTOM w0.127: JNGFF1.69 274.65,24.9 272.7,26.85 264.05,26.85 262.95,27.95 260.03,27.95 257.78,30.21 v6(254.99,30.21) 253.1,30.21 251.64,31.67 251.64,33.38 249.49,35.53 249.49,49.44 v6(249.61,49.55)
NGFF_CONFIG_2: length 73.7
  TOP w0.127: v6(250.19,49.55) 249.57,48.93 v1(249.16,48.93) ; RE501.1 270.19,48.44 270.19,49.76 269.87,50.08 v2(269.87,51.22) 269.84,51.26 UE1.N10
  IN1 w0.061: v6(250.19,49.55) 250.38,49.35 258.28,49.35 259.25,48.38 264.06,48.38 264.06,48.38 264.79,48.38 266,49.58 267.71,49.58 269.36,51.22 v2(269.87,51.22)
  BOTTOM w0.127: v6(250.19,49.55) 250.96,48.77 250.96,47.34 249.74,46.12 249.74,35.64 251.89,33.49 251.89,31.78 252.74,30.92 257.42,30.92 260.14,28.2 263.06,28.2 264.16,27.1 272.8,27.1 274.81,25.1 275.73,25.1 276.15,24.68 JNGFF1.75
NGFF_CONFIG_3: length 55.1
  TOP w0.102: UE1.F4 265.04,57.32 v2(264.59,57.76)
  IN1 w0.061: v2(259.19,58.13) 259.46,57.86 261.56,57.86 261.91,58.21 261.91,58.54 262.42,59.05 263.08,59.05 263.47,58.65 263.96,58.65 264.59,58.02 v2(264.59,57.76) 264.59,57.76 263.96,57.76 v4(263.91,57.7)
  IN3 w0.061: v5(257.65,25.12) 258.13,24.64 260.59,24.64 260.96,25.01 262.27,25.01 262.92,25.66 263.73,25.66 267.97,29.9 267.97,32.35 269.26,33.65 269.26,35.24 269.38,35.36 269.38,41.83 269.12,42.09 269.12,44.77 267.85,46.04 267.85,48.25 268.43,48.83 269.32,48.83 269.57,49.09 269.57,52.13 268.83,52.87 268.37,52.87 266.43,54.81 266.13,54.81 263.91,57.03 v4(263.91,57.7)
  BOTTOM w0.127: JNGFF1.1 v5(257.65,25.12)
NRB_BIT: length 3.1
  TOP w0.127: v6(104.25,38.17) 104.05,38.37 v1(104.05,38.75) RC45.1 RC607.1
  BOTTOM w0.127: UCPU1.CE29 v6(104.25,38.17)
OT_1.2V_DDR: length 1.4
  BOTTOM w0.254: PU600.19 46.98,26.62 PR600.1
OVP_FAULT: length 220.6
  TOP w0.127: PU1500.1 v2(85.13,72.86) ; v2(20.36,8.02) 20.13,8.25 PQ1500.2
  IN1 w0.061: v4(65.54,74.49) 65.67,74.62 65.67,75.3 66.2,75.84 69,75.84 70.14,74.69 71.94,74.69 73.49,76.24 74.48,76.24 74.61,76.12 74.61,75.33 75.37,74.57 76.87,74.57 77.46,73.98 81.01,73.98 82.29,75.27 v2(83.03,75.27) 83.69,75.27 85.13,73.82 v2(85.13,72.86) 85.6,72.86 85.81,73.07 85.81,75.45 86.27,75.91 87.46,75.91 88.3,75.08 88.68,75.08 91.35,72.41 94.4,72.41 97.95,75.96 107.23,75.96 107.48,75.71 107.48,72.6 110.39,69.69 110.39,69.37 110.78,68.98 114.29,68.98 114.85,68.42 114.85,64.93 116.78,63 v4(118.54,63) ; v2(20.36,8.02) 22.94,8.02 23.57,8.65 23.57,10.64 24.18,11.26 24.18,13.23 23.13,14.28 v4(23.13,16.21)
  IN2 w0.061: v4(118.54,63) 117.69,62.15 117.69,50.51 118.06,50.15 118.06,49.3 118.69,48.68 119.33,48.68 120.19,47.82 120.19,44.92 121.22,43.88 123.31,43.88 126.18,41.02 126.65,41.02 128.09,39.58 v4(128.09,39.3) ; v4(39.86,26.9) 39.6,27.17 36.86,27.17 33.59,30.44 33.59,33.94 35.88,36.23 35.88,36.51 36.19,36.82 36.19,42.9 38.5,45.21 38.5,48.17 39.48,49.15 39.48,50.29 40.26,51.08 40.26,51.94 39.88,52.32 39.88,53.39 41.1,54.61 41.1,59.99 41.08,60.02 41.08,61.03 41.23,61.18 41.86,61.18 41.96,61.28 41.96,61.92 42.44,62.4 42.44,63.41 45.21,66.18 45.45,66.18 46.25,66.97 46.25,67.9 45.59,68.56 45.59,68.89 45.98,69.29 46.86,69.29 47.95,70.38 48.73,70.38 49.16,70.81 51.26,70.81 51.98,71.54 56.71,71.54 57.2,71.05 62.64,71.05 64.76,73.18 64.76,73.94 65.32,74.49 v4(65.54,74.49)
  IN3 w0.061: v5(128.41,39.12) 128.27,39.12 v4(128.09,39.3) ; v4(39.86,26.9) 39.86,21.17 33.96,15.26 25.05,15.26 24.69,15.63 23.71,15.63 v4(23.13,16.21)
  BOTTOM w0.127: v1(128.33,37.74) 128.33,39.05 v5(128.41,39.12) 128.42,39.11 PD1504.2
P_SENSOR_PWR_SAVE#: length 65
  TOP w0.127: v2(128.48,28.08) 128.69,28.29 128.69,29.17 v3(129.17,29.65)
  IN1 w0.061: v2(128.48,28.08) 128.43,28.03 v4(128.43,27.59)
  IN2 w0.061: v4(109.02,48.8) 109.02,48.54 109.21,48.35 110.18,48.35 110.44,48.61 112.31,48.61 113.73,47.19 115.28,47.19 116.79,45.69 116.79,45.03 118.54,43.27 119.45,43.27 120.56,42.16 121.55,42.16 128.81,34.91 128.81,28.2 128.43,27.83 v4(128.43,27.59)
  IN3 w0.061: v5(109.04,48.46) 109.04,48.78 v4(109.02,48.8) ; v4(128.43,27.59) 128.43,27.32 v5(128.29,27.18)
  BOTTOM w0.076: 110.2,49 109.91,48.71 109.58,48.71 109.56,48.7 109.5,48.67 109.29,48.46 v5(109.04,48.46)
  BOTTOM w0.127: JCAM1.4 132.77,21.04 132.57,20.85 132.57,20.1 131.7,19.22 130.05,19.22 129.27,20 122.96,20 122.54,20.41 122.54,25.69 124.04,27.18 128.29,27.18 v5(128.29,27.18) ; RC596.2 111.47,50.27 110.2,49
PA_USB2_RBIAS: length 0.7
  IN1 w0.076: v4(21.4,48.79) v2(21.63,48.55)
  IN3 w0.076: v5(21.63,49.02) v4(21.4,48.79)
PANEL_BKEN_EC: length 338.3
  TOP w0.102: UE1.J9 v2(269.04,54.81)
  TOP w0.127: DV2.3 41.61,66.12 v2(40.35,67.38)
  IN1 w0.061: v4(269.38,54.85) 269.08,54.85 v2(269.04,54.81) ; v2(40.35,67.38) 40.26,67.47 v4(39.85,67.47)
  IN2 w0.061: v4(269.38,54.85) 269.38,54.39 269.85,53.92 271.08,53.92 271.78,53.22 271.78,47.38 268.52,44.12 267.28,44.12 266.2,43.03 264.22,43.03 262.3,41.11 256.31,41.11 255.66,40.46 255.55,40.46 254.64,40.46 253.49,39.31 237.96,39.31 217.26,18.61 212.22,18.61 211.91,18.29 202.61,18.29 201,16.69 182.74,16.69 179.19,13.15 152.65,13.15 152.4,13.4 133.82,13.4 133.35,13.87 133.35,16.06 131.63,17.77 128.53,17.77 126.75,18.5 123.51,18.5 123.03,18.03 114.01,18.03 109.44,13.46 103.89,13.46 103.59,13.77 101.12,13.77 100.92,13.57 97.23,13.57 96.77,13.11 58,13.11 56.92,14.18 53.63,14.18 53.48,14.03 52.87,14.03 52.37,13.54 49.11,13.54 46.06,16.59 40.58,16.59 40.12,16.13 28.81,16.13 27.43,17.52 26.64,17.52 26.33,17.52 24.27,19.58 24.27,22.33 24.49,22.56 24.96,22.56 24.96,22.56 25.17,22.56 25.17,22.56 25.27,22.56 28.06,25.34 28.06,29.66 28.35,29.95 28.35,35.16 30.42,37.23 30.42,39.44 32.43,41.45 32.43,43.29 34.58,45.43 34.58,48.47 35.41,49.31 35.41,53.41 35.68,53.68 35.68,54.27 36.53,55.12 36.53,62.6 36.81,62.87 36.81,63.21 38.95,65.35 38.95,66.79 39.64,67.48 39.84,67.48 v4(39.85,67.47)
PANEL_BKLEN: length 172.6
  TOP w0.127: v2(42.33,67.44) 42.3,67.42 DV2.2 ; CC258.1 106.49,31.55 107.05,32.11 107.05,32.52 v1(107,32.57) 106.64,32.93 106.64,33.26 v2(106.72,33.34)
  IN1 w0.061: v2(106.72,33.34) 106.97,33.59 107.17,33.59 107.17,33.6 v4(107.18,33.6) ; v2(42.33,67.44) 42.37,67.48 v4(42.88,67.48)
  IN2 w0.061: v4(104.74,48.05) 104.74,47.81 104.19,47.26 103.71,47.26 103.57,47.12 103.57,44.11 103.73,43.94 104.09,43.94 104.36,43.67 104.36,42.56 104.52,42.4 104.52,42 104,41.48 104,39.86 104.61,39.25 104.61,37.71 104.67,37.65 104.67,36.9 106.74,34.83 106.74,34.04 v4(107.18,33.6) ; v4(42.88,67.48) 42.88,66.49 40.59,64.19 40.59,63.17 39.8,62.38 39.8,59.5 38.58,58.27 38.58,57.78 39.32,57.04 39.32,54.81 37.69,53.18 37.69,51.14 38.07,50.76 38.07,49.8 37.76,49.48 37.76,49 37.67,48.91 37.67,45.56 34.47,42.35 34.47,41.24 34.79,40.92 34.79,37.4 34.48,37.09 34.48,36.88 30.36,32.76 30.36,29.03 30.06,28.74 30.06,24.88 34.07,20.88 35.28,20.88 35.76,21.35 38.27,21.35 38.6,21.02 40.86,21.02 41.63,20.24 41.63,19.58 42.02,19.2 47.15,19.2 49.65,16.7 51.39,16.7 52.02,17.33 53.31,17.33 53.71,16.93 54.11,16.93 95.41,16.93 97.58,19.1 101.33,19.1 103.34,21.11 105.92,21.11 106.16,21.35 106.62,21.35 106.88,21.09 107.32,21.09 v4(107.35,21.12)
  IN3 w0.061: v5(104.79,48.76) 104.79,48.1 v4(104.74,48.05) ; v4(107.18,33.6) 107.58,33.2 v5(107.58,32.4) 107.58,31.61 108.63,30.56 108.63,27.62 107.91,26.89 107.91,26.55 107.35,25.99 107.35,21.12 v4(107.35,21.12)
  BOTTOM w0.127: v5(104.79,48.76) 105.62,48.76 105.95,49.09 106.75,49.09 UCPU1.CK11 ; UCPU1.CM35 107.81,33.06 107.58,32.84 v5(107.58,32.4)
PANEL_PWRGD: length 345.5
  TOP w0.102: UE1.M8 v2(268.23,52.41)
  TOP w0.127: v2(52.51,58.36) 53.16,58.36 53.8,57.72 v1(56.44,57.72) 57.59,57.72 59.22,56.09 60.68,56.09 62.04,57.45 67.71,57.45 71.25,60.99 RV42.2 ; v2(38.3,45.42) 38.05,45.68 38.05,49.05 38.04,49.07 38.04,52.52 38.24,52.72 v2(38.24,55.16)
  IN1 w0.061: v2(268.23,52.41) 268.55,52.41 v4(268.58,52.44) ; v2(38.24,55.16) 38.56,55.48 42.9,55.48 43.48,56.06 45.12,56.06 45.24,56.18 47.58,56.18 47.64,56.24 51.67,56.24 52.52,57.09 52.52,58.35 v2(52.51,58.36) ; v2(38.3,45.42) 38.04,45.69 v4(35.74,45.69)
  IN2 w0.061: v4(35.74,45.69) 35.74,45.4 33.26,42.92 33.26,41.1 31.8,39.65 31.8,39.49 31.8,37.44 29.18,34.81 29.18,29.61 28.89,29.32 28.89,24.36 34.65,18.6 37.57,18.6 37.85,18.88 39.35,18.88 40.62,17.61 46.47,17.61 49.53,14.55 51.95,14.55 52.44,15.05 53.06,15.05 53.22,15.21 58.19,15.21 59.28,14.12 74.72,14.12 75.41,14.82 80.06,14.82 80.7,14.19 88.98,14.19 89.51,14.72 97.28,14.72 97.42,14.58 99.93,14.58 101.1,15.76 103.1,15.76 104.38,14.48 109.02,14.48 113.58,19.04 122.61,19.04 123.09,19.52 126.95,19.52 128.73,18.79 132.06,18.79 133.71,17.14 144.31,17.14 147.01,14.43 152.81,14.43 153.08,14.16 178.71,14.16 183.86,19.31 211.48,19.31 214.85,22.68 219.71,22.68 237.88,40.85 250.78,40.85 253.8,43.87 257.14,43.87 257.41,43.6 263.15,43.6 263.72,44.18 265.6,44.18 267.36,45.94 267.36,48.09 268.26,48.99 268.26,51.36 268.69,51.79 268.69,52.32 v4(268.58,52.44)
PANEL_PWRGD_R: length 18.5
  TOP w0.127: QV7.1 70.86,63.46 71.11,63.21 71.11,62.75 70.64,62.28 CV39.1 70.64,61.93 RV44.1 RV40.2 RV42.1 70.66,61.12 69,59.45 59.85,59.45 v1(59.1,60.21) 58.65,60.66 58.65,61.7 QV5.1
PB_USB2_RBIAS: length 0.7
  IN1 w0.076: v4(20.75,48.79) v2(20.98,48.55)
  IN3 w0.076: v5(20.98,49.02) v4(20.75,48.79)
PBAT_CHARGER_SMBCLK: length 316.4
  TOP w0.127: UE1.N2 263.44,51.57 262.44,50.58 261.72,50.58 261.08,49.94 261.08,49.51 v2(260.9,49.33) ; PR214.1 23.32,17.03 22.64,17.03 v6(22.49,16.88) ; v2(40.59,20.82) 40.8,20.82 41,20.61 41,20.35 41.44,19.92 41.44,19.57 41.32,19.45 41.01,19.45 v2(40.75,19.7)
  IN1 w0.061: v4(40.34,19.66) 40.34,19.66 40.42,19.58 40.63,19.58 v2(40.75,19.7) ; v4(130.38,11.8) 130.56,11.98 130.56,12.27 130.01,12.82 130.01,14.2 127.89,16.33 124.36,16.33 122.9,14.86 120.09,14.86 114.77,9.54 54.18,9.54 51.2,12.52 48.45,12.52 41.02,19.94 41.02,20.39 40.96,20.45 40.96,20.45 v2(40.59,20.82) ; v2(260.9,49.33) v4(260.9,48.97)
  IN2 w0.061: v6(248.09,11.78) 248.19,11.78 248.3,11.89 248.3,12.02 248.16,12.15 244.85,12.15 242.82,10.13 225.55,10.13 224.03,11.65 209.28,11.65 206.79,14.13 203.7,14.13 201.74,12.17 186.49,12.17 186.41,12.17 186.03,12.17 184.74,10.88 151.71,10.88 151.46,11.13 130.87,11.13 130.56,11.45 130.56,11.62 v4(130.38,11.8)
  IN3 w0.061: v4(40.34,19.66) 40.18,19.5 38.72,19.5 34.12,14.9 23.6,14.9 21.97,16.53 21.97,16.95 22.1,17.08 22.28,17.08 v6(22.49,16.88) ; v4(260.9,48.97) 261.08,48.78 261.08,48.29 260.86,48.06 256.71,48.06 251.52,53.24 248.82,53.24 248.75,53.31 v5(248.75,53.35)
  BOTTOM w0.127: v5(248.75,53.35) 248.65,53.24 247.41,53.24 245.29,51.12 245.29,38.85 246.4,37.73 246.4,35.22 248.51,33.11 248.51,32.01 249.08,31.43 249.08,28.87 250.71,27.25 250.71,16.81 248.26,14.36 248.26,11.94 v6(248.09,11.78)
PBAT_CHARGER_SMBDAT: length 318.4
  TOP w0.127: v2(41.59,20.82) 41.4,20.82 41.25,20.67 41.25,20.46 41.69,20.02 v7(41.69,19.7) 41.69,19.46 41.43,19.2 41.01,19.2 v2(40.75,18.94) ; UE1.M3 263.84,52.01 263.84,51.39 263.65,51.2 263.42,51.2 262.55,50.33 261.83,50.33 261.33,49.83 261.33,49.47 v2(261.47,49.33) ; PR213.1 23.26,17.29 22.68,17.29 22.46,17.51 22.46,17.49 v6(22.47,17.49)
  IN1 w0.061: v2(40.75,18.94) 40.57,19.12 v4(40.34,19.12) ; v2(261.47,49.33) v4(261.47,48.99) ; v4(130.92,11.8) 130.86,11.8 130.75,11.92 130.75,12.35 130.2,12.9 130.2,14.28 127.96,16.51 124.28,16.51 122.82,15.05 120.01,15.05 114.69,9.73 54.26,9.73 51.28,12.71 48.53,12.71 41.21,20.02 41.21,20.43 v2(41.59,20.82)
  IN2 w0.061: v6(248.68,11.78) 248.48,11.97 248.48,12.1 248.24,12.34 244.77,12.34 242.75,10.32 225.63,10.32 224.11,11.83 209.35,11.83 206.87,14.32 203.62,14.32 201.66,12.36 186.49,12.36 185.96,12.36 184.66,11.07 151.79,11.07 151.54,11.32 130.95,11.32 130.75,11.52 130.75,11.63 v4(130.92,11.8)
  IN3 w0.061: v4(40.34,19.12) 40.15,19.31 38.8,19.31 34.19,14.71 23.53,14.71 21.78,16.45 21.78,17.03 22.03,17.27 22.25,17.27 v6(22.47,17.49) ; v4(261.47,48.99) 261.27,48.8 261.27,48.21 260.93,47.87 256.63,47.87 251.44,53.06 248.86,53.06 v5(248.74,52.94)
  BOTTOM w0.127: v6(248.68,11.78) 248.51,11.94 248.51,14.26 250.96,16.71 250.96,27.35 249.34,28.98 249.34,31.54 248.77,32.11 248.77,33.22 246.66,35.32 246.66,37.84 245.54,38.96 245.54,51.02 247.51,52.99 248.69,52.99 v5(248.74,52.94)
PBAT_PRES#: length 20.8
  TOP w0.102: v2(270.71,56.81) 269.49,56.81 269.1,57.21 UE1.F9
  TOP w0.127: QE26.1 276.85,52.34 277.16,52.65 RE518.2 277.85,52.85 v1(278.17,53.17) v2(278.56,53.56)
  IN1 w0.061: v2(270.71,56.81) 270.79,56.74 270.79,56.66 271.3,56.15 272.75,56.15 273.62,57.01 275.91,57.01 276.15,57.24 276.15,57.51 276.55,57.92 277.9,57.92 278.75,58.77 279.5,58.77 279.7,58.57 279.7,54.57 278.69,53.56 v2(278.56,53.56)
PCH_3.3V_TS_EN: length 156.2
  TOP w0.127: R223.1 48.56,68.87 46.77,67.08 v1(46.25,67.08) v2(45.48,67.08)
  IN1 w0.061: v4(43.51,67.49) 43.71,67.49 44.44,67.21 45.46,67.07 v2(45.48,67.08)
  IN2 w0.061: v4(105.89,23.85) 106.34,23.85 106.85,23.34 106.85,22.45 106.51,22.12 105.54,22.12 104.96,21.53 103.22,21.53 101.18,19.48 97.43,19.48 95.25,17.31 53.86,17.31 53.47,17.71 51.86,17.71 51.23,17.08 49.8,17.08 47.31,19.58 42.18,19.58 42.02,19.74 42.02,20.4 41.02,21.4 38.76,21.4 38.42,21.74 35.6,21.74 35.12,21.26 34.23,21.26 30.45,25.04 30.45,28.57 30.74,28.86 30.74,32.6 34.86,36.72 34.86,36.93 35.17,37.24 35.17,41.08 34.85,41.4 34.85,42.19 38.05,45.4 38.05,48.75 38.14,48.84 38.14,49.32 38.45,49.64 38.45,50.92 38.08,51.3 38.08,53 39.71,54.63 39.71,56.67 40.08,57.04 40.08,59.57 40.05,59.6 40.05,62.28 40.84,63.07 40.84,64.08 43.51,66.74 v4(43.51,67.49)
  IN3 w0.061: v5(102.87,37.04) 102.87,36.96 102.04,36.14 102.04,31.9 101.64,31.49 101.64,30.69 102.41,29.91 102.41,29.27 102.65,29.03 102.65,28.75 102.48,28.57 102.48,27.26 103.96,25.78 105.31,25.78 105.73,25.37 105.73,24.01 v4(105.89,23.85)
PCH_BATLOW#: length 4.6
  BOTTOM w0.076: UCPU1.BV36 99.96,31.58 100.49,31.05 100.49,29.13 RC80.1
PCH_CL_CLK1: length 142.9
  IN3 w0.061: v5(214.86,33.8) 215.01,33.65 215.01,33.55 214.9,33.44 212.12,33.44 211.8,33.12 211.04,33.12 206.14,28.23 202.29,28.23 199.35,25.29 190.49,25.29 188.68,23.48 188.63,23.42 188.61,23.41 187.18,21.91 185.6,20.47 180.25,16.93 179.07,16.36 172.58,13.5 169.42,13.04 155.3,13.04 155.28,13.04 155.22,13.05 154.42,13.24 153.85,13.38 152.76,13.76 151.12,14.29 149.1,14.86 148.48,15 146.68,15.68 146.23,15.88 144.47,16.74 142.99,17.6 142.92,17.65 141.63,18.58 141.07,18.96 139.59,20.13 136.96,22.41 135.42,23.95 134.9,24.42 133.55,25.8 132.64,26.63 130.73,28.6 129.63,29.22 129.41,29.33 128.8,29.47 126.81,30.65 124.99,30.65 124.42,31.22 117.58,31.22 116.93,31.87 116.93,32.01 113.55,35.39 113.55,37.61 112.33,38.83 112.33,41.14 112.18,41.29 112.18,43.65 111.5,44.33 111.5,46.5 110.08,47.92 110.08,48.9 109.67,49.31 109.13,49.31 108.89,49.55 108.44,49.55 106.95,51.05 106.29,51.05 v5(106.26,51.02)
  BOTTOM w0.127: JNGFF3.42 216.89,30.05 216.75,30.19 215.95,30.19 214.97,31.17 214.97,33.69 v5(214.86,33.8) ; v5(106.26,51.02) 106.2,51.2 UCPU1.CH7
PCH_CL_DATA1: length 142.6
  IN3 w0.061: v5(106.22,50.24) 106.26,50.29 107.44,50.29 108.36,49.37 108.81,49.37 109.05,49.13 109.59,49.13 109.9,48.82 109.9,47.84 111.31,46.42 111.31,44.25 111.99,43.58 111.99,41.22 112.14,41.06 112.14,38.75 113.36,37.53 113.36,35.31 116.74,31.93 116.74,31.79 117.5,31.03 124.34,31.03 124.91,30.47 126.76,30.47 128.73,29.29 129.35,29.15 129.54,29.05 130.62,28.45 132.51,26.49 133.42,25.67 134.77,24.29 135.29,23.81 136.83,22.27 139.47,19.98 140.96,18.81 141.52,18.42 142.82,17.49 142.9,17.44 144.38,16.58 146.15,15.7 146.61,15.51 148.42,14.82 149.06,14.68 151.06,14.11 152.7,13.58 153.79,13.2 154.38,13.06 155.18,12.87 155.25,12.86 155.29,12.85 169.44,12.85 172.63,13.31 179.15,16.19 180.34,16.77 185.72,20.32 187.32,21.77 188.75,23.28 188.76,23.29 188.82,23.35 190.57,25.1 199.43,25.1 202.36,28.04 206.22,28.04 211.11,32.93 211.88,32.93 212.2,33.25 214.97,33.25 215.19,33.47 215.19,33.65 v5(215.34,33.8)
  BOTTOM w0.127: v5(215.34,33.8) 215.22,33.68 215.22,31.27 216.05,30.44 216.75,30.44 216.86,30.55 JNGFF3.40 ; UCPU1.CH8 105.84,50.63 106.16,50.27 106.19,50.27 v5(106.22,50.24)
PCH_CL_RST1#: length 158.9
  IN2 w0.061: v4(106.14,49.76) 105.59,49.22 105.27,49.22 105.05,49 105.05,48.68 105.52,48.21 106,48.21 107.18,47.03 107.53,47.03 108.29,46.27 108.29,45.92 109.01,45.2 113.95,45.2 118.87,40.28 120.77,40.28 124.34,36.71 124.34,29.25 123.82,28.73 123.82,27.23 124.16,26.88 v4(124.16,26.32)
  IN3 w0.061: v4(106.14,49.76) 106.19,49.76 106.33,49.9 v5(106.44,49.9) ; v5(140.47,13.87) 138.86,13.87 136.53,16.2 135.11,16.2 133.79,17.52 132.91,17.52 131.97,18.46 131.24,18.46 130.07,19.63 130.07,20.86 128.81,22.12 127.28,22.12 124.04,25.35 124.04,26.2 v4(124.16,26.32)
  BOTTOM w0.127: JNGFF3.38 218.5,31.05 220.37,29.18 220.37,23.03 217.24,19.91 213.9,19.91 212.83,18.84 203.47,18.84 197.7,24.61 187.72,24.61 v1(186.47,23.36) 177.44,14.32 140.91,14.32 v5(140.47,13.87) ; v5(106.44,49.9) 106.33,49.9 106.33,49.9 106.03,49.9 UCPU1.CH9
PCH_DMIC_CLK0: length 45.8
  IN2 w0.061: v4(129.35,26.23) 129.46,26.12 129.46,26.03 129.34,25.91 125.39,25.91 125.03,25.55 124.08,25.55 123.3,26.32 122.01,26.32 121.1,27.23 120.16,27.23 119.41,27.97 119.41,28.68 116.95,31.14 115.31,31.14 114.02,32.43 114.02,40.03 112.84,41.2 112.84,41.52 v4(112.83,41.53)
  IN3 w0.061: v4(112.83,41.53) 112.85,41.51 v5(112.85,41.2) ; v4(129.35,26.23) 129.52,26.07 129.52,25.65 130.22,24.94 130.73,24.94 133.12,22.55 133.12,21.1 134.98,19.25 136.8,19.25 136.88,19.17 136.88,19.02 136.88,19.02 v5(136.78,18.92)
  BOTTOM w0.127: RC565.1 v5(112.85,41.2) ; v5(136.78,18.92) 136.87,19.01 136.87,19.21 138.73,21.08 139.15,21.08 139.38,20.85 139.38,20.54 RV66.1
PCH_DMIC_DATA0: length 44.7
  IN2 w0.061: v4(129.9,26.21) 129.42,25.72 125.47,25.72 125.11,25.36 123.86,25.36 123.18,26.03 121.89,26.03 120.88,27.04 120.08,27.04 119.23,27.9 119.23,28.6 116.87,30.96 115.23,30.96 113.83,32.35 113.83,39.95 113.42,40.35 v4(112.85,40.35)
  IN3 w0.061: v4(129.9,26.21) 129.7,26.01 129.7,25.72 130.3,25.13 130.81,25.13 133.31,22.62 133.31,21.18 135.05,19.43 136.88,19.43 137.07,19.25 137.07,19.04 v5(137.19,18.92) ; v5(112.85,40.68) v4(112.85,40.35)
  BOTTOM w0.127: RV67.1 139.13,20.53 139.13,20.74 139.05,20.82 138.84,20.82 v7(138.03,20.01) 137.12,19.11 137.12,18.99 v5(137.19,18.92) ; RC566.1 CC246.1
PCH_DPWROK: length 231.3
  TOP w0.127: RE112.1 276.31,60.65 v2(276.55,60.65) ; v2(250.1,44.43) 249.49,45.04 v3(249.27,45.04)
  IN1 w0.061: v2(276.55,60.65) 276.72,60.81 278.76,60.81 280.68,58.89 280.68,51.69 272.57,43.59 253.23,43.59 252.81,44.01 251.9,44.01 251.48,44.43 v2(250.1,44.43) 250.07,44.41 v4(249.63,44.41)
  IN2 w0.061: v4(249.63,44.41) 249.63,44.65 249.38,44.9 247.85,44.9 247.69,44.74 237.03,44.74 231.43,39.14 228.72,39.14 220.9,31.31 220.23,31.31 217.16,28.24 197.92,28.24 197.56,28.59 189.81,28.59 177.73,16.52 154.05,16.52 153.79,16.78 148.02,16.78 143.76,21.04 141.21,21.04 139.53,22.73 134.58,22.73 133.46,21.61 131.64,21.61 131.3,21.27 130.07,21.27 129.06,22.28 126.32,22.28 125.87,21.83 122.62,21.83 122.03,21.25 118.93,21.25 116,24.18 115.53,24.18 110.64,29.07 106.19,29.07 105.35,29.91 102.98,29.91 102.1,29.03 101.62,29.03 101.26,28.67 100.08,28.67 v4(99.77,28.36)
  IN3 w0.061: v5(97.83,36.7) 97.4,36.27 97.4,36.13 98.46,35.06 98.46,32.92 99.21,32.17 99.21,29.29 99.77,28.73 v4(99.77,28.36) 99.8,28.34 v5(99.8,27.83)
  BOTTOM w0.127: UCPU1.BP30 v5(97.83,36.7) ; RC92.1 v5(99.8,27.83) 99.8,27.97 99.54,28.23 RC90.1
PCH_DPWROK_EC: length 9.4
  TOP w0.102: UE1.F8 268.41,57.21 268.8,57.6 v2(269.11,57.6)
  IN1 w0.061: v2(269.11,57.6) 269.11,58.39 270.01,59.29 270.27,59.29 271.19,60.22 272.71,60.22 273.35,60.86 275.52,60.86 v2(275.59,60.79)
PCH_JTAG_TCK: length 47.7
  TOP w0.127: v2(50.5,57.3) 50.5,59.27 v3(50.24,59.52) 49.85,59.91 49.85,62.01 49.52,62.34 49.52,65.8 49.38,65.94 48.68,65.94 48.39,66.24 48.39,67.98 49.22,68.81 49.82,68.81 50.05,68.59 50.05,67.58 50.34,67.29 RC238.1 RC258.2
  IN1 w0.061: v2(50.5,57.3) v4(50.99,57.3)
  IN3 w0.061: v4(50.99,57.3) 51.23,57.06 54.96,57.06 55.29,57.39 58.04,57.39 60.33,55.11 62.94,55.11 64.07,56.23 71.6,56.23 71.93,56.56 72.81,56.56 73.52,55.85 73.77,55.85 73.93,56 75.02,56 75.94,55.08 75.94,53.23 76.05,53.12 76.05,52.66 75.77,52.38 75.65,52.38 75.37,52.1 v5(75.37,52.03)
PCH_JTAG_TDI: length 12.6
  TOP w0.127: v2(73.95,54.04) 73.95,54.78 v3(73.71,55.02)
  IN1 w0.061: v4(74.52,53.19) 73.95,53.76 v2(73.95,54.04)
  IN3 w0.061: v5(74.44,52.68) 74.52,52.76 v4(74.52,53.19)
  BOTTOM w0.076: RC254.2 75.64,61.66 76.01,61.3 76.01,60.8 RC234.1 75.38,60.17 75.38,59.85 74.99,59.46 74.99,55.49 74.75,55.26 74.75,54.58 74.71,54.54 74.71,54.26 74.75,54.22 74.75,53.56 74.84,53.48 74.84,53.08 v5(74.44,52.68)
PCH_JTAG_TDO: length 12.3
  TOP w0.127: v2(76.01,60.55) v3(76.01,61.66)
  IN1 w0.061: v2(76.01,60.55) v4(75.77,60.31)
  IN3 w0.061: v5(76.04,60.11) 75.87,60.28 75.79,60.28 v4(75.77,60.31)
  BOTTOM w0.076: RC255.2 76.25,61.66 76.62,61.3 76.62,60.78 RC233.1 76.33,60.46 76.33,60.22 76.22,60.11 v5(76.04,60.11) 75.6,60.11 75.53,60.05 75.53,59.79 75.16,59.41 75.16,55.43 74.91,55.18 74.91,54.52 74.87,54.48 74.87,54.33 74.91,54.28 74.91,54.06 75.44,53.53 75.44,52.75 UCPU1.W5
PCH_JTAG_TMS: length 12.4
  TOP w0.127: v3(70.41,56.29) 70.8,56.29 v2(71.32,55.77)
  IN1 w0.061: v4(71.69,55.63) 71.46,55.63 v2(71.32,55.77)
  IN3 w0.061: v4(71.69,55.63) v5(72.36,55.63) 72.55,55.63 73.2,54.98 73.2,53.29 v5(72.59,52.68)
  BOTTOM w0.076: v5(72.36,55.63) 72.36,56.37 71.92,56.81 71.92,60.34 RC235.1 72.11,60.79 72.11,61.35 RC252.2
PCH_JTAG_TRST#: length 9.9
  TOP w0.127: v2(78.76,53.99) v3(78.76,54.6)
  IN1 w0.061: v4(78.59,53.66) 78.59,53.82 v2(78.76,53.99)
  IN3 w0.061: v4(78.59,53.66) 78.59,53.59 v5(78.86,53.32)
  BOTTOM w0.076: UCPU1.Y6 76.71,52.03 77,52.31 77.36,52.31 78.19,53.14 78.67,53.14 v5(78.86,53.32) 79.25,53.72 79.49,53.72 79.65,53.88 79.7,54.06 79.57,54.34 79.58,54.42 79.66,54.65 79.65,54.86 79.59,55.01 79.66,55.32 79.95,55.73 80.18,56.04 80.2,56.18 80.2,56.6 79.81,56.99 79.51,56.99 RC236.1
PCH_JTAGX: length 11.9
  IN3 w0.061: v5(72.06,55.87) 72.52,55.87 73.39,55 73.39,53.12 72.88,52.61 72.88,52.32 v5(72.59,52.03)
  BOTTOM w0.076: v5(72.06,55.87) 71.94,55.87 71.41,56.4 v1(71.41,59.62) 71.02,60.01 70.76,60.01 70.52,60.24 RC237.1 70.84,60.79 70.84,61.35 RC257.2
PCH_PCIE_WAKE#: length 353.7
  TOP w0.127: RE189.2 260.46,52.79 v2(261.21,52.04) 261.31,52.04 262.48,53.21 UE1.L1 ; v2(56.27,29.94) 55.79,29.46 55.79,28.94 55.96,28.77 55.96,13.95 56.93,12.97 92.75,12.97 v2(93.07,13.3) ; v2(32.21,57.42) RT289.1 ; v2(124.07,17.15) 124.38,17.46 132.45,17.46 136.46,13.44 144.98,13.44 148.72,12.43 150.45,11.93 153.68,11.93 153.77,11.92 184.89,11.92 186.17,13.2 197.58,13.2 198.72,14.34 208.47,14.34 210.09,12.72 218.04,12.72 220.09,14.77 220.09,19.14 222.11,21.16 222.11,22.93 223.02,23.84 223.02,26.77 233.81,37.56 v1(233.81,47.54) 233.81,49.87 v2(235.04,51.1)
  IN1 w0.061: v4(35.02,62.14) 35.02,61.34 34.15,60.47 34.15,58.64 33.61,58.1 32.27,58.1 32.03,57.86 32.03,57.59 v2(32.21,57.42) ; v2(99.51,27.62) 99.71,27.62 100.47,28.38 100.47,29.13 101.17,29.83 v4(102.02,29.83) ; v2(261.21,52.04) 261.19,52.06 259.68,52.06 259.42,52.31 258.22,52.31 257.29,51.38 254.34,51.38 253.78,51.94 249.47,51.94 249.21,51.68 246.1,51.68 245.52,51.1 v2(235.04,51.1) ; v2(93.07,13.3) 93.07,13.79 94.27,14.99 94.27,15.65 v4(95.23,16.61) ; v2(124.07,17.15) 124.07,17.33 122.07,19.34 120.89,19.34 119.19,21.03 113.53,21.03 112.59,20.1 109.41,20.1 108.71,20.79 106.73,20.79 v4(106.5,21.02) ; v4(42.89,49.65) 42.91,49.65 43.1,49.83 43.71,49.83 43.88,49.67 45.98,49.67 48,47.65 48,40.57 48.62,39.96 50.37,39.96 52.84,37.49 52.84,36.01 56.47,32.38 56.47,30.13 v2(56.27,29.94)
  IN2 w0.061: v4(95.23,16.61) 95.27,16.61 97.64,18.98 101.43,18.98 103.26,20.81 106.29,20.81 v4(106.5,21.02)
  IN3 w0.061: v5(39.11,62.36) 38.94,62.19 38.94,58.69 38.68,58.44 38.68,57.97 39,57.65 39,55.72 38.79,55.51 38.79,51.75 39.65,50.89 41.31,50.89 42.56,49.65 v4(42.89,49.65) ; v5(99.68,36.54) 99.83,36.7 100.24,36.7 100.46,36.48 100.46,36 100.88,35.58 100.88,34.54 100.39,34.05 100.39,33.18 100.57,33 100.7,33 100.85,32.85 100.85,32.15 101.49,31.51 101.49,30.36 v4(102.02,29.83) 102.26,29.59 102.26,28.48 102.36,28.38 102.36,27.21 103.91,25.66 105.26,25.66 105.57,25.35 105.57,22.66 106.22,22 106.22,21.36 106.5,21.08 v4(106.5,21.02) ; v4(35.02,62.14) 35.45,62.14 v5(35.53,62.22)
  BOTTOM w0.127: RT187.2 28.43,61.14 29.35,62.06 33.45,62.06 34.01,61.5 34.81,61.5 v5(35.53,62.22) 35.69,62.07 38.92,62.07 39.09,62.24 39.09,62.34 v5(39.11,62.36) ; v5(99.68,36.54) 99.61,36.6 99.59,36.76 UCPU1.BU30
PCH_PLTRST#: length 17.4
  BOTTOM w0.076: 93.47,31.91 93.97,32.41 93.97,33.74 UCPU1.BJ35
  BOTTOM w0.127: 96.18,21.92 RC77.1 95.77,21.76 95.42,21.76 95.16,22.01 95.16,25.38 94.89,25.65 94.89,27.58 93.84,28.62 93.84,29.2 92.81,30.24 92.81,31.25 93.47,31.91 ; 96.18,21.92 96.18,21.48 96.63,21.04 UC2.1 ; 96.18,21.92 96.42,21.69 UC2.2
PCH_PLTRST#_5105: length 2.6
  TOP w0.127: UE4.4 256.83,51.87 257.19,51.52 v1(257.87,51.52) RE186.2
PCH_PLTRST#_AND: length 460.9
  TOP w0.127: v6(230.71,63.3) v1(230.71,65.27) 230.71,66.01 228.95,67.76 224.87,67.76 224.5,68.13 RE98.2 ; RN113.1 259.32,38.93 260.6,38.93 261.01,39.34 UN5.1 261.45,39.78 264.02,42.35 v2(264.02,42.36) ; v2(45.35,39.51) 45.35,39.52 44.8,40.06 41.83,40.06 41.3,40.59 41.3,43 40.19,44.11 39.1,44.11 37.69,45.52 37.69,48.82 37.51,49 37.51,56.22 38.07,56.77 38.07,57.22 v2(37.92,57.37) 35.11,57.37 34.5,57.98 33.72,57.98 33.41,58.29 RT190.2 33.2,58.11 33.2,57.55 32.97,57.32 RT285.1 ; v6(290.96,37.21) 291.04,37.13 UR1.1 ; UE4.2 256.18,50.27 v2(256.17,50.26) ; RC523.2 53.67,66.05 v6(54.14,65.58) ; v2(51.5,37.2) 51.2,36.9 49.66,36.9 49.28,36.52 47.37,36.52 47.07,36.23 UZ6.17
  IN1 w0.061: v4(38.24,57.2) 38.07,57.37 v2(37.92,57.37) ; v2(256.17,50.26) 256.55,50.26 v4(256.65,50.36) ; v2(264.02,42.36) 264.42,42.36 v4(264.43,42.36) 264.69,42.63 269.37,42.63 v6(269.66,42.34) ; v4(51.74,36.96) v2(51.5,37.2) 51.35,37.35 51.35,37.91 49.73,39.53 45.37,39.53 v2(45.35,39.51)
  IN2 w0.061: v4(100.88,20.82) 100.88,20.79 100.23,20.15 95.64,20.15 95.32,20.47 95.32,21.77 94.83,22.26 94.83,27.56 93.69,28.71 74.02,28.71 73.6,29.13 67.33,29.13 67.03,28.82 65.73,28.82 65.43,29.13 60.11,29.13 59.75,28.77 57.28,28.77 56.46,29.59 55.59,29.59 54.61,30.58 54.61,34.08 51.74,36.95 v4(51.74,36.96) ; v6(198.64,60.19) 200.99,60.19 202.72,61.92 202.72,63.96 203.78,65.03 206.74,65.03 212.72,59.05 212.72,53.74 v6(214.1,52.36)
  IN3 w0.061: v4(38.24,57.2) 38.24,58.81 37.96,59.09 37.96,63.93 38.15,64.13 v5(38.15,65.19) ; v4(264.43,42.36) 263.14,43.65 263.14,46.48 261.95,47.67 261.95,49.09 261.64,49.4 260.23,49.4 259.34,50.29 256.73,50.29 v4(256.65,50.36) 256.22,50.79 254.89,50.79 250.96,54.72 250.96,57.55 245.19,63.32 230.72,63.32 v6(230.71,63.3) 230.21,62.81 222.1,62.81 214.1,54.81 v6(214.1,52.36) ; v5(100.82,21.84) 100.88,21.79 v4(100.88,20.82) 100.88,19.87 101.66,19.09 101.66,18.4 104.06,15.99 105.23,15.99 106.01,15.22 108.65,15.22 109.5,16.07 v5(115.15,16.07) ; v5(216.33,27.55) 216.73,27.15 v5(225.25,27.15)
  BOTTOM w0.127: JNGFF3.52 v5(216.33,27.55) 216.33,23.52 214.26,21.45 214.26,20.99 212.62,19.35 203.46,19.35 197.85,24.96 187.36,24.96 177.07,14.68 139.6,14.68 138.87,13.95 136.52,13.95 136.38,14.09 136.38,14.45 136.23,14.6 135.67,14.6 135.24,14.17 130.92,14.17 130.49,14.6 130.26,14.9 130.26,14.91 129.57,15.72 129.02,16.26 128.32,16.69 128,16.82 127.92,16.85 127.5,17.03 126.58,17.21 125.75,17.21 125.38,17.16 125.37,17.17 125.24,17.15 125.09,17.13 124.12,16.74 124.1,16.73 123.98,16.68 123.97,16.66 121.91,15.47 115.75,15.47 v5(115.15,16.07) ; v5(38.15,65.19) 38.17,65.21 53.78,65.21 v6(54.14,65.58) ; v5(100.82,21.84) 100.18,21.84 99.92,22.09 RC76.1 99.63,22.37 99.59,22.34 UC2.4 ; v6(290.96,37.21) 287.64,37.21 285.63,39.21 285.63,43.9 285.24,44.29 271.61,44.29 v6(269.66,42.34) ; JNGFF2.50 v6(214.1,52.36) 214.19,52.36 216.16,50.39 216.16,44.21 223.37,37 223.37,32.72 225.25,30.85 v5(225.25,27.15) ; LED_RST.1 v6(198.64,60.19)
PCH_POPIRCOMP: length 1.7
  IN1 w0.305: v2(100.85,41.48) 100.85,41.32 100.64,41.11 v4(100.64,40.15)
  IN3 w0.305: v5(100.41,39.92) v4(100.64,40.15)
PCH_PRIM_EN: length 176.5
  TOP w0.127: R208.1 229.44,42.93 v1(229.44,40.48) v6(229.44,39.69) ; U12.5 124.35,27.71 124.02,27.38 120.91,27.38 v2(120.26,28.03) 120.17,27.95 120.17,24.62 120.27,24.52 120.27,23.31 121.3,22.28 v2(121.3,22.13) ; v6(121.95,36.88) 124.54,39.46 125.72,39.46 126.67,40.42 126.67,40.76 v2(127.11,41.2)
  IN1 w0.061: v2(120.26,28.03) 120.18,28.11 v4(119.93,28.11) ; v2(121.3,22.13) 121.3,22.02 v4(121.63,21.68) ; v4(127.11,43) v2(127.11,41.2)
  IN2 w0.061: v6(229.44,39.69) 228.92,39.69 220.79,31.57 220.12,31.57 217.04,28.49 198.02,28.49 197.67,28.85 189.7,28.85 177.63,16.77 154.16,16.77 153.89,17.04 148.13,17.04 143.87,21.3 141.34,21.3 139.66,22.98 129.86,22.98 129.42,22.53 126.21,22.53 125.78,22.1 122.05,22.1 v4(121.63,21.68) ; v4(119.93,28.11) 120.33,28.11 120.76,27.68 122.13,27.68 122.37,27.91 122.37,30.26 122.86,30.75 122.86,35.97 v6(121.95,36.88)
  IN3 w0.061: v5(120.42,50.23) 120.97,50.23 121.29,49.91 121.29,44.14 121.44,43.99 122.61,43.99 122.94,43.66 127.17,43.66 v5(127.17,43.65) 127.17,43.05 v4(127.11,43) ; v5(119.23,28.11) v4(119.93,28.11)
  BOTTOM w0.127: v5(120.42,50.23) 120.29,50.37 RC574.1 ; RC630.2 118.02,28.23 118.02,27.97 ; 118.02,27.97 118.02,27.7 117.5,27.18 RC599.2 RC575.1 ; 118.02,27.97 118.03,27.98 119.1,27.98 v5(119.23,28.11)
