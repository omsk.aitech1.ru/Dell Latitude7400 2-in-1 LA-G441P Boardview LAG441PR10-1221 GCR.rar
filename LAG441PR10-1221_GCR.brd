# Allegro board LAG441PR10-1221_GCR.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+8.4V_BATT+ on BOTTOM (solid shape): 44.58,26.15 44.58,25.13 44.93,24.77 45.29,25.13 45.29,25.66 45.83,25.66 45.95,25.54 45.95,23.93 45.68,23.66 44.08,23.66 43.94,23.52 43.94,22.65 43.82,22.54 42.25,22.54 42.14,22.64 42.14,23.63 42.45,23.93 42.81,23.93 42.92,24.04 42.92,26.19 42.96,26.23 44.5,26.23
+DVDD on TOP: 276.63,24.13 276.52,24.24 276.52,25.65 276.67,25.8 277.85,25.8 277.98,25.93 277.98,26.31 278.03,26.36 278.94,26.36 279.75,25.55 280.9,25.55 280.9,25.29 278.61,25.29 278.23,24.91 277.72,24.91 277.6,24.78 277.6,24.28 277.45,24.13
+PVDD on TOP (solid shape): 285.28,30.18 285.28,29.42 284.2,28.34 284.2,26.67 284.15,26.62 284.06,26.62 284,26.68 284,28.93 284.01,28.94 284.01,29.74 283.76,29.99 283.76,30.18 284.33,30.75 284.71,30.75
+PVDD on TOP: 281.99,26.68 281.99,27.5 281.54,27.96 280.43,27.96 280.02,28.36 280.02,29.33 280.11,29.42 280.64,29.42 280.83,29.23 281.31,29.23 281.38,29.16 281.38,28.48 282.21,27.66 282.21,26.68 282.15,26.63 282.05,26.63
+PVDD on BOTTOM: 285.41,31.13 285.41,30.63 285.91,30.12 285.91,29.1 285.28,28.47 284.14,28.47 284.01,28.59 284.01,29.61 283.53,30.09 283.53,30.53 284.38,31.38 284.38,31.72 284.79,32.13 284.89,32.13 285.61,31.41 285.61,31.34
+PVDD on IN1: 284.07,28.47 284.26,28.47 285.41,29.61 285.41,31.64 284.77,32.28 280.77,32.28 279.95,31.45 279.95,29.1 280.2,28.85 281.22,28.85 281.28,28.91 281.28,29.74 281.41,29.86 283.88,29.86 284.01,29.74 284.01,28.53
+VBATT on BOTTOM (solid shape): 45.18,21.64 45.94,21.64 46.03,21.55 46.03,20.5 45.96,20.43 45.81,20.38 45.69,20.27 45.14,20.27 45.03,20.16 45.03,19.62 46.12,18.53 46.12,16.17 46.08,16.13 44.65,16.13 44.27,15.74 43.39,15.74 43.27,15.87 43.27,19.03 42.72,19.57 42.16,19.57 42.1,19.63 42.1,21.9 42.16,21.96 44.87,21.96
+VBUS1_20V on TOP (solid shape): 21.96,68.2 21.96,67.32 21.43,66.8 18.88,66.8 18.65,67.02 18.65,68.24 19.01,68.6 21.56,68.6
+VBUS1_20V on BOTTOM (solid shape): 20.49,67.54 20.49,66.82 20.15,66.47 20.15,65 20.15,64.99 20.15,64.64 20.03,64.52 18.32,64.52 18.05,64.78 18.05,66.52 18.19,66.66 18.19,66.66 18.86,67.33 19.75,67.33 20,67.58 20.46,67.58
+VBUS1_20V on BOTTOM (solid shape): 13.25,51.45 13.25,50.56 13.06,50.38 13.06,49.52 12.87,49.32 11.38,49.32 11.01,48.95 11.01,46.7 11.01,46.35 10.89,46.23 9.79,46.23 9.7,46.32 9.7,48.37 9.45,48.63 8.51,48.63 8.41,48.73 8.41,51.06 8.55,51.2 10.09,51.2 10.29,51.4 11.54,51.4 11.72,51.58 13.12,51.58
+VBUS1_20V on IN1 (solid shape): 20.1,67.43 20.1,67.05 19.98,66.92 18.35,66.92 18.19,67.09 18.19,67.6 18.34,67.75 19.79,67.75
+VBUS1_20V on IN1 (solid shape): 10.41,49.92 11.18,49.92 11.44,49.66 11.44,49.09 10.91,48.57 8.85,48.57 8.22,49.2 8.22,50.56 8.3,50.64 9.69,50.64
+VBUS1_20V on IN3 (solid shape): 20.47,64.21 17.95,64.21 17.95,67.44 20.47,67.44
+VBUS1_20V on IN3 (solid shape): 9.71,49.9 11.49,49.9 11.59,49.8 11.59,48.66 10.96,48.02 9.67,48.02 8.8,48.89 8.8,49.93 9.05,50.18 9.44,50.18
+VBUS1_20V on TOP: 11.84,51.85 12.1,52.11 14.06,52.11 14.25,52.3 14.25,52.88 14.48,53.1 15.58,53.1 15.79,52.89 15.79,51.88 15.61,51.7 15.08,51.7 15,51.62 15,51.02 14.83,50.84 14.18,50.84 14.18,50.84 13.31,50.84 13.22,50.94 13.22,51.13 13,51.34 12.43,51.34 11.99,50.9 10.39,50.9 10.23,50.75 10.23,50.11 9.76,49.63 9.76,48.85 9.64,48.74 8.38,48.74 8.23,48.88 8.23,50.55 8.33,50.65 9.42,50.65 9.98,51.21 9.98,51.44 10.39,51.85
+VBUS1_20V on IN2: 19.98,67.46 20.23,67.2 20.23,64 19.88,63.65 18.27,63.65 17.69,64.23 16.6,64.23 15,62.63 15,56.85 15.3,56.55 15.3,49.21 13.98,47.9 9.56,47.9 8.8,48.66 8.8,54.25 9.54,54.98 9.79,54.98 10.08,55.28 10.08,62.13 15.4,67.46
+VBUS2_20V on BOTTOM (solid shape): 20.36,74.45 20.36,73.63 20.12,73.39 20.12,73.38 20.08,73.34 20.08,71.92 20.35,71.64 20.35,71.5 20.26,71.4 18.36,71.4 18.05,71.72 18.05,73.45 18.19,73.59 18.19,73.59 18.86,74.26 19.75,74.26 20,74.51 20.3,74.51
+VBUS2_20V on BOTTOM (solid shape): 11.4,64.86 12.55,64.86 12.83,64.59 13.38,64.59 13.5,64.47 13.5,63.77 13.12,63.39 13.12,62.25 12.91,62.04 10.75,62.04 10.58,61.87 10.58,60.06 9.65,59.14 9.13,59.14 9.09,59.18 9.09,63.26 8.97,63.39 8.86,63.39 8.55,63.7 8.55,64.79 8.74,64.98 11.27,64.98
+VBUS2_20V on IN3 (solid shape): 10.78,74.86 11.13,74.66 11.49,74.49 11.49,74.11 11.19,73.81 10.11,73.81 9.85,74.07 9.85,74.59 10.13,74.86 10.77,74.86
+VBUS2_20V on IN3 (solid shape): 20.47,74.08 20.47,71.5 20.3,71.34 18.16,71.34 17.96,71.54 17.89,71.77 17.66,71.84 17.24,72.26 17.24,73.35 18.15,74.26 20.29,74.26
+VBUS2_20V on TOP: 18.49,74.9 19.59,74.9 19.94,74.55 19.94,72.03 19.68,71.77 18.53,71.77 18.16,72.15 18.16,74.57
+VBUS2_20V on IN1: 17.91,74.32 19.74,74.32 20.15,73.91 20.15,71.58 19.92,71.36 17.93,71.36 17.22,72.07 17.22,73.62
+VBUS2_20V on IN2: 10.27,74.89 11.22,74.89 13.13,74.45 15.02,75 20.23,75 20.65,74.58 20.65,71.75 20.16,71.27 16.04,71.27 14.52,69.74 14.01,69.74 11.59,67.33 11.59,65.8 9.36,63.57 8.58,63.57 8.48,63.67 8.48,67.84 9.37,68.73 9.37,74
+VBUS2_20V on VCC: 8.59,63.52 8.48,63.62 8.48,67.1 9.56,68.18 9.56,69.08 9.37,69.28 9.37,74.02 10.24,74.89 10.63,74.89 10.9,74.73 11.43,74.46 11.98,74.25 12.66,74.19 13.35,74.19 13.43,74.26 13.44,74.26 13.44,74.21 13.77,74.26 14.1,74.34 15.13,74.77 16,75.46 16.44,75.01 20.25,75.01 20.67,74.59 20.67,71.75 17.63,68.7 17.63,66.12 16.95,66.12 14.35,63.52 ; 2 cut-outs
+VBUS2_20V on IN3: 8.99,65.49 9.24,65.49 10.48,64.26 10.48,59.71 10.07,59.3 9.33,59.3 9.21,59.43 9.21,62.96 8.48,63.68 8.48,64.98
+VCC0V9_CIO on TOP (solid shape): 25.14,55.05 25.14,52.04 25.06,51.97 24.72,51.97 24.63,52.06 24.63,55.03 24.72,55.12 25.07,55.12
+VCC0V9_DP on TOP (solid shape): 26.44,53.1 26.44,51.53 26.36,51.45 25.96,51.45 25.88,51.53 25.88,52.6 25.83,52.65 25.4,52.65 25.32,52.72 25.32,53.1 25.37,53.16 26.39,53.16
+VCC0V9_DP on TOP (solid shape): 23.82,55.03 23.82,54.04 23.77,53.99 23.39,53.99 23.34,54.04 23.34,54.41 23.23,54.53 22.81,54.53 22.71,54.62 22.71,55.04 22.76,55.09 23.77,55.09
+VCC0V9_DP on IN1 (solid shape): outline of 95 points within 22.44,51.63 26.15,55.29
+VCC0V9_DP on IN3: 22.59,55.3 23.48,55.3 23.7,55.08 23.7,54.47 24.71,53.46 24.72,53.45 25.95,53.45 26.32,53.08 26.32,51.58 26.23,51.48 26.07,51.48 25.75,51.81 25.2,51.81 25.05,51.95 25.05,52.98 24.97,53.06 24.45,53.06 24.44,53.05 23.36,53.05 23.09,52.79 23.09,52.01 22.91,51.83 22.58,51.83 22.46,51.95 22.46,53.3 22.61,53.44 23.13,53.44 23.13,53.44 23.63,53.44 23.75,53.56 23.75,53.72 23.44,54.02 22.77,54.02 22.49,54.3 22.49,55.2
+VCC0V9_PCIE on IN1 (solid shape): outline of 83 points within 22.48,48.37 24.39,51.77
+VCC_CORE on BOTTOM (solid shape): 101.46,76.17 101.46,70.35 100.7,69.59 100.7,65.91 100.65,65.86 97.44,65.86 97.45,65.86 97.21,65.86 96.86,65.51 96.86,64.97 96.77,64.88 86.71,64.88 86.58,65.01 86.58,66.08 86.42,66.24 84.64,66.24 84.59,66.29 84.59,70.26 84.37,70.48 84.37,74.87 84.57,75.08 87.16,75.08 87.41,74.82 87.41,70.78 87.79,70.4 88.02,70.4 88.03,70.41 88.21,70.23 88.21,69.09 88.31,68.99 97.44,68.99 97.5,68.99 97.73,69.23 97.73,70.07 98.28,70.62 98.28,76.09 98.51,76.32 101.31,76.32
+VCC_CORE on BOTTOM (solid shape): outline of 833 points within 84.03,38.75 93,41.24
+VCC_CORE on BOTTOM (solid shape): outline of 4480 points within 76.14,48.79 92.62,55.26
+VCC_CORE on TOP: 77.3,50.98 77.28,50.96 76.16,50.96 76.08,50.88 76.08,49.64 76.85,48.88 76.85,41.98 76.9,41.93 78.65,41.93 78.76,42.04 78.76,43.74 79.07,44.04 80.5,44.04 80.91,43.63 80.91,41.96 80.95,41.93 84.48,41.93 84.54,41.87 84.54,38.65 84.66,38.54 91.39,38.54 91.5,38.65 91.5,40.84 91.52,40.84 91.59,40.91 91.59,52.43 91.76,52.6 93.18,52.6 93.42,52.85 93.42,58.81 96.16,61.55 100.85,61.55 101.15,61.85 101.15,70.22 100.62,70.76 97.8,70.76 95.93,68.89 89.74,68.89 88.44,70.2 84.77,70.2 84.67,70.1 84.67,66.53 84.35,66.21 75.63,66.21 74.94,65.53 74.94,61.56 74.05,60.67 74.05,57.89 74.05,57.88 74.05,57.39 74.68,56.76 74.68,55.83 74.47,55.62 74.14,55.62 74.05,55.53 74.05,53.27 74.31,53.02 75.25,53.02 75.3,53.07 75.3,53.52 75.63,53.85 76.79,53.85 77,53.65 77.89,53.65 78.52,53.02 78.52,51.89 77.61,50.98
+VCC_CORE on IN1: 84.49,38.56 84.17,38.88 84.17,40.6 83.6,41.17 82.4,41.17 81.76,41.8 76.94,41.8 76.68,42.06 76.68,48.34 76.3,48.72 76.3,51.07 76.43,51.2 78.7,51.2 78.8,51.1 78.8,50.79 78.93,50.67 79.23,50.67 79.34,50.77 79.77,50.77 79.87,50.67 80.2,50.67 80.73,51.2 84.11,51.2 84.52,51.61 84.89,51.61 85.29,52.01 85.29,52.49 85.13,52.65 85.13,53.18 85.05,53.26 85.05,53.33 85.1,53.38 85.25,53.38 85.53,53.1 87.01,53.1 87.34,53.43 87.44,53.43 87.77,53.1 89.27,53.1 89.52,53.36 89.88,53.36 90.09,53.15 90.96,53.15 92.75,51.36 92.75,50.76 93,50.5 93,49.1 92.56,48.66 92.56,42.13 92.77,41.92 92.77,38.61 92.72,38.56
+VCC_CORE on IN1: 84.6,67.71 84.6,70.11 84.81,70.33 87.97,70.33 88.18,70.12 88.18,69.22 88.5,68.89 96.89,68.89 98.32,70.32 100.92,70.32 101.03,70.21 101.03,66.55 100.9,66.43 85.88,66.43
+VCC_CORE on IN2: 93.38,44.79 93.38,41.17 93,41.17 92.81,40.98 92.81,38.31 92.75,38.25 84.17,38.25 84.05,38.37 84.05,41.61 83.6,42.06 80.95,42.06 80.91,42.09 80.91,43.63 80.52,44.03 79.05,44.03 78.76,43.73 78.76,42.22 78.6,42.06 77.19,42.06 77,42.25 77,48.51 76.21,49.29 76.21,53.64 75.16,54.69 75.16,55.39 76.24,56.47 76.24,58.69 76.55,59.01 78.14,59.01 78.27,59.14 81.89,59.14 83.35,60.6 83.35,68.6 85,70.25 87.67,70.25 87.92,70 87.92,69.36 88.43,68.85 96.94,68.85 98.21,70.12 100.05,70.12 101.13,69.04 101.13,62.12 100.75,61.74 95.99,61.74 94.06,59.82 94.06,52.51 92.68,51.14 92.68,50.59 92.91,50.36 92.91,45.26
+VCC_CORE on VCC: 84.16,38.25 84.05,38.36 84.05,41.6 83.59,42.06 75.73,42.06 75.73,49.19 76.24,49.7 76.24,53.59 75.16,54.67 75.16,55.41 76.24,56.49 76.24,58.71 76.72,59.2 81.87,59.2 83.29,60.62 83.29,68.62 84.91,70.25 87.63,70.25 87.98,69.89 87.98,69.38 88.51,68.85 96.98,68.85 98.25,70.12 100.07,70.12 101.19,69 101.19,61.59 100.83,61.23 96.26,61.23 93.45,58.42 93.45,55.79 93.57,55.67 93.57,51.76 93.33,51.52 93.08,51.52 92.68,51.13 92.68,50.51 92.87,50.32 92.87,45.3 93.38,44.8 93.38,41.17 93.01,41.17 92.81,40.97 92.81,38.35 92.71,38.25
+VCC_CORE on IN3: 84.65,66.35 84.58,66.42 84.58,70.17 84.67,70.26 88.2,70.26 88.35,70.11 88.35,69.04 88.51,68.89 97.34,68.89 97.52,69.07 97.52,69.96 97.88,70.31 100.8,70.31 100.98,70.14 100.98,66.45 100.88,66.35
+VCC_CORE on IN3: 93.05,43.76 91.73,42.44 77.25,42.44 77.13,42.56 77.13,48.85 76.17,49.8 76.17,54.25 77.57,55.64 80.87,55.64 83.29,53.23 91.16,53.23 91.67,52.72 91.67,50.82 92.05,50.44 92.67,50.44 93.05,50.06
+VCCGT on BOTTOM (solid shape): outline of 3419 points within 50.43,40.07 75.98,55.1
+VCCGT on TOP: 50.89,39.22 74.56,39.22 74.67,39.34 74.67,48.76 75.35,49.43 75.35,50.73 75.17,50.91 74,50.91 73.8,51.11 73.8,52.2 73.23,52.76 73.23,54.45 71.85,55.84 61.73,55.84 61.11,55.21 53.34,55.21 52.73,54.6 52.73,53.34 50.45,51.06 50.45,39.66
+VCCGT on IN1: 50.63,53.45 50.63,42.64 52.49,40.79 55.03,40.79 56.16,41.92 66.15,41.92 66.71,42.47 66.71,42.5 70.34,42.5 70.78,42.07 70.78,41.74 70.93,41.59 76.03,41.59 76.11,41.66 76.11,41.96 76.11,41.97 76.11,53.4 75.85,53.66 75.3,53.66 75.29,53.67 72.92,53.67 72.36,54.23 70.26,54.23 69.95,54.54 63.45,54.54 62.86,53.95 58.21,53.95 57.71,53.45
+VCCGT on IN2: 75.22,42.18 75.22,48.85 75.73,49.36 75.73,51.77 75.03,52.47 74.27,52.47 73.53,53.21 73.53,54.51 72.78,55.26 64.68,55.26 62.52,53.1 51.98,53.1 51.66,52.79 51.66,40.34 51.85,40.15 62.97,40.15 64.74,41.93 74.97,41.93
+VCCGT on VCC: 51.66,40.15 51.66,52.81 51.96,53.1 62.5,53.1 64.66,55.26 72.68,55.26 72.68,54.07 72.43,53.82 72.43,53.41 74.7,51.14 75.73,51.14 75.73,49.91 75.22,49.4 75.22,42.16 74.99,41.93 64.77,41.93 62.99,40.15
+VCCGT on IN3: 75.88,43.39 63.94,43.39 59.3,38.74 50.23,38.74 50.23,55.43 50.79,55.99 59.04,55.99 60.2,54.83 63.08,54.83 64.24,55.99 71.59,55.99 71.74,55.83 71.74,55.82 72.16,55.39 72.16,55.3 72.27,55.19 72.78,55.19 72.88,55.09 72.88,54.77 72.54,54.43 72.54,53.07 72.21,52.75 72.21,51.38 72.45,51.14 75.84,51.14 75.96,51.02 75.96,43.47
+VCCLDOSRAM_1P24 on IN1: 101.13,42.06 102.02,42.06 102.15,41.93 102.15,40.79 102.02,40.66 101.13,40.66 101,40.79 101,40.91 101.13,41.04
+VCCPLL_OC on IN2: 93.26,34.04 93.26,37.61 94.65,39.01 94.65,39.39 94.84,39.58 95.93,39.58 96.05,39.46 96.05,37.86 94.91,36.72 94.91,34.05 94.78,33.93 93.37,33.93
+VCCPLL_OC_R on BOTTOM (solid shape): 96.66,19.17 96.66,18.29 96.77,18.18 96.77,16.02 96.61,15.86 95.83,15.86 95.41,16.27 95.41,19.07 95.57,19.22 96.61,19.22
+VCCSA on BOTTOM (solid shape): 131.55,59.1 131.55,55.5 131.37,55.32 126.75,55.32 126.33,55.75 126.33,58.87 126.63,59.18 131.48,59.18
+VCCSA on BOTTOM (solid shape): outline of 873 points within 92.75,38.6 97.07,51.12
+VCCSA on TOP: 93.38,41.04 93.26,41.17 93.26,41.8 93.51,42.06 93.51,48.79 93,49.29 93,51.06 93.36,51.42 93.36,51.8 93.38,51.82 93.38,51.82 93.41,51.85 93.61,51.85 93.63,51.85 93.84,51.85 93.9,51.91 93.92,51.91 93.92,51.92 93.97,51.97 93.97,52.64 94.29,52.96 94.29,58.48 96.53,60.72 101.22,60.72 102.03,61.54 102.03,62.36 102.19,62.52 116.75,62.52 116.76,62.51 117.1,62.51 120.5,59.11 120.5,57.05 121.07,56.48 121.31,56.14 121.69,56.28 125.97,56.28 126.33,56.64 126.33,57.24 126.5,57.42 128.33,57.42 128.71,57.04 128.71,54.43 128.03,53.74 123.08,53.74 122.33,52.99 118.02,52.99 116.28,54.73 116.28,55.86 113.91,58.23 102.48,58.23 98.79,54.54 98.79,51.3 98.72,51.23 96.98,51.23 96.89,51.14 96.89,49.85 96.54,49.51 95.73,49.51 95.3,49.07 95.3,47.27 95.17,47.13 95.04,47.13 94.89,46.98 94.89,45.48 95.13,45.25 95.13,45.24 95.13,42.1 94.82,41.79 94.13,41.79 93.89,41.55 93.89,41.17 93.76,41.04
+VCCSA on IN1: 94.53,40.15 94.27,40.15 94.08,39.96 94.08,39.71 94.46,39.33 94.46,38.6 94.53,38.54 95.07,38.54 95.16,38.63 95.16,39.83 95.48,40.15 96.18,40.15 96.3,40.02 96.3,39.9 96.43,39.77 96.62,39.77 96.94,40.09 96.94,40.85 96.3,41.48 96.3,45.99 95.92,46.37 95.21,46.37 95.03,46.55 95.03,47.2 95.41,47.57 95.41,48.91 95.52,49.02 95.99,49.02 96.11,49.14 96.11,51.07 95.99,51.2 93.06,51.2 92.94,51.07 92.94,50.88 93.19,50.63 93.19,41.93 93.64,41.48 94.53,41.48 94.78,41.23 94.78,40.4
+VCCSA on IN2: 96.94,50.44 96.94,39.87 96.79,39.72 94.88,39.72 94.78,39.82 94.78,40.15 94.91,40.28 94.91,40.91 94.65,41.17 93.64,41.17 93.64,44.91 93.13,45.42 93.13,50.5 92.91,50.72 92.91,51.07 93.04,51.2 96.18,51.2
+VCCSA on VCC: 94.9,38.88 94.84,38.93 94.84,40.22 94.91,40.29 94.91,40.9 94.64,41.17 93.64,41.17 93.64,44.9 93.13,45.41 93.13,50.43 92.94,50.62 92.94,51.02 93.18,51.26 93.43,51.26 93.83,51.65 93.83,55.67 93.95,55.79 93.95,58.21 96.47,60.72 101.04,60.72 101.7,61.38 101.7,65.93 125.84,65.93 128.5,62.79 128.5,54.63 116.24,54.63 116.24,55.52 100.9,55.52 100.77,55.39 100.76,55.39 99.29,53.92 99.29,50.11 98.73,49.55 97.26,49.55 97.26,38.88
+VCCSA on IN3: 96.94,40.02 96.62,39.71 95.48,39.71 95.22,39.45 95.22,38.69 95.1,38.56 94.78,38.56 94.46,38.88 94.46,39.96 95.41,40.91 95.41,41.67 96.05,42.31 96.18,42.31 96.3,42.18 96.3,41.55 96.94,40.91
+VCCSA on IN3: 126.66,55.26 128.56,55.26 128.82,55.52 128.82,56.53 127.8,57.55 126.53,57.55 126.28,57.3 126.28,55.64
+VCCSA on IN3: 93,51.2 96.05,51.2 96.3,50.95 96.3,49.55 96.05,49.29 93.51,49.29 93.13,49.68 93.13,50.18 92.75,50.56 92.75,50.95
AGND on GND1: 302.4,11.45 301.26,12.59 299.29,12.59 299.06,12.82 299.06,18.16 298.66,18.56 294.46,18.56 294.21,18.81 289.43,18.81 288.48,17.86 285.24,17.86 284.86,17.48 284.18,17.48 284.14,17.52 284.14,19.55 284.01,19.68 284.01,21.43 284.08,21.5 284.16,21.42 285.64,21.42 286.17,21.95 286.17,26.22 285.77,26.63 285.17,26.63 285.05,26.5 284.57,26.5 284.39,26.68 284.39,28.1 285.09,28.8 285.11,28.78 285.32,28.78 286.93,30.39 286.93,30.46 287.37,30.9 287.37,31.41 287.73,31.77 288.67,31.77 290.42,30.01 290.42,28.39 290.73,27.92 291.14,27.51 292.29,27.51 292.45,27.35 292.45,25.44 292.92,24.97 293.58,24.97 293.98,25.38 293.98,25.63 294.15,25.8 296.41,25.8 297.43,24.78 311.51,24.78 311.51,24.79 313.67,24.79 313.67,21.57 313.58,21.36 313.38,21.27 311.51,21.27 302.35,21.27 301.65,20.67 302.15,19.9 302.15,14.44 301.65,13.67 302.35,13.07 315.07,13.07 315.27,12.98 315.36,12.77 315.36,11.45
AGND on GND2: 302.4,11.45 301.26,12.59 299.29,12.59 299.06,12.82 299.06,18.16 298.66,18.56 294.46,18.56 294.21,18.81 289.43,18.81 288.48,17.86 285.24,17.86 284.86,17.48 284.18,17.48 284.14,17.52 284.14,19.55 284.01,19.68 284.01,21.43 284.08,21.5 284.16,21.42 285.64,21.42 286.17,21.95 286.17,26.22 285.77,26.63 285.17,26.63 285.05,26.5 284.57,26.5 284.39,26.68 284.39,28.1 285.09,28.8 285.11,28.78 285.32,28.78 286.93,30.39 286.93,30.46 287.37,30.9 287.37,31.41 287.73,31.77 288.67,31.77 290.42,30.01 290.42,28.39 290.73,27.92 291.14,27.51 292.29,27.51 292.45,27.35 292.45,25.44 292.92,24.97 293.58,24.97 293.98,25.38 293.98,25.63 294.15,25.8 296.41,25.8 297.43,24.78 313.67,24.78 313.67,21.57 313.58,21.36 313.38,21.27 310.99,21.27 302.35,21.27 301.65,20.67 302.15,19.9 302.15,14.44 301.65,13.67 302.35,13.07 315.07,13.07 315.27,12.98 315.36,12.77 315.36,11.45
AGND on VCC: 302.4,11.45 301.26,12.59 299.29,12.59 299.06,12.82 299.06,18.16 298.66,18.56 294.46,18.56 294.21,18.81 289.43,18.81 288.48,17.86 285.24,17.86 284.86,17.48 284.18,17.48 284.14,17.52 284.14,19.55 284.01,19.68 284.01,21.43 284.08,21.5 284.16,21.42 285.64,21.42 286.17,21.95 286.17,26.22 285.77,26.63 285.17,26.63 285.05,26.5 284.57,26.5 284.39,26.68 284.39,28.1 285.09,28.8 285.11,28.78 285.32,28.78 286.93,30.39 286.93,30.46 287.37,30.9 287.37,31.41 287.73,31.77 288.67,31.77 290.42,30.01 290.42,28.39 290.73,27.92 291.14,27.51 292.29,27.51 292.45,27.35 292.45,25.44 292.92,24.97 293.58,24.97 293.98,25.38 293.98,25.63 294.15,25.8 296.41,25.8 297.43,24.78 313.67,24.78 313.67,21.57 313.58,21.36 313.38,21.27 311.24,21.27 302.35,21.27 301.65,20.67 302.15,19.9 302.15,14.44 301.65,13.67 302.35,13.07 315.07,13.07 315.27,12.98 315.36,12.77 315.36,11.45
AGND on GND3: 302.4,11.45 301.26,12.59 299.29,12.59 299.06,12.82 299.06,18.16 298.66,18.56 294.46,18.56 294.21,18.81 289.43,18.81 288.48,17.86 285.24,17.86 284.86,17.48 284.18,17.48 284.14,17.52 284.14,19.55 284.01,19.68 284.01,21.43 284.08,21.5 284.16,21.42 285.64,21.42 286.17,21.95 286.17,26.22 285.77,26.63 285.17,26.63 285.05,26.5 284.57,26.5 284.39,26.68 284.39,28.1 285.09,28.8 285.11,28.78 285.32,28.78 286.93,30.39 286.93,30.46 287.37,30.9 287.37,31.41 287.73,31.77 288.67,31.77 290.42,30.01 290.42,28.39 290.73,27.92 291.14,27.51 292.29,27.51 292.45,27.35 292.45,25.44 292.92,24.97 293.58,24.97 293.98,25.38 293.98,25.63 294.15,25.8 296.41,25.8 297.43,24.78 313.67,24.78 313.67,21.57 313.58,21.36 313.38,21.27 310.89,21.27 302.35,21.27 301.65,20.67 302.15,19.9 302.15,14.44 301.65,13.67 302.35,13.07 315.07,13.07 315.27,12.98 315.36,12.77 315.36,11.45
AGND on GND4: 302.4,11.45 301.26,12.59 299.29,12.59 299.06,12.82 299.06,18.16 298.66,18.56 294.46,18.56 294.21,18.81 289.43,18.81 288.48,17.86 285.24,17.86 284.86,17.48 284.18,17.48 284.14,17.52 284.14,19.55 284.01,19.68 284.01,21.43 284.08,21.5 284.16,21.42 285.64,21.42 286.17,21.95 286.17,26.22 285.77,26.63 285.17,26.63 285.05,26.5 284.57,26.5 284.39,26.68 284.39,28.1 285.09,28.8 285.11,28.78 285.32,28.78 286.93,30.39 286.93,30.46 287.37,30.9 287.37,31.41 287.73,31.77 288.67,31.77 290.42,30.01 290.42,28.39 290.73,27.92 291.14,27.51 292.29,27.51 292.45,27.35 292.45,25.44 292.92,24.97 293.58,24.97 293.98,25.38 293.98,25.63 294.15,25.8 296.41,25.8 297.43,24.78 313.67,24.78 313.67,21.57 313.58,21.36 313.38,21.27 302.35,21.27 301.65,20.67 302.15,19.9 302.15,14.44 301.65,13.67 302.35,13.07 315.07,13.07 315.27,12.98 315.36,12.77 315.36,11.45
DV12S on TOP: 292.8,31.53 292.72,31.6 292.72,32.08 292.82,32.18 293.27,32.18 293.42,32.34 293.42,32.5 293.55,32.63 293.55,32.81 293.55,33.67 293.6,33.73 293.78,33.73 293.85,33.66 293.85,32.74 294.12,32.46 294.12,31.82 294.04,31.74 293.65,31.74 293.43,31.53
DV33_18 on TOP: 297.23,34.07 297.23,33.75 297.15,33.66 296.7,33.66 296.64,33.61 296.14,33.61 295.57,34.18 294.74,34.18 294.69,34.23 294.69,34.42 294.76,34.49 295.62,34.49 295.71,34.58 296.23,34.58 296.61,34.2 297.1,34.2
GND on TOP (solid shape): 101.12,10.04 53.22,10.04 53.22,10.84 101.12,10.84
GND on TOP (solid shape): 80.18,48.63 80.18,44.01 79.31,44.01 79.31,48.63 79.41,48.73 80.08,48.73
GND on TOP (solid shape): 68.42,47.25 68.42,46.65 68.36,46.59 64.06,46.59 64,46.65 64,47.24 64.05,47.29 68.38,47.29
GND on TOP (solid shape): 73.32,48.66 73.32,41.55 73.19,41.42 72.43,41.42 72.3,41.55 72.3,48.66 72.43,48.79 73.19,48.79
GND on TOP (solid shape): 76.75,48.53 76.75,41.8 76.49,41.55 75.09,41.55 74.84,41.8 74.84,48.53 74.97,48.66 76.62,48.66
GND on TOP (solid shape): 83.57,49.01 83.57,42.08 83.47,41.98 82.84,41.98 82.74,42.09 82.74,49.01 82.79,49.06 83.52,49.06
GND on TOP (solid shape): 101.12,13.19 100.32,13.19 100.32,30.94 54.02,30.94 54.02,13.19 53.22,13.19 53.22,31.74 101.12,31.74
GND on TOP (solid shape): 120.8,76.09 124.37,76.09 124.62,75.84 124.62,73.3 124.24,72.92 108.89,72.92 108.57,73.23 108.57,76.3 108.61,76.33 120.56,76.33
GND on TOP (solid shape): 305.14,26.38 305.14,25.39 304.97,25.22 304.2,25.22 304.06,25.36 304.06,25.58 303.84,25.8 303.84,26.38 304,26.53 304.99,26.53
GND on TOP (solid shape): 24.46,49.89 24.46,49.53 24.38,49.45 23.97,49.45 23.88,49.36 23.88,48.41 23.83,48.36 23.46,48.36 23.39,48.43 23.39,49.88 23.44,49.93 24.42,49.93
GND on TOP (solid shape): 68.77,42.89 68.77,41.8 64.04,41.8 64.04,42.57 66.87,42.57 67.14,42.84 67.55,42.84 67.55,42.84 67.8,42.84 68.02,43.07 68.59,43.07
GND on TOP (solid shape): 298.73,17.43 298.73,14.43 298.69,14.39 298.21,14.39 298.12,14.48 298.12,15.43 297.87,15.68 297.87,17.39 298,17.53 298.63,17.53
GND on TOP (solid shape): 51.57,30.58 51.57,28.92 51.57,27.82 51.45,27.7 49.82,27.7 49.69,27.83 49.69,30.49 50.23,31.02 51.13,31.02
GND on TOP (solid shape): 73.3,52.03 73.3,51.32 73.61,51.01 73.61,50.64 73.59,50.62 72.25,50.62 72.21,50.66 72.21,52.04 72.26,52.08 73.24,52.08
GND on TOP (solid shape): 41.01,30.74 41.01,27.51 40.47,26.97 39.85,26.97 39.78,27.04 39.78,27.45 39.79,27.46 39.79,28.68 39.64,28.83 38.25,28.83 37.96,29.12 37.96,29.81 39.02,30.87 40.87,30.87
GND on TOP (solid shape): 74.44,72.36 76.6,72.36 77.16,71.8 77.16,69.33 76.42,68.59 73.33,68.59 71.68,70.25 71.68,72.41 71.8,72.53 72.24,72.53 72.43,72.73 74.08,72.73
GND on TOP (solid shape): 21.92,54.42 23.09,54.42 23.15,54.36 23.15,53.99 23.08,53.92 21.45,53.92 21.38,53.99 21.38,54.42 21.22,54.58 20.77,54.66 20.77,55.02 20.82,55.07 21.28,55.07
GND on TOP (solid shape): 89.69,40.57 89.69,40.09 89.73,40.05 90.25,40.05 90.27,40.03 90.27,39.65 90.24,39.62 89.67,39.62 89.67,39.63 89.26,39.63 89.23,39.66 89.23,40.56 89.27,40.6 89.66,40.6
GND on TOP (solid shape): 302.68,27.32 302.68,26.82 300.77,24.91 300.77,19.54 299.71,18.48 297.18,18.48 295.68,19.97 295.68,23.06 296.96,24.34 296.96,26.43 298.23,27.7 302.3,27.7
GND on TOP (solid shape): 87.61,40.57 87.61,39.65 87.59,39.63 87.18,39.63 86.46,39.63 86.44,39.66 86.44,39.99 86.46,40.01 87.06,40.01 87.15,40.1 87.15,40.56 87.19,40.6 87.58,40.6
GND on TOP (solid shape): 19.45,62.17 19.45,59.86 19.39,59.8 18.63,59.68 18.63,58.98 18.57,58.92 17.94,58.92 17.84,59.02 17.84,62.2 17.94,62.3 19.32,62.3
GND on TOP (solid shape): 24.47,54.42 24.47,53.86 24.53,53.8 24.53,52.09 24.44,52 23.48,52 23.41,52.07 23.41,53.18 23.48,53.25 23.93,53.25 24.02,53.34 24.02,53.77 23.95,53.84 23.95,54.46 23.97,54.48 24.41,54.48
GND on TOP (solid shape): 305.1,58.47 305.31,58.26 305.31,57.73 305.19,57.73 305.04,57.88 305.04,58.1 301.82,58.1 301.82,43.75 307.95,43.75 308.04,43.83 308.95,43.83 309.16,43.63 308.95,43.43 308,43.43 308,42.95 301.02,42.95 301.02,58.9 305.1,58.9
GND on TOP (solid shape): 14.75,2.14 10.66,2.14 10.66,2.79 10.48,2.79 10.4,2.86 10.4,3.19 10.45,3.24 10.63,3.24 10.71,3.17 10.71,2.94 13.95,2.94 13.95,17.22 10.34,17.22 10.16,17.04 8.17,17.04 7.99,17.22 6.54,17.22 6.54,18.02 14.75,18.02
GND on TOP (solid shape): 69.17,50.91 69.17,50.65 69.18,50.56 69.31,50.42 69.37,50.42 69.82,49.98 69.82,49.59 69.75,49.52 68.71,49.52 68.53,49.34 64.06,49.34 64.02,49.38 64.02,50.45 64.06,50.48 66.28,50.48 66.41,50.61 68.6,50.61 68.69,50.69 68.69,50.89 68.78,50.98 69.11,50.98
GND on TOP (solid shape): 22.58,49.24 22.58,48.32 22.55,48.29 22.16,48.29 22.09,48.36 22.09,48.71 21.97,48.83 20.77,48.83 20.62,48.67 20.62,48.67 20.62,48.29 20.72,48.18 21.86,48.18 21.93,48.12 21.93,47.65 21.87,47.59 18.96,47.59 18.56,48 18.56,48.9 18.71,49.05 20.11,49.05 20.35,49.3 22.52,49.3
GND on TOP (solid shape): 185.24,31.29 179.96,26.32 173.64,22.74 173.11,24.14 173.19,24.18 173.32,24.38 174.31,24.83 175.6,25.49 177.48,26.61 178.5,27.3 179.54,28.09 180.38,28.72 181.11,29.41 182.41,30.68 183.83,32.23 184.05,32.2 184.1,32.26
GND on TOP (solid shape): 90.24,47.59 90.24,47 90.13,46.89 89.79,46.89 89.79,46.9 89.72,46.9 89.67,46.84 89.67,46.29 89.55,46.17 89.44,46.17 89.23,45.96 89.23,45.13 89.44,44.92 89.63,44.92 89.75,44.8 89.75,44.33 89.81,44.26 90.05,44.26 90.06,44.26 90.18,44.26 90.24,44.21 90.24,43.48 90.16,43.4 85.62,43.4 85.52,43.5 85.52,44.19 85.62,44.3 86.04,44.3 86.15,44.41 86.15,44.88 86.28,45 86.43,45 86.44,44.99 86.65,44.99 86.81,45.15 86.81,45.98 86.56,46.23 86.24,46.23 86.15,46.31 86.15,46.78 86.05,46.87 85.95,46.87 85.95,46.87 85.67,46.87 85.56,46.98 85.56,47.63 85.64,47.7 90.12,47.7
GND on TOP (solid shape): 138.94,33.44 139.92,32.2 140.98,31.01 141.19,31.01 141.62,30.57 145.1,27.55 148.55,25.39 150.38,24.55 150.49,24.3 150.68,24.22 150.87,24.14 150.33,22.74 143.38,26.8 137.74,32.54
GND on TOP (solid shape): outline of 83 points within 295.75,42.31 300.67,51.61
GND on TOP (solid shape): 144.95,11.41 146.29,11.09 147.34,10.21 185.6,10.21 186.66,11.09 188,11.41 191.72,11.41 191.72,9.61 187.84,9.61 187.18,9.42 186.74,8.89 186.44,8.54 186.01,8.41 146.42,8.41 146.23,8.48 145.71,9.34 144.95,9.61 132.73,9.61 132.73,11.41
GND on TOP (solid shape): 242.6,77.86 244.06,78.25 245.53,77.87 246.29,77.87 246.47,77.68 246.47,77.05 246.92,76.2 247.08,75.25 243.89,72.26 241.1,75.63 241.06,75.63 240.95,75.73 240.95,75.82 241.06,75.93 241.15,75.93 241.44,76.68 241.92,77.33 241.92,77.76 242.04,77.88 242.58,77.88
GND on TOP (solid shape): outline of 128 points within 0.2,59.56 8.63,64.14
GND on TOP (solid shape): 0.67,46.95 2.84,48.03 5.09,47.16 5.08,47.07 5.07,46.99 5.07,46.48 5.32,45.86 5.92,45.58 4.26,42.32 0.69,43.09 0.69,42.91 0.6,42.82 0.44,42.82 0.32,42.94 0.32,43.64 -0.02,44.99 0.28,46.35 0.28,47.18 0.39,47.29 0.47,47.29 0.67,47.08
GND on TOP (solid shape): 201.33,76.06 201.54,75.97 201.62,75.76 201.62,74.27 202.18,73.72 202.73,74.27 202.73,75.76 202.82,75.97 203.02,76.06 208.83,76.06 209.04,75.97 209.12,75.76 209.12,74.27 209.67,73.72 210.23,74.27 210.23,75.76 210.32,75.97 210.52,76.06 212,76.06 212,75.55 210.74,75.55 210.74,74.27 209.67,73.21 208.61,74.27 208.61,75.55 203.24,75.55 203.24,74.27 202.18,73.21 201.11,74.27 201.11,75.55 199.43,75.55 199.43,76.06
GND on TOP (solid shape): 304.07,46.97 304.33,46.67 304.71,46.56 305.47,46.56 305.47,45.16 305.68,44.66 306.18,44.46 308.28,44.46 308.57,44.52 308.81,44.71 314.38,44.71 314.58,44.62 314.67,44.41 314.67,41.11 314.84,40.65 315.72,40.14 315.91,39.63 315.91,27.22 315.82,27.01 315.62,26.92 314.38,26.92 313.88,26.72 313.67,26.22 313.67,25.29 313.16,25.29 313.16,26.22 313.37,26.9 313.92,27.34 314.5,27.03 315.02,27.43 315.4,27.43 315.4,28.29 315.62,28.51 315.62,36.49 315.4,36.7 315.4,36.77 314.44,36.77 314.31,36.9 314.31,37.59 314.49,37.76 315.4,37.76 315.4,39.63 315.34,39.82 314.45,40.33 314.16,41.11 314.16,44.2 313.65,44.2 313.65,43.63 313.45,43.43 312.28,43.43 312.15,43.55 312.15,44.2 309.66,44.2 309.66,43.6 309.51,43.45 308.7,43.45 308.2,43.95 306.18,43.95 305.32,44.3 304.97,45.16 304.97,46.05 304.71,46.05 304.13,46.19 303.7,46.6
GND on TOP (solid shape): outline of 128 points within 211.34,56.26 315.36,78.06
GND on TOP (solid shape): outline of 122 points within 0.45,0.2 315.36,15.97
GND on TOP (solid shape): outline of 288 points within 0.2,14.45 200.6,80.23
GND on BOTTOM (solid shape): 5.65,68.19 5.47,68.19 5.33,68.04 5.09,68.04 5.09,70.94 5.65,70.94
GND on BOTTOM (solid shape): 14.11,1.76 8.49,1.76 8.49,2.56 13.31,2.56 13.31,5.52 14.11,5.52
GND on BOTTOM (solid shape): 5.47,55.58 5.65,55.58 5.65,53 5.49,53 5.31,52.82 5.09,52.82 5.09,55.72 5.33,55.72
GND on BOTTOM (solid shape): 9.19,57.33 9.19,56.57 8.28,56.57 8,56.85 7.43,56.85 7.4,56.88 7.4,57.69 8.83,57.69
GND on BOTTOM (solid shape): 14.11,7.15 13.84,7.15 13.54,7.46 13.31,7.46 13.31,8.29 13.53,8.51 14.11,8.51
GND on BOTTOM (solid shape): 22.52,29.14 22.52,28.35 22.43,28.27 17.76,28.27 17.62,28.41 17.62,30.03 17.72,30.13 21.52,30.13
GND on BOTTOM (solid shape): 35.64,51.74 35.64,45.94 35.63,45.93 33.44,45.93 33.41,45.96 33.41,51.96 33.51,52.06 35.32,52.06
GND on BOTTOM (solid shape): 40.71,51.95 40.71,50.95 40.64,50.89 39.11,50.89 39.05,50.95 39.05,51.91 39.19,52.05 40.61,52.05
GND on BOTTOM (solid shape): 108.05,26.37 108.05,23.14 107.96,23.06 106.65,23.06 106.58,23.12 106.58,26.38 106.64,26.44 107.98,26.44
GND on BOTTOM (solid shape): 125.28,69.53 125.28,68.67 125.2,68.59 123.52,68.59 123.38,68.73 123.38,69.59 123.46,69.67 125.14,69.67
GND on BOTTOM (solid shape): 268.3,43.46 268.3,33.48 268.06,33.24 253.07,33.24 252.5,33.82 252.5,43.26 252.98,43.74 268.01,43.74
GND on BOTTOM (solid shape): 307.28,58.76 302.3,58.76 302.3,44.41 307.28,44.41 307.28,43.62 301.51,43.62 301.51,59.57 307.28,59.57
GND on BOTTOM (solid shape): 38.7,59.45 38.62,59.37 35.56,59.37 35.34,59.58 35.34,61.79 35.44,61.89 35.74,61.89 35.76,61.91 38.7,61.91
GND on BOTTOM (solid shape): 20.69,68.83 20.69,67.94 20.64,67.89 19.85,67.89 19.7,67.73 18.99,67.73 18.88,67.84 18.88,68.09 19.72,68.93 20.59,68.93
GND on BOTTOM (solid shape): 46.88,43.43 46.88,42.31 46.84,42.27 43.81,42.27 43.78,42.3 43.78,43.46 43.83,43.51 46.81,43.51
GND on BOTTOM (solid shape): 54.23,15.34 54.23,14.47 54.16,14.41 50.99,14.41 50.83,14.56 50.83,15.31 50.96,15.44 51.96,15.44 51.96,15.45 54.11,15.45
GND on BOTTOM (solid shape): 97.48,70.51 97.48,69.18 97.45,69.15 88.35,69.15 88.33,69.17 88.33,69.2 88.33,70.55 88.42,70.64 97.35,70.64
GND on BOTTOM (solid shape): 127.99,71.48 127.99,68.89 128.22,68.66 128.22,67.14 128.08,67 126.67,67 126.54,67.13 126.54,71.48 126.6,71.54 127.93,71.54
GND on BOTTOM (solid shape): 291.18,67.07 291.18,62.38 291.06,62.25 289.66,62.25 289.41,62.5 289.41,66.95 289.79,67.33 290.93,67.33
GND on BOTTOM (solid shape): 50.57,43.11 50.57,40.38 50.27,40.07 48.51,40.07 48.28,40.3 48.28,43.14 48.44,43.29 50.39,43.29
GND on BOTTOM (solid shape): 119.6,49.51 119.6,48.36 119.54,48.3 118.82,48.3 118.74,48.39 118.74,49.49 118.85,49.61 119.5,49.61
GND on BOTTOM (solid shape): 34.06,40.75 34.06,38.35 33.57,37.86 31.78,37.86 31.16,38.48 31.16,40.68 31.31,40.83 33.98,40.83
GND on BOTTOM (solid shape): 84.44,69.82 84.44,66.36 84.31,66.24 82.94,66.24 82.78,66.4 82.78,66.7 82.78,66.7 82.79,66.72 82.79,69.69 83.17,70.07 84.19,70.07
GND on BOTTOM (solid shape): 131.51,55.17 131.51,54.06 131.44,53.99 126.65,53.99 126.6,54.04 126.6,55.14 126.67,55.21 131.47,55.21
GND on BOTTOM (solid shape): 33.3,46.32 33.3,45.89 33.39,45.8 34.04,45.8 34.12,45.72 34.12,44.56 33.92,44.37 31.71,44.37 31.58,44.49 31.58,46.31 31.68,46.41 33.21,46.41
GND on BOTTOM (solid shape): 103.49,69.12 103.49,67.98 103.71,67.76 103.71,66.99 102.56,65.85 101.26,65.85 101.05,66.06 101.05,69.1 101.28,69.33 103.28,69.33
GND on BOTTOM (solid shape): 119.75,57.61 119.75,56.79 119.72,56.76 118.4,56.76 118.3,56.66 118.3,55.94 118.22,55.86 117.76,55.86 117.72,55.91 117.72,57.35 118.01,57.64 119.72,57.64
GND on BOTTOM (solid shape): 122.44,42.62 122.44,42.62 122.51,42.54 122.51,41.52 122.3,41.31 119.18,41.31 119.06,41.43 119.06,42.56 119.12,42.62 119.12,42.62 119.18,42.68 122.38,42.68
GND on BOTTOM (solid shape): 126.38,55.39 126.38,54.88 126.3,54.79 125.41,54.79 125.35,54.86 124.49,54.86 124.44,54.91 124.44,55.37 124.44,55.4 124.5,55.46 126.32,55.46
GND on BOTTOM (solid shape): 39.53,26.1 39.53,21.73 39.41,21.6 38.65,21.6 38.26,21.22 35.69,21.22 34.45,22.46 34.45,24.65 34.71,24.9 35.55,24.9 36.97,26.33 39.31,26.33
GND on BOTTOM (solid shape): 116.14,29.5 116.14,28.79 114.97,27.62 114.97,27.49 114.88,27.4 114.23,27.4 114.16,27.47 114.16,29.52 114.25,29.61 116.03,29.61
GND on BOTTOM (solid shape): 128.69,46.79 130.8,46.79 130.94,46.65 130.94,45.61 130.86,45.54 128.46,45.54 127.41,46.59 126.45,46.59 126.39,46.64 126.39,46.8 126.47,46.88 128.6,46.88
GND on BOTTOM (solid shape): 196.57,46.18 196.57,44.42 196.88,44.11 197.62,44.11 197.71,44.02 197.71,36.22 197.51,36.02 194.91,36.02 194.74,36.19 194.74,46.25 194.89,46.39 196.36,46.39
GND on BOTTOM (solid shape): 49.51,53.36 49.51,49.6 49.34,49.43 47.84,49.43 47.66,49.62 47.66,50.51 47.66,50.52 47.66,53.41 47.79,53.54 49.34,53.54
GND on BOTTOM (solid shape): 115.25,25.83 115.25,25.26 115.23,25.24 114.57,25.24 114.34,25 114.34,23.94 114.28,23.88 114.14,23.88 114.08,23.94 114.08,25.8 114.14,25.85 115.23,25.85
GND on BOTTOM (solid shape): 14.11,13.19 14.04,13.1 13.93,13.12 13.61,13.44 13.31,13.44 13.31,16.91 8.49,16.91 8.49,17.71 14.11,17.71
GND on BOTTOM (solid shape): 50.08,37.96 50.08,37.06 51.18,35.96 51.18,33.13 49.98,31.93 48.01,31.93 47.9,32.04 47.89,32.04 47.89,35.66 47.68,35.86 47.68,37.08 48.73,38.12 49.92,38.12
GND on BOTTOM (solid shape): 8.24,68.23 8.24,66.52 8.43,66.33 8.43,66.25 8.43,66.25 8.43,66.2 8.36,66.13 7.59,66.13 7.52,66.2 7.52,66.32 7.7,66.5 7.7,68.04 7.69,68.06 7.69,68.25 7.72,68.29 8.19,68.29
GND on BOTTOM (solid shape): 42.25,31.14 42.72,31.14 42.73,31.13 42.73,24.06 42.71,24.05 41.55,24.05 41.51,24.09 41.51,28.42 41.4,28.53 38.06,28.53 37.7,28.89 37.7,30.68 37.89,30.87 41.32,30.87 41.6,31.15 42.24,31.15
GND on BOTTOM (solid shape): 44.41,40.17 44.41,38.99 44.4,38.99 44.4,38.28 44.25,38.12 43.26,38.12 43.01,38.37 43.01,39.32 42.66,39.66 41.55,39.66 41.46,39.75 41.46,39.97 41.51,40.02 43.17,40.02 43.37,40.22 44.37,40.22
GND on BOTTOM (solid shape): 107.36,20 107.36,19.37 107.26,19.28 107.26,18.7 107.21,18.64 106.6,18.64 106.35,18.89 105.26,18.89 105.19,18.96 105.19,19.09 105.27,19.16 106.09,19.16 106.19,19.27 106.19,19.46 106.76,20.03 107.33,20.03
GND on BOTTOM (solid shape): 103.76,18.88 103.76,17.19 103.52,16.95 103.11,16.95 102.95,16.8 102.95,14.66 102.82,14.53 101.86,14.53 101.76,14.62 101.76,16.88 101.9,17.02 101.9,17.18 102.37,17.65 103.31,17.65 103.44,17.77 103.44,18.89 103.53,18.98 103.66,18.98
GND on BOTTOM (solid shape): 119.28,22.44 119.28,21.44 119.21,21.37 118.27,21.37 117.93,21.71 116.71,21.71 116.05,21.05 114.18,21.05 113.97,21.26 113.97,21.61 114.07,21.7 114.07,22.51 114.16,22.6 115.36,22.6 115.41,22.65 119.07,22.65
GND on BOTTOM (solid shape): 130.5,50.54 130.5,50.29 130.36,50.15 130.36,48.99 130.3,48.93 130.21,48.93 128.7,48.93 128.64,48.98 128.64,49.51 128.64,49.59 128.9,49.85 129.26,49.85 130.13,50.72 130.32,50.72
GND on BOTTOM (solid shape): 96.83,64.23 96.83,63.6 96.74,63.51 88.08,63.51 87.91,63.58 87.74,63.51 86.69,63.51 86.61,63.59 86.61,64.23 86.69,64.32 96.74,64.32
GND on BOTTOM (solid shape): 14.54,54.93 14.54,50.42 14.25,50.13 14.16,50.13 13.63,50.67 13.63,51.58 13.38,51.83 11.73,51.83 11.44,51.55 10.38,51.55 10.32,51.6 10.32,51.71 10.32,54.96 10.39,55.03 14.43,55.03
GND on BOTTOM (solid shape): 74.4,72.92 74.4,71.71 74.69,71.42 76.96,71.42 77.15,71.23 77.15,69.55 74.5,66.9 74.5,66.44 74.33,66.27 70.9,66.27 69.94,67.24 69.94,71.95 70.09,72.11 71.16,72.11 71.45,72.4 72.36,72.4 72.55,72.59 72.55,72.85 72.81,73.11 74.21,73.11
GND on BOTTOM (solid shape): 125.86,64.93 125.86,63.75 125.75,63.64 121.99,63.64 121.36,63 121.35,62.99 121.06,62.7 121.06,62.08 120.75,61.78 119.71,61.78 119.54,61.94 119.54,63.12 119.7,63.28 120.69,63.28 121.04,63.63 121.04,64.89 121.18,65.03 125.76,65.03
GND on BOTTOM (solid shape): 122.21,76.22 122.21,74.35 122.08,74.22 118.5,74.22 117.96,73.68 115.99,73.68 115.8,73.49 115.8,73.11 115.61,72.92 113.38,72.92 113,72.54 111.35,72.54 111.16,72.73 111.16,74.19 111.04,74.31 109.38,74.31 109.13,74.06 108.23,74.06 108.04,74.25 108.04,76.21 108.18,76.34 122.08,76.34
GND on BOTTOM (solid shape): 42.85,48.99 42.85,47.87 42.97,47.74 42.97,47.55 43.13,47.39 44.77,47.39 45.2,46.97 45.2,44.78 44.99,44.57 42.67,44.57 42.49,44.75 39.36,44.75 39.18,44.93 39.18,45.59 38.98,45.79 38.44,45.79 38.34,45.89 38.34,48.69 38.5,48.86 40.84,48.86 41.08,49.1 42.74,49.1
GND on BOTTOM (solid shape): 220.63,68.31 215.13,68.31 215.13,76.51 215.32,76.87 215.38,77.26 215.62,77.82 216.18,78.06 220.63,78.06
GND on BOTTOM (solid shape): 122.02,56.05 122.02,55.27 122.38,54.91 122.38,53.01 122.45,52.93 122.45,52.11 122.58,51.98 122.97,51.98 123.04,52.05 123.04,52.7 123.12,52.79 125.01,52.79 125.09,52.71 125.09,51.99 125.3,51.77 126.36,51.77 126.4,51.74 126.4,51.12 126.31,51.04 121.93,51.04 121.74,51.23 121.74,53 121.29,53.45 121.29,54.8 121.72,55.23 121.72,56.05 121.8,56.13 121.94,56.13
GND on BOTTOM (solid shape): 315.36,1 315.13,0.44 314.57,0.2 308.73,0.2 308.73,0.71 314.57,0.71 314.77,0.8 314.85,1 314.85,10.94 315.36,10.94
GND on BOTTOM (solid shape): 0.43,72.96 0.81,72.71 1.25,72.62 1.32,72.62 1.52,72.06 1.52,66.86 1.32,66.3 1.25,66.3 0.81,66.21 0.43,65.96 0.2,65.96 0.2,72.96
GND on BOTTOM (solid shape): 0.43,57.74 0.81,57.49 1.25,57.4 1.32,57.4 1.52,56.84 1.52,51.64 1.32,51.08 1.25,51.08 0.81,50.99 0.43,50.74 0.2,50.74 0.2,57.74
GND on BOTTOM (solid shape): 49.21,79.56 49.36,79.54 49.44,79.52 49.51,79.5 49.58,79.47 49.65,79.43 49.71,79.38 49.77,79.33 49.83,79.27 49.87,79.21 49.91,79.14 49.95,79.07 49.96,79.04 49.96,78.72 50.43,78.25 50.43,77.68 50.09,77.34 50.09,74.82 49.77,74.5 30.52,74.5 29.82,75.2 29.82,78.05 30.52,78.05 30.52,75.79 31.06,75.24 48.97,75.24 49.08,75.35 49.08,77.89 49.08,78.25 48.96,78.38 47.08,78.38 46.98,78.28 46.98,77.52 46.92,77.46 46.72,77.46 46.67,77.52 46.67,78.28 46.57,78.38 45.85,78.38 45.78,78.31 45.78,77.54 45.71,77.47 45.51,77.47 45.45,77.54 45.45,78.3 45.37,78.38 43.84,78.38 43.78,78.32 43.78,77.54 43.71,77.47 43.58,77.47 43.49,77.56 43.49,78.32 43.44,78.38 39.85,78.38 39.78,78.3 39.78,77.54 39.71,77.48 39.52,77.48 39.45,77.55 39.45,78.3 39.37,78.38 35.85,78.38 35.74,78.26 35.74,77.53 35.64,77.43 35.2,77.43 35.11,77.51 35.11,78.2 34.94,78.38 30.85,78.38 30.52,78.05 29.82,78.05 29.82,78.19 29.81,78.19 29.81,78.37 29.46,78.72 29.46,79.42 29.6,79.56
GND on BOTTOM (solid shape): outline of 89 points within 9.77,64.79 15,69.41
GND on BOTTOM (solid shape): 6,80.23 6.17,79.84 6.23,79.43 6.23,78.43 6.35,77.82 6.72,77.32 6.72,74.89 6.39,74.89 5.9,74.77 5.52,74.46 3.48,74.46 3.07,74.81 2.54,74.94 1.25,74.94 0.72,74.81 0.31,74.46 0.2,74.46 0.2,76.7 0.2,76.7 0.2,78.43 0.73,79.7 2,80.23 4.28,80.23
GND on BOTTOM (solid shape): 0.68,46.96 2.84,48.03 5.09,47.16 5.08,47.07 5.07,46.99 5.07,46.48 5.32,45.86 5.92,45.58 4.26,42.32 0.68,43.1 0.68,42.89 0.51,42.72 0.29,42.95 0.29,43.7 -0.02,45.02 0.27,46.33 0.27,47.27 0.38,47.37 0.48,47.37 0.68,47.18
GND on BOTTOM (solid shape): outline of 170 points within 0.2,41.62 7.88,49.24
GND on BOTTOM (solid shape): 248.08,78.06 248.64,77.82 248.87,77.26 248.87,75.26 249.22,74.41 250.07,74.06 264.09,74.06 264.94,74.41 265.29,75.26 265.29,77.26 265.52,77.82 266.09,78.06 283.88,78.06 283.88,71.26 270.44,71.26 266.89,73.6 263.34,71.26 250.08,71.26 250.08,71.74 238.58,71.74 238.58,75.26 225.83,75.26 225.83,76.08 226.79,76.44 227.27,77.36 227.53,77.86 228.06,78.06 228.69,78.06
GND on BOTTOM (solid shape): 0.31,64.46 0.72,64.11 1.25,63.98 2.54,63.98 3.07,64.11 3.48,64.46 5.51,64.46 5.9,64.15 6.39,64.03 6.53,64.03 6.53,62.24 5.07,61.53 6.53,60.82 6.53,59.67 6.39,59.67 5.9,59.55 5.52,59.24 3.48,59.24 3.07,59.59 2.54,59.72 1.25,59.72 0.72,59.59 0.31,59.24 0.2,59.24 0.2,59.85 0.29,60.06 1.01,60.35 1.22,60.85 1.22,62.85 1.01,63.35 0.29,63.64 0.2,63.85 0.2,64.46
GND on BOTTOM (solid shape): outline of 199 points within 14.88,12.96 133.18,78.26
GND on BOTTOM (solid shape): 304.2,46.77 304.43,46.61 304.71,46.56 305.47,46.56 305.47,45.16 305.68,44.66 306.18,44.46 308.28,44.46 308.57,44.52 308.81,44.71 314.38,44.71 314.58,44.62 314.67,44.41 314.67,41.11 314.84,40.65 315.72,40.14 315.91,39.63 315.91,27.22 315.82,27.01 315.62,26.92 314.38,26.92 313.88,26.72 313.67,26.22 313.67,25.29 313.16,25.29 313.16,26.22 313.2,26.52 313.31,26.8 313.54,26.8 313.54,27.09 313.72,27.24 313.92,27.34 314.5,27.03 315.02,27.43 315.4,27.43 315.4,39.63 315.34,39.82 314.45,40.33 314.16,41.11 314.16,44.2 313.63,44.2 313.63,43.66 313.47,43.5 312.25,43.5 312.13,43.63 312.13,44.2 309.82,44.2 309.82,43.63 309.66,43.48 308.16,43.48 308.04,43.6 308.04,43.95 306.18,43.95 305.32,44.3 304.97,45.16 304.97,46.05 304.71,46.05 304.19,46.17 303.77,46.49 304.05,46.77
GND on BOTTOM (solid shape): outline of 131 points within 0.45,0.2 306.54,15.97
GND on BOTTOM (solid shape): outline of 467 points within 0.2,14.42 315.36,80.23
GND on BOTTOM (solid shape): outline of 4375 points within 17.78,46.58 28.92,57.84
GND on IN1 (solid shape): 8.82,50.84 7.13,50.84 7.13,51.48 8.82,51.48
GND on IN1 (solid shape): 128.29,68.63 128.29,67.04 128.2,66.95 127.16,66.95 127.04,67.07 127.04,68.6 127.13,68.69 128.23,68.69
GND on IN1 (solid shape): 19.18,62.2 19.18,59.93 18.63,59.38 18.63,59.02 18.53,58.92 17.94,58.92 17.84,59.02 17.84,62.2 17.94,62.3 19.08,62.3
GND on IN1 (solid shape): 122.09,56.12 122.09,55.94 122.24,55.79 122.9,55.79 122.95,55.74 122.95,53.71 122.85,53.61 121.6,53.61 121.43,53.78 121.43,55.97 121.62,56.16 122.05,56.16
GND on IN1 (solid shape): 75.36,72.4 75.75,72.4 77.14,71.01 77.14,69.49 76.52,68.87 74.19,68.87 71.76,71.3 71.76,72.25 71.92,72.41 75.35,72.41
GND on IN1 (solid shape): 25.81,74.62 25.81,74.51 25.4,74.1 25.25,74.1 25.11,73.96 25.11,73.71 24.97,73.57 24.28,73.57 24.18,73.67 24.18,73.81 24.29,73.92 24.5,73.92 24.71,74.13 24.71,74.58 24.91,74.78 25.65,74.78
GND on IN1 (solid shape): 9.49,67.11 9.49,66.35 8.77,65.63 8.55,65.63 8.41,65.77 8.41,65.99 8.34,66.06 7.46,66.06 7.16,66.06 7.09,66.14 7.09,66.66 7.15,66.73 9.02,66.73 9.1,66.81 9.1,67.1 9.11,67.12 9.49,67.12
GND on IN1 (solid shape): 123.6,74.73 123.6,74.38 123.45,74.22 118.23,74.22 117.98,73.97 117.98,72.22 117.7,71.94 116.15,71.94 116.15,72.07 116.03,72.19 114.49,72.19 114.46,72.22 111.86,72.22 111.84,72.19 111.78,72.19 111.48,71.89 111.48,71.61 110.04,71.61 108.63,73.02 108.63,76.01 108.79,76.16 122.17,76.16
GND on IN1 (solid shape): 128.8,46.33 128.87,46.5 129.06,46.53 130.01,46.53 130.43,46.12 130.43,45.92 130.31,45.8 128.87,45.8 128.75,45.92 128.75,46 128.75,46.04 128.76,46.08
GND on IN1 (solid shape): 5.97,57.35 6.48,57.35 6.58,57.25 6.58,57.21 6.58,57.21 6.58,57.02 6.48,56.92 6.3,56.92 6.27,56.95 5.83,56.95 5.72,56.83 5.72,55.87 5.63,55.77 5.33,55.57 5.44,55.22 5.44,55.04 5.31,54.79 5.44,54.54 5.44,54.36 5.32,54.16 5.36,53.94 5.36,52.63 5.72,52.28 5.72,51.83 5.81,51.74 6.06,51.74 6.12,51.67 6.3,51.67 6.33,51.68 6.36,51.69 6.39,51.69 6.56,51.4 6.24,51.33 5.87,51.33 5.74,51.2 5.39,51.2 4.77,51.82 4.77,57.09 4.87,57.19 5.17,57.19 5.56,57.58 5.74,57.58
GND on IN1 (solid shape): 5.95,72.59 6.18,72.59 6.26,72.51 6.58,72.36 6.27,72.17 5.84,72.17 5.72,72.05 5.72,71.09 5.63,70.99 5.33,70.79 5.44,70.44 5.44,70.26 5.31,70.01 5.44,69.76 5.44,69.58 5.32,69.28 5.53,69.03 5.53,68.89 5.47,68.58 5.72,68.38 5.72,67.05 5.81,66.96 6.06,66.96 6.12,66.89 6.3,66.89 6.33,66.9 6.36,66.91 6.39,66.91 6.56,66.62 6.24,66.55 5.87,66.55 5.74,66.42 5.39,66.42 4.77,67.04 4.77,72.31 4.87,72.41 5.13,72.41 5.2,72.41 5.59,72.8 5.73,72.8
GND on IN1 (solid shape): 201.33,76.06 201.54,75.97 201.62,75.76 201.62,74.27 202.18,73.72 202.73,74.27 202.73,75.76 202.82,75.97 203.02,76.06 208.83,76.06 209.04,75.97 209.12,75.76 209.12,74.27 209.67,73.72 210.23,74.27 210.23,75.76 210.32,75.97 210.52,76.06 212,76.06 212,75.55 210.74,75.55 210.74,74.27 209.67,73.21 208.61,74.27 208.61,75.55 203.24,75.55 203.24,74.27 202.18,73.21 201.11,74.27 201.11,75.55 199.43,75.55 199.43,76.06
GND on IN1 (solid shape): 304.12,46.87 304.37,46.64 304.71,46.56 305.47,46.56 305.47,45.16 305.68,44.66 306.18,44.46 308.28,44.46 308.57,44.52 308.81,44.71 314.38,44.71 314.58,44.62 314.67,44.41 314.67,41.11 314.84,40.65 315.72,40.14 315.91,39.63 315.91,27.22 315.82,27.01 315.62,26.92 314.38,26.92 313.88,26.72 313.67,26.22 313.67,25.29 313.16,25.29 313.16,26.22 313.37,26.9 313.92,27.34 314.5,27.03 315.02,27.43 315.4,27.43 315.4,39.63 315.34,39.82 314.45,40.33 314.16,41.11 314.16,44.2 313.63,44.2 313.63,43.53 313.5,43.4 312.38,43.4 312.2,43.58 312.2,44.2 309.61,44.2 309.61,43.58 309.43,43.4 308.29,43.4 308.01,43.68 308.01,43.95 306.18,43.95 305.32,44.3 304.97,45.16 304.97,46.05 304.71,46.05 304.14,46.19 303.71,46.58 304,46.87
GND on IN1 (solid shape): outline of 136 points within 211.47,56.23 315.36,78.06
GND on IN1 (solid shape): outline of 123 points within 0.45,0.2 315.36,15.97
GND on IN1 (solid shape): outline of 307 points within 0.2,14.4 200.6,80.23
GND on IN2 (solid shape): 304.15,46.83 304.4,46.63 304.71,46.56 305.47,46.56 305.47,45.16 305.68,44.66 306.18,44.46 308.28,44.46 308.57,44.52 308.81,44.71 314.38,44.71 314.58,44.62 314.67,44.41 314.67,41.11 314.84,40.65 315.72,40.14 315.91,39.63 315.91,27.22 315.82,27.01 315.62,26.92 314.38,26.92 313.88,26.72 313.67,26.22 313.67,25.29 313.16,25.29 313.16,26.22 313.37,26.9 313.92,27.34 314.5,27.03 315.02,27.43 315.4,27.43 315.4,39.63 315.34,39.82 314.45,40.33 314.16,41.11 314.16,44.2 313.6,44.2 313.6,43.53 313.55,43.48 312.25,43.48 312.1,43.63 312.1,44.2 309.74,44.2 309.74,43.6 309.59,43.45 308.29,43.45 308.14,43.6 308.14,43.95 306.18,43.95 305.32,44.3 304.97,45.16 304.97,46.05 304.71,46.05 304.16,46.18 303.74,46.54 304.03,46.83
GND on IN2 (solid shape): outline of 124 points within 0.45,0.2 315.36,15.97
GND on IN2 (solid shape): outline of 488 points within 0.2,14.4 315.36,80.23
GND on IN3 (solid shape): 33.68,45.62 33.68,45.17 33.47,44.96 32.39,44.96 32.3,45.05 32.3,45.81 32.52,46.04 33.26,46.04
GND on IN3 (solid shape): 97.12,70.71 97.12,69.23 97.03,69.14 88.66,69.14 88.58,69.23 88.58,70.63 88.71,70.76 97.07,70.76
GND on IN3 (solid shape): 122.53,75.68 122.53,72.98 122.27,72.72 108.9,72.72 108.54,73.07 108.54,75.94 108.76,76.15 122.06,76.15
GND on IN3 (solid shape): 104.16,18.6 104.16,17.72 103.97,17.53 103.55,17.53 103.34,17.74 103.34,18.62 103.51,18.79 103.98,18.79
GND on IN3 (solid shape): 103.16,15.76 103.16,14.75 103.07,14.66 103.04,14.63 101.97,14.63 101.86,14.73 101.86,16.53 102.03,16.7 102.22,16.7
GND on IN3 (solid shape): 128.32,68.67 128.32,67.06 128.2,66.95 127.16,66.95 127.04,67.07 127.04,68.6 127.16,68.73 128.26,68.73
GND on IN3 (solid shape): 130.45,46.12 130.62,46.12 130.73,46.01 130.73,45.89 130.48,45.64 128.85,45.64 128.75,45.74 128.75,46.45 128.87,46.56 130.01,46.56
GND on IN3 (solid shape): 122.09,56.12 122.09,55.94 122.24,55.79 122.9,55.79 122.95,55.74 122.95,53.99 122.75,53.8 121.58,53.8 121.45,53.93 121.44,53.93 121.44,55.97 121.63,56.16 122.05,56.16
GND on IN3 (solid shape): 77.15,71.27 77.15,69.56 76.43,68.84 74.62,68.84 71.7,71.77 71.7,72.31 71.7,72.32 71.7,72.54 71.86,72.69 72.33,72.69 72.74,73.11 75.31,73.11
GND on IN3 (solid shape): 8.85,51.34 8.85,50.92 8.75,50.82 7.2,50.82 7.11,50.91 7.11,50.98 7.04,51.05 6.71,51.05 6.61,51.15 6.61,51.28 6.7,51.37 7.3,51.37 7.4,51.48 8.71,51.48
GND on IN3 (solid shape): 8.82,66.34 8.82,65.74 8.73,65.65 8.56,65.65 8.32,65.89 8.32,66.04 7.2,66.04 7.11,66.13 7.11,66.2 7.04,66.27 6.78,66.27 6.65,66.39 6.65,66.5 6.75,66.59 7.3,66.59 7.68,66.98 8.18,66.98
GND on IN3 (solid shape): 118.63,22.53 118.72,22.53 119.37,21.89 119.37,21.58 119.25,21.47 118.11,21.47 117.86,21.72 116.57,21.72 115.92,21.08 114.07,21.08 113.87,21.27 113.87,22.17 114.33,22.62 114.34,22.62 114.95,23.23 117.93,23.23
GND on IN3 (solid shape): 9.22,72.83 9.22,72.69 9.05,72.52 8.29,72.52 8.23,72.46 8.23,72.32 8.1,72.19 7.43,72.19 7.3,72.31 7.3,72.36 6.97,72.36 6.86,72.48 6.86,72.57 7.13,72.84 7.37,72.84 7.48,72.95 9.1,72.95
GND on IN3 (solid shape): 9.22,57.61 9.22,57.47 9.05,57.3 8.29,57.3 8.23,57.24 8.23,57.1 8.1,56.97 7.43,56.97 7.26,57.14 6.97,57.14 6.84,57.27 6.84,57.48 6.99,57.62 7.37,57.62 7.48,57.73 9.1,57.73
GND on IN3 (solid shape): 5.18,71.44 5.18,71 5.25,70.98 5.28,70.97 5.3,70.95 5.33,70.93 5.33,70.78 5.31,70.69 5.33,70.59 5.33,70.11 5.31,70.02 5.33,69.92 5.33,69.42 5.31,69.33 5.33,69.23 5.33,68.09 5.26,68.02 5.26,67.81 4.7,67.81 4.7,71.54 5.08,71.54
GND on IN3 (solid shape): 5.18,56.22 5.18,55.78 5.25,55.76 5.28,55.75 5.3,55.73 5.33,55.71 5.33,55.56 5.31,55.47 5.33,55.37 5.33,54.89 5.31,54.8 5.33,54.7 5.33,54.2 5.31,54.11 5.33,54.01 5.33,52.87 5.26,52.8 5.26,52.59 4.7,52.59 4.7,56.32 5.08,56.32
GND on IN3 (solid shape): 304.17,46.8 304.41,46.62 304.71,46.56 305.47,46.56 305.47,45.16 305.68,44.66 306.18,44.46 308.28,44.46 308.57,44.52 308.81,44.71 314.38,44.71 314.58,44.62 314.67,44.41 314.67,41.11 314.84,40.65 315.72,40.14 315.91,39.63 315.91,27.22 315.82,27.01 315.62,26.92 314.38,26.92 313.88,26.72 313.67,26.22 313.67,25.29 313.16,25.29 313.16,26.22 313.37,26.9 313.92,27.34 314.5,27.03 315.02,27.43 315.4,27.43 315.4,39.63 315.34,39.82 314.45,40.33 314.16,41.11 314.16,44.2 313.63,44.2 313.63,43.6 313.45,43.43 312.3,43.43 312.13,43.6 312.13,44.2 309.71,44.2 309.71,43.63 309.54,43.45 308.27,43.45 308.09,43.63 308.09,43.95 306.18,43.95 305.32,44.3 304.97,45.16 304.97,46.05 304.71,46.05 304.18,46.17 303.76,46.51 304.04,46.8
GND on IN3 (solid shape): outline of 123 points within 0.45,0.2 315.36,15.97
GND on IN3 (solid shape): outline of 472 points within 0.2,14.4 315.36,80.23
GND on TOP: 25.32,52.52 25.66,52.52 25.73,52.44 25.73,51.48 25.88,51.33 26.36,51.33 26.44,51.26 26.44,50.92 26.08,50.57 26.08,48.52 25.99,48.42 25.32,48.42 25.24,48.5 25.24,52.44
GND on TOP: 123,53.11 123,52.35 123.06,52.29 125.7,52.29 125.84,52.43 125.84,53.04 125.7,53.18 123.06,53.18
GND on TOP: 47.57,30.23 48.34,30.23 48.54,30.03 48.54,27.92 48.3,27.68 47.33,27.68 47.25,27.76 47.25,28.03 47.57,28.35 47.57,29.05 47.47,29.15 47.47,29.68 47.47,29.68 47.47,30.12
GND on TOP: 91.73,48.98 93.13,48.98 93.19,48.91 93.19,41.93 93.06,41.8 91.73,41.8 91.67,41.87 91.67,48.91
GND on TOP: 246.02,40.05 246.15,39.92 246.15,39.24 246.2,39.19 246.46,39.19 246.53,39.11 246.53,36.52 246.44,36.43 245.12,36.43 245.01,36.54 245.01,39.92 245.13,40.05
