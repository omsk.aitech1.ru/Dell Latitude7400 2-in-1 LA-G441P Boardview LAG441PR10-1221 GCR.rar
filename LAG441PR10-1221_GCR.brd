# Allegro board LAG441PR10-1221_GCR.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBT_A_TTX_C_DRX_N1: length 14.3
  IN1 w0.074: v2(6.05,52.62) v4(6.38,52.5)
  IN3 w0.074: v5(6.05,52.42) v4(6.38,52.5) ; v5(7.15,52.42) arc(7.24,52.36) 7.35,52.33 8.51,52.33 arc(8.6,52.35) 8.68,52.41 9.65,53.37 arc(9.84,53.5) 10.07,53.55 10.57,53.55 arc(11,53.37) 11.19,52.93 11.19,52.76 arc(11.22,52.6) 11.31,52.47 14.48,49.3 arc(15.09,48.89) 15.81,48.75 16.14,48.75 arc(16.24,48.77) v5(16.33,48.82)
  BOTTOM w0.112: v5(6.05,52.42) 6.09,52.38 arc(6.13,52.35) 6.17,52.34 6.39,52.34 arc(6.44,52.35) 6.47,52.38 DT31.2 6.77,52.42 arc(6.87,52.35) 6.99,52.33 arc(7.06,52.34) 7.12,52.38 v5(7.15,52.42) ; v5(16.33,48.82) 16.51,48.82 arc(16.65,48.85) CT45.2
TBT_A_TTX_C_DRX_N2: length 12.8
  TOP w0.112: JUSBC1.A3 8.03,55.87 arc(8.1,55.88) 8.16,55.92 8.23,55.99 arc(8.27,56.02) 8.33,56.03 9.01,56.03 arc(9.13,56.01) 9.22,55.94 DT10.1 9.48,56.03 arc(9.51,56.06) 9.55,56.07 arc(9.56,56.07) 9.56,56.07 9.56,56.07 arc(9.68,56.04) v2(9.78,55.98)
  IN1 w0.074: v2(9.78,55.98) v4(10.11,55.92)
  IN3 w0.074: v4(10.11,55.92) 10.12,55.93 arc(10.26,56.02) 10.41,56.05 10.96,56.05 arc(11.3,55.98) 11.59,55.79 11.6,55.78 arc(11.78,55.5) 11.85,55.17 11.85,55.16 11.95,54.34 arc(12.09,53.84) 12.37,53.4 12.84,52.87 arc(13.01,52.62) 13.14,52.35 13.18,52.25 arc(13.19,52.24) 13.19,52.22 arc(13.29,51.96) 13.45,51.73 14.47,50.71 arc(15.1,50.28) 15.85,50.14 16.11,50.14 arc(16.23,50.11) v5(16.33,50.04)
  BOTTOM w0.112: v5(16.33,50.04) 16.51,50.04 arc(16.65,50.02) CT41.2
TBT_A_TTX_C_DRX_P1: length 14.3
  IN1 w0.074: v2(6.05,52.11) v4(6.38,51.99)
  IN3 w0.074: v5(6.05,52.04) v4(6.38,51.99) ; v5(16.33,48.47) arc(16.24,48.52) 16.14,48.54 15.82,48.54 arc(15.02,48.7) 14.34,49.15 11.17,52.33 arc(11.03,52.53) 10.98,52.76 10.98,52.93 arc(10.86,53.22) 10.57,53.35 10.07,53.35 arc(9.92,53.32) 9.79,53.23 8.82,52.26 arc(8.68,52.17) 8.51,52.13 7.39,52.13 arc(7.26,52.11) v5(7.15,52.03)
  BOTTOM w0.112: v5(16.33,48.47) 16.51,48.47 arc(16.65,48.44) CT43.2 ; v5(6.05,52.04) 6.07,52.07 arc(6.15,52.12) 6.24,52.14 6.33,52.14 arc(6.42,52.12) 6.5,52.07 DT35.2 6.74,52.02 arc(6.85,52.1) 6.99,52.12 arc(7.06,52.11) 7.12,52.07 v5(7.15,52.03)
TBT_A_TTX_C_DRX_P2: length 12.8
  TOP w0.112: v2(9.78,56.36) 9.72,56.3 arc(9.68,56.28) 9.64,56.27 9.6,56.27 arc(9.52,56.29) 9.45,56.33 DT6.1 9.21,56.38 arc(9.04,56.27) 8.84,56.23 8.44,56.23 arc(8.31,56.26) 8.2,56.33 arc(8.17,56.36) 8.12,56.36 JUSBC1.A2
  IN1 w0.074: v2(9.78,56.36) v4(10.11,56.42)
  IN3 w0.074: v4(10.11,56.42) 10.12,56.41 arc(10.3,56.29) 10.5,56.25 10.96,56.25 arc(11.38,56.17) 11.73,55.93 11.74,55.92 arc(11.97,55.58) 12.05,55.17 12.15,54.37 arc(12.28,53.92) 12.53,53.53 12.99,53 arc(13.19,52.73) 13.33,52.42 13.37,52.31 arc(13.38,52.3) 13.38,52.28 13.38,52.28 arc(13.47,52.06) 13.6,51.87 14.61,50.85 arc(15.18,50.47) 15.85,50.34 16.18,50.34 arc(16.26,50.35) v5(16.33,50.4)
  BOTTOM w0.112: v5(16.33,50.4) 16.51,50.4 arc(16.65,50.42) CT39.2
TBT_A_TTX_DRX_N1: length 2
  BOTTOM w0.076: CT45.1 17.5,48.77 arc(17.54,48.74) 17.58,48.73 17.63,48.73 arc(17.73,48.75) 17.81,48.81 17.97,48.97 arc(18.02,49.01) 18.07,49.03 18.08,49.04 arc(18.15,49.07) 18.22,49.12 arc(18.27,49.16) 18.31,49.21 arc(18.37,49.24) 18.43,49.26 18.64,49.26 arc(18.72,49.24) 18.79,49.19 18.89,49.09 arc(18.93,49.06) UT2.B19
TBT_A_TTX_DRX_N2: length 1.9
  BOTTOM w0.076: UT2.B17 18.9,49.89 arc(18.77,49.8) 18.61,49.77 18.45,49.77 arc(18.36,49.79) 18.28,49.84 18.13,49.99 18.07,50.05 18.06,50.06 arc(18.06,50.06) 18.05,50.07 arc(18.03,50.08) 18.02,50.1 arc(17.99,50.11) 17.96,50.12 17.65,50.12 arc(17.53,50.09) 17.43,50.03 CT41.1
TBT_A_TTX_DRX_P1: length 1.9
  BOTTOM w0.076: CT43.1 17.52,48.54 arc(17.55,48.56) 17.58,48.57 17.63,48.57 arc(17.79,48.6) 17.93,48.69 18.09,48.85 arc(18.11,48.87) 18.13,48.88 arc(18.16,48.88) 18.18,48.89 18.23,48.89 arc(18.26,48.88) 18.29,48.87 arc(18.32,48.85) 18.35,48.85 18.66,48.85 arc(18.73,48.87) 18.75,48.94 arc(18.72,49.02) 18.64,49.05 UT2.A19
TBT_A_TTX_DRX_P2: length 1.9
  BOTTOM w0.076: CT39.1 17.48,50.36 arc(17.57,50.31) 17.66,50.29 17.96,50.29 arc(18.06,50.27) 18.14,50.21 arc(18.15,50.21) 18.17,50.2 18.67,50.2 arc(18.72,50.18) 18.75,50.13 18.75,50.06 arc(18.72,50) 18.66,49.97 UT2.A17
TBT_A_USB2_T_N: length 31.5
  IN1 w0.074: v4(8.08,54.5) 8.26,54.32 8.73,54.32 8.94,54.2 9.45,53.7 9.53,53.57 9.63,53.47 10.04,53.47 10.4,53.47 10.49,53.56 11.52,53.56 12.14,54.18 12.14,57.29 11.46,57.97 11.46,62.66 12.36,63.57 15.8,63.57 16.27,64.04 19.97,64.04 20.11,64.18 21.42,64.18 21.85,63.75 22.92,63.75 23.15,63.97 23.89,63.97 v4(24.05,64.13)
  IN3 w0.074: v4(24.05,64.13) 24.05,64.44 24.13,64.52 24.31,64.52 24.4,64.43 24.4,63.9 24.53,63.76 25.45,63.76 25.68,63.99 25.68,64.49 25.77,64.58 25.77,64.88 v5(25.73,64.92) ; v5(7.75,54.5) v4(8.08,54.5)
  BOTTOM w0.112: v5(7.75,54.5) 7.43,54.5 LT11.1
TBT_A_USB2_T_N_R: length 1.8
  IN1 w0.074: v2(6.05,54.62) v4(5.62,54.8)
  IN3 w0.074: v4(5.62,54.8) v5(5.95,54.66)
  BOTTOM w0.112: v5(5.95,54.66) 5.96,54.66 6.18,54.44 arc(6.23,54.41) 6.3,54.39 6.49,54.39 arc(6.63,54.42) 6.75,54.5 LT11.2
TBT_A_USB2_T_P: length 31.6
  IN1 w0.074: v4(24.05,63.61) 23.89,63.77 23.23,63.77 23.01,63.55 21.77,63.55 21.34,63.98 20.2,63.98 20.06,63.84 16.36,63.84 15.88,63.37 12.44,63.37 11.66,62.58 11.66,58.06 12.34,57.37 12.34,54.09 11.61,53.36 10.57,53.36 10.48,53.27 10.04,53.27 9.54,53.27 9.37,53.45 9.29,53.57 8.82,54.04 8.68,54.12 8.23,54.12 v4(8.08,53.97)
  IN3 w0.074: v5(7.75,54.12) v4(8.08,53.97) ; v5(25.73,65.42) 25.97,65.05 25.97,64.49 25.88,64.41 25.88,63.91 25.53,63.56 24.45,63.56 24.29,63.72 24.15,63.72 v4(24.05,63.61)
  BOTTOM w0.112: LT11.4 7.47,54.12 v5(7.75,54.12)
TBT_A_USB2_T_P_R: length 1.8
  IN1 w0.074: v2(6.05,54.11) v4(5.62,54.11)
  IN3 w0.074: v5(5.95,53.92) v4(5.62,54.11)
  BOTTOM w0.112: LT11.3 6.75,54.08 arc(6.63,54.16) 6.49,54.19 6.3,54.19 arc(6.22,54.17) 6.16,54.13 v5(5.95,53.92)
TBT_A_VBUS_L: length 8.2
  TOP w0.254: v2(23.42,69.77) 23.42,69.78 23.47,69.83 CT197.1
  IN1 w0.254: v4(23.72,69.64) 23.59,69.77 v2(23.42,69.77)
  IN2 w0.305: v4(23.72,69.64) 23.38,69.98 22.83,69.98 22.45,69.6 22.45,69.11 23.1,68.47 23.1,66.88 22.83,66.61 v4(22.83,65.97)
  IN3 w0.254: v4(22.83,65.97) 22.88,65.92 v5(23.22,65.92) ; v4(23.72,69.64) 23.71,69.64 23.71,69.64 23.71,69.64 23.71,69.64 23.72,69.65 v5(23.72,70.26)
  BOTTOM w0.127: v5(23.72,70.26) UT1.A10 UT1.B10
TBT_B_AUX_N: length 32.3
  IN1 w0.074: v2(27.46,72.84) 27.12,72.84 v4(27.09,72.88)
  IN3 w0.074: v5(31.72,71.09) 31.72,70.94 32.58,70.08 32.58,68.37 33.72,67.23 33.72,65.95 33.4,65.63 33.4,61.22 34.45,60.17 34.45,57.97 34.03,57.55 34.03,56.54 34.51,56.06 34.51,50.11 32.4,48 32.24,48 32.09,47.85 v5(32.09,47.77) ; v4(27.09,72.88) 27.2,72.88 v5(27.44,73.11)
  BOTTOM w0.076: UT5.J2 27.98,73.19 28.43,73.19 29.82,71.8 30.84,71.8 31.55,71.09 v5(31.72,71.09)
  BOTTOM w0.112: UT5.J2 27.69,72.93 v5(27.44,73.11)
TBT_B_AUX_N_C: length 6
  IN3 w0.074: v5(31.5,47.77) 31.38,47.89 30.26,47.89 28.98,49.16 28.98,49.6 28.73,49.85 27.93,49.85 27.73,50.06 27.34,50.06 27.07,50.32 v5(26.83,50.32)
TBT_B_AUX_P: length 31.5
  TOP w0.112: v2(28.68,73) 28.4,73 RT140.2
  IN1 w0.074: v2(28.68,73) 27.97,73 v4(27.89,72.92)
  IN3 w0.074: v4(27.89,72.92) 27.97,73 28.16,73 v5(28.23,72.93) ; v5(32.09,48.33) 32.21,48.2 32.32,48.2 34.31,50.2 34.31,55.98 33.83,56.46 33.83,57.64 34.25,58.05 34.25,60.08 33.2,61.13 33.2,65.72 33.52,66.04 33.52,67.15 32.38,68.29 32.38,70 31.57,70.8 v5(31.44,70.8)
  BOTTOM w0.076: v5(28.23,72.93) 28.45,72.93 29.75,71.63 30.77,71.63 31.44,70.97 v5(31.44,70.8)
TBT_B_AUX_P_C: length 5.3
  IN3 w0.074: v5(31.5,48.33) 31.22,48.05 30.32,48.05 29.15,49.23 29.15,49.67 28.8,50.02 28,50.02 27.79,50.22 27.58,50.22 v5(27.48,50.32)
TBT_B_CC1: length 25.9
  TOP w0.102: CT193.1 24.29,72.32 v1(23.84,71.86)
  IN1 w0.203: v4(6.56,69) 6.56,69.76 6.88,70.08 7.09,70.57 7.09,71.2
  IN1 w0.254: v2(6.05,68.84) v4(5.75,68.68)
  IN1 w0.305: v4(24.22,72.69) 24.3,72.77 v2(24.3,73.17) 24.04,73.17 23.71,73.5 23.19,73.5 22.8,73.89 21.95,73.89 21.67,73.61 21.01,73.61 20.7,73.92 20.7,74.23 20.29,74.64 17.65,74.64 15.59,72.58 12.96,72.58 12.1,73.44 9.09,73.44 8.59,72.93 8.59,72.51 8.78,72.33 8.78,71.94 8.4,71.57 7.45,71.57 7.09,71.2
  vias: v5(5.95,68.41) v5(6.29,68.81) v5(24.22,71.93)
TBT_B_CC2: length 20.2
  TOP w0.102: v2(23.72,72.76) 22.64,71.68 v1(22.05,71.68)
  TOP w0.305: CT192.1 23.72,72.76 v2(23.72,72.76) ; JUSBC2.A5 7.65,70.09 8.75,70.09 8.86,70.21 9.8,70.21 DT12.1
  IN1 w0.305: v4(23.71,72.37) 23.62,72.37 23.56,72.43 23.51,72.37 22.07,72.37 21.01,71.3 21.01,70.93 20.62,70.55 18.93,70.55 18.28,70.55 17.22,71.61 11.43,71.61 v2(10.83,71.01)
  IN3 w0.305: v5(23.72,71.93) 23.72,72.36 v4(23.71,72.37)
TBT_B_DBG_CTL1: length 1.5
  TOP w0.127: RT123.2 26.54,75.14 v2(26.54,75.14)
  IN1 w0.061: v4(26.82,75.41) v2(26.54,75.14)
  IN3 w0.061: v5(26.53,75.23) 26.54,75.22 26.62,75.22 v4(26.82,75.41)
  BOTTOM w0.127: v5(26.53,75.23) 26.53,75.15 26.73,74.96 UT5.E4
TBT_B_DBG_CTL2: length 1
  IN1 w0.061: v4(26.02,75.08) 26.23,75.28 26.23,75.54 v2(26.25,75.56)
  IN3 w0.061: v5(26.23,75.43) 26.23,75.43 26.23,75.28 v4(26.02,75.08)
TBT_B_DEBUG1: length 3.3
  IN1 w0.061: v2(30.03,71.38) 29.44,71.38 v4(29.3,71.24) 28.97,71.24 v2(28.83,71.38)
  IN3 w0.061: v5(28.83,71.35) 29.2,71.35 v4(29.3,71.24)
  BOTTOM w0.127: v5(28.83,71.35) 28.11,71.35 27.73,71.74 UT5.L2
TBT_B_DEBUG2: length 3.6
  TOP w0.127: v2(30.11,71.85) 30.1,71.87 RT128.2
  IN1 w0.061: v2(30.11,71.85) 29.89,71.85 29.67,71.63 29.24,71.63 v4(29.14,71.73) 29.13,71.72 28.99,71.72 v2(28.84,71.87)
  IN3 w0.061: v4(29.14,71.73) 29.12,71.71 v5(28.61,71.71)
  BOTTOM w0.076: v5(28.61,71.71) 28.5,71.6 28.14,71.6 27.98,71.76 27.98,72.12 27.73,72.37 UT5.K2
TBT_B_DEBUG3: length 1.8
  TOP w0.127: v2(28.24,71.54) 28.18,71.61 RT59.2
  IN1 w0.061: v4(27.71,71.48) 27.79,71.57 28.22,71.57 v2(28.24,71.54)
  IN3 w0.061: v4(27.71,71.48) 27.25,71.93 v5(27.23,71.93)
TBT_B_DEBUG4: length 1.4
  TOP w0.127: RT144.2 RT60.2
  IN1 w0.061: v4(27.54,72.32) 27.48,72.32 27.41,72.25 v2(27.12,72.25)
  IN3 w0.061: v5(27.23,72.43) 27.23,72.43 27.29,72.37 27.5,72.37 v4(27.54,72.32)
TBT_B_HPD: length 25.2
  TOP w0.127: v2(23.1,69.62) 22.45,69.62 21.63,70.44 21.63,72.62 21.96,72.95 21.96,73.74 21.61,74.09 21.61,75.76 v1(21.69,75.84) 21.75,75.9 22.54,75.9
  IN1 w0.061: v2(23.1,69.62) 23.07,69.62 22.91,69.46 v4(22.91,69.33)
  IN2 w0.061: v4(22.72,64.14) 23.23,64.65 23.23,65.54 24.5,66.81 24.5,66.85 24.49,66.85 24.49,68 23.67,68.83 23.22,68.83 22.91,69.13 v4(22.91,69.33)
  IN3 w0.061: v5(21.29,56.87) 21.29,57.24 23.41,59.36 23.41,59.9 23.84,60.33 v5(23.84,60.45) 23.88,60.49 23.88,61.81 23.71,61.97 23.25,61.97 22.9,62.32 22.9,62.99 22.86,63.03 22.86,63.99 22.72,64.14 v4(22.72,64.14)
  BOTTOM w0.127: RT39.1 23.58,60.4 23.79,60.4 v5(23.84,60.45)
TBT_B_I2C_B_N: length 16.1
  IN1 w0.074: v2(11.17,69.09) 11.33,69.24 11.55,69.24 12.48,70.17 15.28,70.17 15.82,70.71 16.84,70.71 17.78,69.77 21.14,69.77 22.79,71.42 23.96,71.42 24.63,72.09 24.73,72.09 v4(24.88,71.93)
  IN3 w0.074: v5(25.22,71.93) 24.88,71.93 v4(24.88,71.93)
TBT_B_I2C_B_N_R: length 3.3
  TOP w0.112: JUSBC2.A7 8.04,69.08 arc(8.08,69.09) 8.12,69.12 8.2,69.2 arc(8.24,69.23) 8.29,69.23 8.77,69.23 arc(8.95,69.2) 9.11,69.09 DT20.1 9.3,68.93 arc(9.39,69.15) 9.6,69.24 10.26,69.24 arc(10.4,69.21) 10.53,69.13 LT10.2
TBT_B_I2C_B_P: length 16.1
  IN1 w0.074: v2(11.17,69.58) 11.31,69.44 11.46,69.44 12.4,70.37 15.2,70.37 15.74,70.91 16.93,70.91 17.87,69.98 21.06,69.98 22.7,71.62 23.88,71.62 24.55,72.29 24.73,72.29 v4(24.89,72.44)
  IN3 w0.074: v4(24.89,72.44) 24.99,72.44 25,72.43 v5(25.22,72.43)
TBT_B_I2C_B_P_R: length 3.3
  TOP w0.112: JUSBC2.A6 8.04,69.58 arc(8.08,69.58) 8.12,69.55 8.2,69.47 arc(8.24,69.45) 8.28,69.44 8.41,69.44 8.41,69.44 8.82,69.44 arc(8.95,69.46) 9.06,69.54 DT16.1 9.3,69.75 arc(9.39,69.53) 9.6,69.44 10.26,69.44 arc(10.41,69.47) 10.54,69.56 LT10.3
TBT_B_I2C_INT#: length 31.1
  IN2 w0.061: v4(22.2,64.12) 22.2,66.39 22.85,67.04 22.85,68.36 22.2,69.01 22.2,69.7 23.13,70.63 23.13,71.58 22.83,71.88 22.83,73.22 23.05,73.44 23.8,73.44 25.78,75.42 26.21,75.42 26.62,75.82 27.41,75.82 28.12,75.12 28.12,74.3 v4(28.7,73.71)
  IN3 w0.061: v4(28.7,73.71) 28.88,73.71 29.25,74.08 v5(29.32,74.08) ; v5(20.37,56.87) 20.37,57.16 20.74,57.54 21.2,57.54 22.61,58.95 22.61,59.74 22.75,59.88 22.75,60.44 v5(22.87,60.56) 22.9,60.56 23.29,60.94 23.29,61.38 23.16,61.52 23.16,61.84 22.78,62.22 22.78,62.94 22.74,62.98 22.74,63.59 v4(22.2,64.12)
  BOTTOM w0.127: UT5.C1 28.34,76.05 28.65,76.05 29.32,75.38 v5(29.32,74.08)
TBT_B_LSRX: length 31
  TOP w0.127: RT144.1 RT142.1 26.01,71.11 25.66,70.76 25.66,70.28 25.46,70.08 v2(25.46,69.9)
  IN1 w0.061: v2(25.46,69.9) 25.44,69.88 25.28,69.88 24.91,69.51 24.91,69.07 24.76,68.92 24.76,68.43 24.54,68.21 24.54,67.49 24.61,67.42 24.61,67.1 25.8,65.9 25.8,63.94 25.51,63.65 25.51,62.9 24.83,62.22 23.81,62.22 23.17,61.59 22.52,61.59 22.26,61.86 22.26,62.14 21.66,62.73 21.39,62.73 21.09,63.03 18.8,63.03 18.53,62.76 16.44,62.76 16.23,62.54 16.02,62.54 15.94,62.46 15.94,58.43 16.2,58.17 v4(17.23,58.17)
  IN3 w0.061: v4(17.23,58.17) 17.07,58 17.07,56.85 v5(17.34,56.57)
  BOTTOM w0.076: v5(17.34,56.57) 17.48,56.57 18.36,55.7 18.78,55.7 UT2.B5
TBT_B_LSRX_R: length 0.8
  IN1 w0.061: v2(26.06,72.12) 26.11,72.12 v4(26.37,72.38)
  IN3 w0.061: v5(26.73,72.43) 26.67,72.38 v4(26.37,72.38)
TBT_B_LSTX: length 31.3
  TOP w0.127: RT141.1 24.83,70.58 v1(24.95,70.45) 24.99,70.41 v2(25.37,70.41) ; v2(28.69,72.43) 28.53,72.43 RT143.1
  IN1 w0.061: v4(22.57,61.99) 22.64,62.06 23.46,62.06 23.76,62.35 24.78,62.35 25.39,62.95 25.39,63.7 25.68,63.99 25.68,65.84 25.24,66.28 24.69,66.28 24.49,66.49 24.49,67.37 24.42,67.44 24.42,68.1 24.1,68.41 24.1,68.71 24.27,68.87 24.36,68.87 24.64,69.16 24.64,69.59 25.37,70.31 v2(25.37,70.41) 25.37,70.41 25.42,70.47 25.94,70.47 26.19,70.72 26.19,71.09 26.06,71.21 26.06,71.69 26.34,71.97 28.23,71.97 v2(28.69,72.43)
  IN3 w0.061: v5(22.46,62.32) 22.57,62.2 v4(22.57,61.99) ; v5(21,58.79) 20.73,58.52 20.13,58.52 19.61,58 17.71,58 17.4,57.69 v5(17.34,57.69)
  BOTTOM w0.076: UT2.B4 18.78,56.16 18.33,56.16 17.92,56.57 17.92,57.12 17.5,57.54
  BOTTOM w0.127: v5(17.34,57.69) 17.5,57.54 ; v5(22.46,62.32) 22.25,62.52 21.51,62.52 20.91,61.92 20.91,58.88 v5(21,58.79)
TBT_B_LSTX_R: length 2.3
  IN1 w0.061: v2(25.47,71.33) 25.47,71.19 v4(25.75,70.9)
  IN3 w0.061: v5(26.73,71.93) 26.21,71.93 25.75,71.48 v4(25.75,70.9)
TBT_B_RESET_N: length 15.6
  IN2 w0.061: v4(22.34,72.87) 22.41,72.79 22.41,71.71 22.71,71.41 22.71,70.8 21.78,69.88 21.78,68.84 22.41,68.21 22.41,67.31 21.41,66.31 21.41,64.04 21.94,63.51 22.53,63.51 23.26,62.78 v4(23.26,62.58)
  IN3 w0.061: v4(23.26,62.58) 23.26,62.46 v5(23.46,62.27) ; v4(22.34,72.87) 22.12,73.09 22.12,73.94 22.32,74.14 v5(22.32,74.43)
  BOTTOM w0.127: v5(22.32,74.43) 22.32,74.43 UT5.F11
TBT_B_SBU1: length 25.5
  IN1 w0.061: v2(6.05,70.33) v4(5.62,70.69)
  IN1 w0.076: v4(23.86,74.36) 23.83,74.39 23.35,74.39 23.19,74.55 22.98,74.55 21.63,75.9 17.92,75.9 16.01,73.99 8.93,73.99 7.88,72.94 7.22,72.94 6.75,72.47 6.75,70.53 v4(6.56,70.33)
  IN3 w0.061: v5(24.22,74.02) 23.95,74.29 23.93,74.29 v4(23.86,74.36) ; v5(5.95,70.62) v4(5.62,70.69) ; v4(6.56,70.33) v5(6.33,70.1)
  BOTTOM w0.127: v5(24.22,74.02) 24.22,74.02 24.22,73.5 24.72,73 UT5.K8 ; v5(5.95,70.62) v5(6.33,70.1)
TBT_B_SBU2: length 22.1
  TOP w0.102: DT24.1 9.68,68.58 JUSBC2.A8
  TOP w0.127: DT24.1 10.09,67.86 10.3,67.66 v2(10.83,67.66)
  IN1 w0.076: v2(10.83,67.66) 11.42,67.66 12.47,68.71 13.29,68.71 13.68,68.33 14.55,68.33 15.19,67.69 16.79,67.69 17.12,68.03 19.94,68.03 20.34,67.63 21.39,67.63 21.54,67.79 21.54,68.41 23.22,70.09 23.96,70.09 v4(24.19,69.86)
  IN3 w0.061: v5(24.14,70.29) 24.14,69.9 v4(24.19,69.86)
  BOTTOM w0.127: UT5.L8 24.72,71.51 24.14,70.93 v5(24.14,70.29)
TBT_B_TRX_DTX_N1: length 23.4
  TOP w0.112: v2(9.78,67.47) 9.75,67.44 arc(9.68,67.4) 9.6,67.38 arc(9.52,67.39) 9.46,67.44 DT28.1 9.26,67.55 arc(9.12,67.46) 8.96,67.42 8.29,67.42 arc(8.26,67.43) 8.24,67.44 8.13,67.55 arc(8.1,67.58) 8.05,67.58 JUSBC2.A10
  IN1 w0.074: v4(10.1,67.54) 10.09,67.53 v2(9.78,67.47)
  IN3 w0.074: v4(10.1,67.54) arc(10.31,67.55) 10.52,67.53 10.54,67.53 10.74,67.49 arc(11.24,67.32) 11.67,67.01 14.02,64.66 arc(14.53,63.9) 14.7,63.01 14.7,55.64 arc(14.89,54.72) 15.41,53.94 15.62,53.73 arc(15.7,53.66) 15.77,53.59 arc(15.84,53.54) 15.92,53.52 arc(16.27,53.49) 16.63,53.48 16.95,53.48 arc(17.39,53.38) 17.76,53.13 arc(17.98,52.95) 18.24,52.83 18.39,52.78 18.47,52.76 arc(18.81,52.53) 18.99,52.16 arc(19.01,51.99) v5(18.98,51.81)
TBT_B_TRX_DTX_N2: length 28.7
  IN1 w0.074: v2(6.05,71.33) v4(6.38,71.33)
  IN3 w0.074: v4(6.38,71.33) v5(6.05,71.39) ; v5(7.07,71.32) arc(7.12,71.46) 7.26,71.51 arc(7.28,71.51) 7.3,71.51 arc(7.34,71.51) 7.38,71.51 8.27,71.51 arc(8.78,71.61) 9.21,71.9 9.91,72.6 arc(10.03,72.67) 10.16,72.7 11.18,72.7 arc(11.57,72.62) 11.9,72.4 arc(12.28,71.83) 12.41,71.16 12.41,70.15 arc(12.6,69.21) 13.14,68.41 15.6,65.94 arc(15.79,65.66) 15.86,65.32 15.86,56.67 arc(15.94,56.28) 16.16,55.95 16.43,55.68 arc(16.99,55.31) 17.64,55.18 18.42,55.18 arc(18.65,55.1) 18.77,54.9 18.77,54.88 arc(18.71,54.66) v5(18.49,54.57)
  BOTTOM w0.112: v5(6.05,71.39) 6.06,71.41 arc(6.14,71.46) 6.22,71.48 6.35,71.48 arc(6.43,71.46) 6.5,71.42 DT9.2 6.73,71.36 6.87,71.36 arc(6.97,71.35) v5(7.07,71.32)
TBT_B_TRX_DTX_P1: length 23.4
  TOP w0.112: v2(9.78,67.09) 9.77,67.09 arc(9.71,67.14) 9.64,67.17 9.64,67.17 arc(9.61,67.17) 9.59,67.18 9.59,67.18 arc(9.58,67.18) 9.57,67.18 9.56,67.18 arc(9.56,67.18) 9.56,67.18 arc(9.55,67.18) 9.55,67.18 arc(9.54,67.18) 9.54,67.18 arc(9.51,67.16) 9.48,67.14 DT32.1 9.24,67.03 arc(9.09,67.14) 8.92,67.21 arc(8.85,67.22) 8.78,67.22 8.29,67.22 arc(8.2,67.2) 8.13,67.16 8.12,67.14 arc(8.05,67.1) 7.98,67.08 JUSBC2.A11
  IN1 w0.074: v2(9.78,67.09) v4(10.11,67.03)
  IN3 w0.074: v4(10.11,67.03) arc(10.24,67.17) 10.39,67.29 arc(10.47,67.32) 10.55,67.32 10.71,67.29 arc(11.15,67.14) 11.53,66.86 13.88,64.52 arc(14.34,63.83) 14.5,63.01 14.5,55.64 arc(14.7,54.65) 15.27,53.8 15.48,53.59 arc(15.56,53.51) 15.63,53.44 arc(15.76,53.36) 15.9,53.32 arc(16.26,53.28) 16.63,53.27 16.95,53.27 arc(17.31,53.2) 17.62,52.99 arc(17.87,52.78) 18.17,52.64 18.33,52.59 18.4,52.56 arc(18.65,52.4) 18.79,52.12 18.79,52.12 arc(18.73,51.89) v5(18.51,51.82)
TBT_B_TRX_DTX_P2: length 28.8
  IN1 w0.074: v2(6.05,71.84) v4(6.38,71.84)
  IN3 w0.074: v4(6.38,71.84) v5(6.05,71.78) ; v5(18.98,54.57) arc(18.98,54.7) 18.98,54.84 arc(18.97,54.89) 18.96,54.94 arc(18.77,55.25) 18.42,55.38 17.64,55.38 arc(17.06,55.49) 16.58,55.82 16.3,56.1 arc(16.12,56.36) 16.06,56.67 16.06,65.32 arc(15.98,65.73) 15.75,66.08 13.28,68.55 arc(12.79,69.29) 12.62,70.15 12.62,71.16 arc(12.47,71.91) 12.04,72.54 arc(11.65,72.81) 11.18,72.9 10.16,72.9 arc(9.95,72.86) 9.77,72.74 9.07,72.04 arc(8.7,71.79) 8.27,71.71 7.38,71.71 arc(7.22,71.73) v5(7.08,71.78)
  BOTTOM w0.112: v5(6.05,71.78) 6.08,71.74 arc(6.15,71.7) 6.22,71.68 6.35,71.68 arc(6.42,71.7) 6.49,71.74 DT42.2 6.76,71.78 v5(7.08,71.78)
TBT_B_TTX_C_DRX_N1: length 22.7
  IN1 w0.074: v2(6.05,67.84) v4(6.38,67.72)
  IN3 w0.074: v5(6.05,67.64) v4(6.38,67.72) ; v5(16.33,52.5) arc(16.15,52.42) 15.96,52.45 arc(15.5,52.69) 15.11,53.04 arc(14.31,54.4) 14.03,55.96 14.03,62.7 arc(13.98,62.94) 13.85,63.14 12.78,64.21 arc(12.66,64.29) 12.52,64.32 arc(12.3,64.33) 12.09,64.36 arc(11.44,64.59) 10.89,65 8.57,67.31 arc(8.3,67.49) 7.99,67.56 7.44,67.56 arc(7.32,67.58) v5(7.22,67.64)
  BOTTOM w0.112: v5(7.22,67.64) 7.22,67.64 arc(7.12,67.58) 7.01,67.55 6.93,67.55 arc(6.86,67.57) 6.8,67.61 6.78,67.62 DT29.2 6.5,67.62 arc(6.43,67.57) 6.34,67.56 6.24,67.56 arc(6.14,67.58) 6.06,67.63 v5(6.05,67.64) ; v5(16.33,52.5) 16.51,52.5 arc(16.65,52.53) CT46.2
TBT_B_TTX_C_DRX_N2: length 23.8
  TOP w0.112: JUSBC2.A3 8.08,71.08 arc(8.12,71.09) 8.15,71.11 8.23,71.19 arc(8.29,71.23) 8.36,71.25 9.04,71.25 arc(9.13,71.23) 9.21,71.18 DT8.1 9.45,71.22 arc(9.52,71.27) 9.6,71.29 arc(9.68,71.27) 9.75,71.22 v2(9.78,71.2)
  IN1 w0.074: v2(9.78,71.2) v4(10.11,71.14)
  IN3 w0.074: v4(10.11,71.14) 10.17,71.2 arc(10.27,71.26) 10.39,71.29 10.98,71.29 arc(11.22,71.24) 11.42,71.11 11.52,71.01 arc(11.6,70.89) 11.63,70.74 11.63,68.39 arc(11.7,68) 11.92,67.68 13.56,66.04 arc(13.82,65.87) 14.12,65.81 14.23,65.81 arc(14.5,65.75) 14.73,65.6 15.01,65.32 arc(15.12,65.15) 15.17,64.94 15.17,55.58 arc(15.26,55.11) 15.53,54.71 15.74,54.49 arc(15.86,54.41) 15.99,54.35 arc(16.16,54.31) v5(16.33,54.25)
  BOTTOM w0.112: v5(16.33,54.25) 16.51,54.25 arc(16.65,54.22) CT42.2
TBT_B_TTX_C_DRX_P1: length 22.7
  IN1 w0.074: v2(6.05,67.33) v4(6.38,67.21)
  IN3 w0.074: v5(6.05,67.26) v4(6.38,67.21) ; v5(16.33,52.15) arc(16.1,52.19) 15.88,52.26 arc(15.38,52.53) 14.96,52.91 arc(14.12,54.33) 13.83,55.96 13.83,62.7 arc(13.8,62.86) 13.71,63 12.64,64.07 arc(12.58,64.11) 12.52,64.12 arc(12.28,64.13) 12.05,64.16 arc(11.35,64.41) 10.75,64.85 9.59,66.01 8.43,67.17 arc(8.23,67.31) 7.99,67.35 7.44,67.35 arc(7.32,67.33) v5(7.22,67.26)
  BOTTOM w0.112: v5(6.05,67.26) 6.06,67.28 arc(6.14,67.33) 6.24,67.35 6.34,67.35 arc(6.43,67.34) 6.5,67.29 DT33.2 6.79,67.29 arc(6.86,67.33) 6.93,67.35 7.02,67.35 arc(7.13,67.33) v5(7.22,67.26) ; v5(16.33,52.15) 16.51,52.15 arc(16.65,52.12) CT44.2
TBT_B_TTX_C_DRX_P2: length 23.8
  TOP w0.112: v2(9.78,71.58) 9.73,71.53 arc(9.68,71.5) 9.63,71.49 arc(9.52,71.51) 9.43,71.57 DT4.1 9.14,71.54 arc(9.04,71.47) 8.93,71.45 8.31,71.45 arc(8.22,71.47) 8.14,71.52 arc(8.07,71.57) 7.99,71.58 JUSBC2.A2
  IN1 w0.074: v2(9.78,71.58) v4(10.11,71.64)
  IN3 w0.074: v4(10.11,71.64) 10.14,71.61 arc(10.28,71.52) 10.44,71.49 10.98,71.49 arc(11.29,71.43) 11.56,71.25 11.66,71.15 arc(11.78,70.96) 11.83,70.74 11.83,68.39 arc(11.89,68.08) 12.06,67.82 13.7,66.18 arc(13.89,66.05) 14.12,66.01 14.23,66.01 arc(14.58,65.94) 14.87,65.74 15.15,65.46 arc(15.31,65.22) 15.37,64.94 15.37,55.58 arc(15.44,55.18) 15.67,54.85 15.88,54.64 arc(15.95,54.58) 16.04,54.55 arc(16.19,54.55) v5(16.33,54.6)
  BOTTOM w0.112: v5(16.33,54.6) 16.51,54.6 arc(16.65,54.63) CT40.2
TBT_B_TTX_DRX_N1: length 2
  BOTTOM w0.076: CT46.1 17.5,52.45 arc(17.54,52.42) 17.59,52.41 17.61,52.41 arc(17.72,52.43) 17.81,52.49 17.89,52.55 18.18,52.76 18.31,52.88 arc(18.37,52.92) 18.43,52.94 18.65,52.94 arc(18.72,52.92) 18.78,52.88 18.81,52.86 18.89,52.77 arc(18.94,52.74) UT2.B11
TBT_B_TTX_DRX_N2: length 2.3
  BOTTOM w0.076: UT2.B9 18.9,53.57 arc(18.77,53.48) 18.61,53.45 18.45,53.45 arc(18.36,53.47) 18.28,53.52 18.04,53.76 arc(18.01,53.79) 17.99,53.81 arc(17.94,53.94) 17.92,54.08 17.93,54.11 17.9,54.2 arc(17.84,54.28) 17.74,54.31 arc(17.53,54.25) CT42.1
TBT_B_TTX_DRX_P1: length 2
  BOTTOM w0.076: CT44.1 17.5,52.2 arc(17.54,52.23) 17.59,52.24 17.61,52.24 arc(17.79,52.28) 17.93,52.37 17.98,52.41 18.17,52.54 18.25,52.54 arc(18.29,52.54) 18.32,52.52 arc(18.36,52.49) 18.4,52.48 18.62,52.48 arc(18.71,52.52) 18.75,52.61 18.75,52.62 arc(18.72,52.7) 18.63,52.73 UT2.A11
TBT_B_TTX_DRX_P2: length 2.3
  BOTTOM w0.076: UT2.A9 18.66,53.65 arc(18.73,53.68) 18.76,53.76 18.76,53.79 arc(18.73,53.86) 18.67,53.88 18.29,53.88 arc(18.17,53.93) 18.12,54.05 arc(18.12,54.09) 18.11,54.14 18.11,54.14 18.09,54.15 18.06,54.25 arc(17.93,54.42) 17.72,54.47 arc(17.49,54.52) CT40.1
TBT_B_USB2_T_N: length 21.9
  IN1 w0.074: v4(8.08,69.72) 8.26,69.54 8.68,69.54 9.01,69.35 9.45,68.92 9.53,68.79 9.53,68.79 arc(9.64,68.71) 9.77,68.69 10.04,68.69 10.4,68.69 10.47,68.76 11.6,68.76 12.2,69.37 15.77,69.37 16.39,68.74 18.18,68.74 18.93,69.5 21.26,69.5 22.5,70.74 23.9,70.74 24.39,71.23 24.83,71.23 v4(24.98,71.38)
  IN3 w0.074: v4(24.98,71.38) 25.07,71.47 v5(25.32,71.47) ; v5(7.75,69.72) v4(8.08,69.72)
  BOTTOM w0.076: v5(25.32,71.47) 25.34,71.45 25.34,71.44 25.47,71.3 25.65,71.3 25.81,71.46 25.81,71.58 25.71,71.68 25.61,71.68 25.48,71.81 25.48,72.08 25.55,72.15 25.67,72.15 25.73,72.1 UT5.L6
  BOTTOM w0.112: v5(7.75,69.72) 7.43,69.72 LT12.1
TBT_B_USB2_T_N_R: length 1.8
  IN1 w0.074: v2(6.05,69.84) v4(5.62,70.02)
  IN3 w0.074: v4(5.62,70.02) v5(5.95,69.88)
  BOTTOM w0.112: LT12.2 6.74,69.71 arc(6.63,69.64) 6.5,69.61 6.35,69.61 arc(6.22,69.64) 6.12,69.71 v5(5.95,69.88)
TBT_B_USB2_T_P: length 22
  IN1 w0.074: v4(24.95,70.86) 24.78,71.03 24.47,71.03 23.99,70.54 22.59,70.54 21.34,69.3 19.02,69.3 18.26,68.54 16.31,68.54 15.69,69.17 12.28,69.17 11.68,68.56 10.56,68.56 10.48,68.49 10.04,68.49 9.77,68.49 arc(9.56,68.53) 9.39,68.64 9.37,68.66 9.29,68.79 8.89,69.19 8.63,69.34 8.23,69.34 v4(8.08,69.19)
  IN3 w0.074: v4(24.95,70.86) 25.11,70.86 v5(25.33,71.07) ; v5(7.75,69.34) v4(8.08,69.19)
  BOTTOM w0.076: v5(25.33,71.07) 25.34,71.07 25.4,71.13 25.72,71.13 25.97,71.39 25.97,72.05 25.88,72.2 UT5.K6
  BOTTOM w0.112: v5(7.75,69.34) 7.47,69.34 LT12.4
TBT_B_USB2_T_P_R: length 1.8
  IN1 w0.074: v2(6.05,69.33) v4(5.62,69.33)
  IN3 w0.074: v5(5.95,69.14) v4(5.62,69.33)
  BOTTOM w0.112: v5(5.95,69.14) 6.12,69.32 arc(6.23,69.39) 6.35,69.41 6.5,69.41 arc(6.63,69.39) 6.74,69.31 LT12.3
TBT_B_VBUS_L: length 6.2
  IN1 w0.203: v2(23.72,77.32) 23.72,77.32 v4(23.72,76.92)
  IN3 w0.203: v5(23.72,77.32) v4(23.72,76.92)
  IN3 w0.254: v4(23.72,76.92) 23.44,76.92 22.47,75.95 22.47,74.98 22.91,74.54 22.91,73.85 23.22,73.54 v5(23.22,73.43)
  BOTTOM w0.203: v5(23.72,77.32) 23.72,76.94 UT5.A10 UT5.B10
  vias: v1(21.88,72.1)
TBT_BATLOW#: length 135.9
  TOP w0.127: v2(49.38,31.69) 49.8,32.1 50.12,32.1 51.68,33.66 94.47,33.66 97.34,36.53 99.45,36.53 100.03,37.11 102.5,37.11 102.63,36.98 105.29,36.98 105.49,37.18 105.49,37.54 105.91,37.95 106.36,37.95 106.53,37.79 107.81,37.79 v1(108.1,38.08) v2(108.6,38.58)
  IN1 w0.061: v2(106.4,41.18) 106.43,41.15 v4(106.43,40.43) 106.43,40.19 107.07,39.56 107.63,39.56 108.6,38.58 v2(108.6,38.58) ; v4(17.79,49.42) 17.74,49.46 17.74,50.22 17.89,50.37 v4(17.89,55.89) ; v4(15.58,42.22) 16.55,41.25 20.57,41.25 20.78,41.04 20.78,40.66 20.95,40.48 23.58,40.48 24.28,39.79 24.81,39.79 25.2,40.18 27.16,40.18 27.67,39.67 29.16,39.67 32.53,43.04 39.71,43.04 39.82,43.04 41.38,41.48 41.38,37.82 41.38,37.7 42.9,36.18 45.86,36.18 47.63,34.42 47.63,33.08 48.64,32.07 49,32.07 v2(49.38,31.69)
  IN2 w0.061: v4(17.79,49.42) 17.79,48.67 15.85,46.73 15.85,44.89 15.3,44.34 15.3,42.5 v4(15.58,42.22)
  IN3 w0.061: v4(17.89,55.89) 17.89,57.28 18.19,57.58 19.81,57.58 20.34,58.11 21.13,58.11 21.84,58.82 v5(21.84,58.91) ; v5(106.62,40.73) 106.44,40.56 106.44,40.44 v4(106.43,40.43)
  BOTTOM w0.076: 21.07,57.5 21.07,57.12 UT2.F2
  BOTTOM w0.102: v5(21.84,58.91) 21.82,58.89 21.82,58.25 21.07,57.5
  BOTTOM w0.127: v5(21.84,58.91) 21.81,58.95 21.81,59.33 RT30.1 ; UCPU1.CJ25 106.44,40.56 v5(106.62,40.73)
TBT_CIO_PLUG_EVENT#: length 153.4
  IN2 w0.061: v4(106.94,21.48) 106.11,21.48 105.87,21.24 103.29,21.24 101.28,19.23 97.53,19.23 95.36,17.06 54.24,17.06 53.76,17.06 53.36,17.46 51.96,17.46 51.33,16.83 49.7,16.83 47.2,19.32 42.07,19.32 41.76,19.63 41.76,20.3 40.91,21.15 38.66,21.15 38.32,21.48 35.7,21.48 35.22,21 34.12,21 30.19,24.93 30.19,28.67 30.49,28.97 30.49,32.71 34.61,36.83 34.61,37.04 34.91,37.35 34.91,40.97 34.59,41.29 34.59,42.3 37.8,45.5 37.8,48.85 37.89,48.94 37.89,49.43 38.2,49.74 38.2,50.82 37.82,51.2 37.82,53.11 39.45,54.74 39.45,57.55 v4(39.49,57.59)
  IN3 w0.061: v5(107.13,32.85) 107.3,32.67 107.3,31.72 108.51,30.51 108.51,27.67 107.79,26.94 107.79,26.6 107.05,25.86 107.05,21.59 v4(106.94,21.48) ; v5(39.75,57.03) 39.75,57.33 v4(39.49,57.59)
  BOTTOM w0.076: 27.05,57.54 27.05,57.11 UT2.W2
  BOTTOM w0.127: v5(39.75,57.03) 39.21,57.03 37.68,58.57 35.34,58.57 35.17,58.74 35.17,60.41 34.43,61.15 v1(32.2,61.15) 31.73,61.62 30.66,61.62 30.37,61.33 RT305.1 30,61.51 29.28,61.51 28.7,60.93 28.7,60.26 27.84,59.39 RT29.1 27.8,58.8 27,58 27,57.59 27.05,57.54 ; v5(107.13,32.85) UCPU1.CL36
TBT_DP0_N0: length 47.9
  TOP w0.112: CM7.1 v2(18.96,26.99)
  IN1 w0.074: v2(18.96,26.99) 19.15,26.81 19.53,26.81 19.69,26.96 19.69,27.22 18.05,28.85 18.05,30.36 17.4,31.01 17.4,33.02 17.94,33.57 17.94,34.44 16.9,35.48 15.98,35.48 15.29,36.18 15.29,36.56 14.3,37.54 14.3,38.87 13.11,40.06 13.11,43.68 14.27,44.84 14.27,47.46 16.18,49.36 16.18,56.35 18.37,58.54 18.54,58.54 19.6,59.59 21.13,59.59 21.7,59.02 23.55,59.02 24.54,58.03 24.73,58.03 24.93,57.83 24.93,57.4 25.06,57.28 25.13,57.28 v4(25.3,57.45)
  IN3 w0.074: v4(25.3,57.45) 25.21,57.35 v5(24.97,57.35)
TBT_DP0_P0: length 47.9
  TOP w0.112: CM6.1 18.95,26.42 CM52.2
  IN1 w0.074: v2(18.96,26.42) 19.15,26.61 19.62,26.61 19.89,26.88 19.89,27.3 18.25,28.94 18.25,30.45 17.6,31.1 17.6,32.94 18.15,33.49 18.15,34.52 16.98,35.68 16.06,35.68 15.49,36.26 15.49,36.64 14.5,37.63 14.5,38.95 13.31,40.14 13.31,43.6 14.48,44.76 14.48,47.37 16.38,49.28 16.38,56.26 18.46,58.34 18.62,58.34 19.68,59.39 21.05,59.39 21.62,58.82 23.46,58.82 24.45,57.83 24.64,57.83 24.73,57.74 24.73,57.32 24.97,57.08 25.14,57.08 v4(25.31,56.91)
  IN3 w0.074: v5(24.96,56.87) 25.22,56.87 25.26,56.91 v4(25.31,56.91)
TBT_DP1_CLK: length 59.4
  IN3 w0.061: 29.08,47.29 29.08,47.24 29.09,47.23 29.09,45.66 28.42,44.99 28.03,44.99 25.45,42.41 24.71,42.41 24.37,42.75 24.37,43.08 23.88,43.57 23.29,43.57 22.99,43.26 22.99,42.23 22.66,41.91 21.08,41.91 20.92,41.74 19.28,41.74 19,41.46 16.47,41.46 15.38,40.37 15.38,39.4 15.24,39.27 15.24,39.19 14.32,38.27 14.32,36.86 14.05,36.58 14.05,27.13 13.28,26.37 13.28,25.65 13.75,25.18 v5(13.86,25.18)
  IN3 w0.076: 29.08,47.29 29.08,47.81 28.61,48.28 28.08,48.28 27.89,48.47 27.89,48.69 26.59,50 26.59,54.37 26.7,54.48 27.03,54.48 27.23,54.68 27.23,56.84 v5(27.26,56.87)
  BOTTOM w0.076: v5(27.26,56.87) UT2.Y2 27.51,57.11 27.51,57.54
  BOTTOM w0.102: 27.51,57.54 27.52,57.55 27.52,57.82 28.25,58.55 28.85,58.55 29.48,59.18 29.48,60.23 RT11.1
  BOTTOM w0.127: QM1.4 17.67,22.1 18.27,22.7 18.27,23.61 17.65,24.24 14.79,24.24 14.18,24.84 14.18,24.99 13.99,25.18 v5(13.86,25.18)
TBT_DP1_DATA: length 56.4
  IN3 w0.061: v5(13.88,24.82) 13.12,25.58 13.12,26.44 13.88,27.2 13.88,36.65 14.16,36.93 14.16,38.34 14.24,38.41 14.24,38.52 14.09,38.67 14.09,38.77 14.16,38.84 14.26,38.84 14.43,38.67 14.53,38.67 14.6,38.74 14.6,38.85 14.4,39.05 14.4,39.15 14.47,39.22 14.57,39.22 14.77,39.02 14.87,39.02 14.94,39.09 14.94,39.19 14.74,39.39 14.74,39.49 14.82,39.56 14.92,39.56 15.08,39.4 15.15,39.4 15.21,39.47 15.21,40.44 16.4,41.63 18.94,41.63 19.21,41.9 20.85,41.9 21.02,42.07 22.59,42.07 22.82,42.3 22.82,43.33 23.23,43.73 23.95,43.73 24.54,43.15 24.54,42.82 24.78,42.58 25.38,42.58 27.96,45.15 28.36,45.15 28.93,45.73 28.93,47.17 28.92,47.18 28.92,47.29
  IN3 w0.076: 28.92,47.29 28.93,47.3 28.93,47.74 28.55,48.13 28.02,48.13 27.74,48.41 27.74,48.63 26.44,49.93 26.44,54.44 26.63,54.63 26.96,54.63 27.08,54.75 27.08,56.71 27.02,56.77 27.02,56.97 27.26,57.22 v5(27.26,57.78)
  BOTTOM w0.076: UT2.Y1 27.26,57.54
  BOTTOM w0.127: 27.26,57.54 v5(27.26,57.78) 27.26,57.91 28.5,59.14 RT13.1 ; v5(13.88,24.82) 14.72,23.98 16.28,23.98 16.67,23.59 QM1.1
TBT_DP1_N1: length 42.3
  TOP w0.112: CM15.1 v2(18.97,29.53)
  IN1 w0.074: v2(18.97,29.53) 18.97,29.36 19.04,29.29 19.25,29.29 19.39,29.44 19.39,29.79 17.93,31.25 17.93,32.83 18.48,33.37 18.48,34.58 17.1,35.96 16.19,35.96 15.8,36.35 15.8,36.73 14.82,37.7 14.82,39.04 13.61,40.26 13.61,43.5 14.82,44.72 14.82,47.31 16.66,49.15 16.66,56.15 18.42,57.91 20.75,57.91 21.38,58.54 23.26,58.54 24.04,57.76 24.04,57.51 24.14,57.42 24.3,57.42 v4(24.35,57.47)
  IN3 w0.074: v4(24.35,57.47) 24.21,57.33 v5(24.04,57.33)
TBT_DP1_P1: length 42.3
  TOP w0.112: v2(18.97,28.96) CM14.1
  IN1 w0.074: v4(24.38,56.89) 24.38,56.89 23.84,57.42 23.84,57.67 23.18,58.34 21.46,58.34 20.84,57.71 18.51,57.71 16.86,56.07 16.86,49.06 15.02,47.22 15.02,44.63 13.81,43.42 13.81,40.35 15.03,39.13 15.03,37.78 16,36.81 16,36.44 16.27,36.16 17.18,36.16 18.68,34.66 18.68,33.29 18.13,32.74 18.13,31.34 19.6,29.88 19.6,29.36 19.33,29.09 19.1,29.09 v2(18.97,28.96)
  IN3 w0.074: v4(24.38,56.89) 24.36,56.87 v5(24.04,56.87)
TBT_DP2_N2: length 35.5
  TOP w0.112: CM17.1 18.93,36.68 CM50.1 18.99,36.7 19.13,36.84 19.13,36.87 19.24,36.98 19.43,36.98 19.51,36.9 19.51,36.56 19.58,36.49 19.8,36.49 19.84,36.53 v7(19.84,36.81) 19.84,37.11 19.73,37.22 19,37.22 18.83,37.05 18.68,37.05 v2(18.61,37.12)
  IN1 w0.074: v2(18.61,37.12) 18.54,37.19 18.08,37.19 17.84,36.95 16.26,36.95 15.31,37.9 15.31,39.25 14.1,40.47 14.1,43.31 15.31,44.52 15.31,47.1 17.16,48.95 17.16,55.97 18.61,57.43 20.97,57.43 21.6,58.06 22.98,58.06 23.29,57.74 23.29,57.67 v4(23.46,57.5)
  IN3 w0.074: v5(23.12,57.33) 23.3,57.33 v4(23.46,57.5)
TBT_DP2_P2: length 35.6
  TOP w0.112: CM16.1 CM50.2 19.13,36.11 19.63,36.28 19.88,36.28 20.08,36.48 20.08,37.15 19.81,37.42 18.69,37.42 v2(18.6,37.51)
  IN1 w0.074: v4(23.47,56.91) 23.37,56.81 23.19,56.81 23.09,56.91 23.09,57.66 22.9,57.85 21.68,57.85 21.05,57.22 18.7,57.22 17.36,55.89 17.36,48.87 15.51,47.02 15.51,44.44 14.3,43.23 14.3,40.55 15.51,39.34 15.51,37.99 16.35,37.15 17.75,37.15 17.99,37.39 18.48,37.39 v2(18.6,37.51)
  IN3 w0.074: v4(23.47,56.91) 23.43,56.87 v5(23.12,56.87)
TBT_DP3_N3: length 35.6
  TOP w0.112: v2(18.95,32.56) CM20.1
  IN1 w0.074: v4(22.68,57.48) 22.5,57.3 21.59,57.3 21.22,56.93 19.8,56.93 18.91,56.05 18.91,55.43 18.46,54.98 18.46,49.56 15.8,46.91 15.8,44.34 14.6,43.15 14.6,40.73 15.81,39.52 15.81,38.56 16.33,38.04 16.76,38.04 17.1,37.7 17.68,37.7 17.91,37.93 19.06,37.93 19.9,37.09 19.9,35.24 19.62,34.96 19.62,32.51 19.47,32.36 19.14,32.36 v2(18.95,32.56)
  IN3 w0.074: v4(22.68,57.48) 22.53,57.33 v5(22.2,57.33)
TBT_DP3_P3: length 35.6
  TOP w0.112: CM18.1 18.93,31.98 v2(18.95,31.97)
  IN1 w0.074: v2(18.95,31.97) 19.14,32.16 19.55,32.16 19.82,32.43 19.82,34.88 20.1,35.15 20.1,37.17 19.14,38.13 17.83,38.13 17.59,37.9 17.19,37.9 16.84,38.24 16.41,38.24 16.01,38.64 16.01,39.61 14.81,40.82 14.81,43.06 16,44.26 16,46.82 18.66,49.48 18.66,54.89 19.11,55.35 19.11,55.96 19.88,56.73 21.3,56.73 21.67,57.1 22.52,57.1 v4(22.67,56.95)
  IN3 w0.074: v4(22.67,56.95) 22.59,56.86 22.21,56.86 v5(22.2,56.87)
TBT_DP_HPD: length 48.8
  IN1 w0.061: v4(18.27,56.23) 18.24,56.2 18.24,55.77 18.03,55.57 18.03,49.98 v4(18.06,49.95)
  IN2 w0.061: v4(13.87,25.99) 16.48,28.61 16.48,30.96 17.46,31.93 17.46,34.91 15.7,36.67 15.7,40.03 15.17,40.56 15.17,44.45 15.67,44.95 15.67,46.78 17.39,48.5 17.39,49.75 17.59,49.95 v4(18.06,49.95)
  IN3 w0.061: v5(13.74,25.55) 13.74,25.87 v4(13.87,25.99) ; v5(22.31,59.97) 22.31,59.03 21.24,57.97 20.4,57.97 19.64,57.21 19.64,56.75 19.07,56.18 18.32,56.18 v4(18.27,56.23)
  BOTTOM w0.127: v1(19.28,23.5) RM96.2 18.71,24.87 QM2.3 14.89,24.49 14.43,24.95 14.43,25.1 13.98,25.55 v5(13.74,25.55)
TBT_FORCE_PWR: length 123.4
  TOP w0.127: v2(103.16,37.64) 103.09,37.56 99.77,37.56 99.19,36.99 97.15,36.99 94.47,34.3 v1(91.97,34.3) 58.15,34.3 58.02,34.17 51.55,34.17 49.99,32.61 49.23,32.61 48.66,32.04 v2(48.66,31.68)
  IN1 w0.061: v4(16.86,46.21) 17.42,46.21 19.09,47.88 19.09,53.29 19.27,53.47 20.26,53.47 20.43,53.64 20.43,55.25 20.62,55.44 20.91,55.44 v4(21.33,55.86) 21.59,56.13 v2(21.59,56.18) ; v2(103.16,37.64) 103.29,37.76 v4(103.52,37.76) ; v4(15.51,41.21) 15.78,40.94 18.42,40.94 19.28,40.07 20.71,40.07 20.86,40.22 23.46,40.22 24.16,39.53 24.92,39.53 25.31,39.92 27.06,39.92 27.56,39.42 29.27,39.42 32.63,42.78 39.71,42.78 41.12,41.37 41.12,37.6 42.79,35.92 45.75,35.92 47.34,34.33 47.34,33 v2(48.66,31.68)
  IN2 w0.061: v4(15.51,41.21) 15.78,41.21 16.05,41.48 16.05,42.37 15.71,42.71 15.71,44.29 16.15,44.73 16.15,45.5 v4(16.86,46.21)
  IN3 w0.061: v5(104.81,39.74) 104.81,39.43 103.52,38.13 v4(103.52,37.76)
  IN3 w0.076: v5(21.63,56.17) v4(21.33,55.86)
  BOTTOM w0.127: v5(104.81,39.74) 105.14,40.07 UCPU1.CG25
TBT_I2C_CLK: length 26.8
  IN1 w0.061: v4(25.83,60.81) 25.83,60.97 27.3,62.44 27.3,64.48 27.65,64.83 28.5,64.83 28.67,64.99 29.06,64.99 29.94,65.87 29.94,66.44 29.7,66.67 29.7,67.82 29.27,68.25 v4(29.27,68.52)
  IN3 w0.061: 29.27,68.57 v4(29.27,68.52) ; 29.27,68.57 29.42,68.57 29.78,68.92 29.78,71.84 30.15,72.22 30.15,72.78 30.91,73.54 30.91,74.43 30.11,75.23 28.74,75.23 28.65,75.14 28.02,75.14 v5(27.73,75.43) ; 29.27,68.57 29.17,68.57 28.9,68.84 28.42,68.84 28.24,68.66 27.96,68.66 v5(27.72,68.42) ; v4(25.83,60.81) 25.83,60.67 v5(25.99,60.52)
  BOTTOM w0.076: UT2.U2 25.88,56.97 26.11,57.19 26.11,57.54
  BOTTOM w0.102: v5(25.99,60.52) 26.11,60.39 26.11,57.54
TBT_I2C_DATA: length 26.7
  IN1 w0.061: v4(28.72,68.5) 29.06,68.16 29.09,68.16 29.52,67.74 29.52,66.59 29.75,66.36 29.75,65.95 28.98,65.18 28.59,65.18 28.42,65.02 27.57,65.02 27.12,64.56 27.12,62.52 25.78,61.18 25.66,61.18 v4(25.28,60.8)
  IN3 w0.061: v5(28.23,75.43) 28.24,75.42 30.19,75.42 31.1,74.51 31.1,73.46 30.34,72.7 30.34,72.14 29.96,71.77 29.96,68.58 29.44,68.06 29.26,68.06 28.81,68.5 v4(28.72,68.5) 28.63,68.42 v5(28.22,68.42) ; v4(25.28,60.8) 25.44,60.64 25.44,60.54 v5(25.47,60.51)
  BOTTOM w0.076: UT2.U1 25.88,57.54
  BOTTOM w0.102: v5(25.47,60.51) 25.47,60.46 25.67,60.26 25.67,58.7 25.88,58.49 25.88,57.54
  BOTTOM w0.127: v5(25.47,60.51) 25.43,60.51 25.38,60.56 RT25.1
TBT_JTAG_TCK: length 5.8
  IN3 w0.061: v5(24.49,60.5) 24.49,60.3 24.33,60.14 24.33,59.72
  IN3 w0.076: v5(25.54,56.17) 25.54,56.45 25.79,56.71 25.79,57.92 25.59,58.12 24.5,58.12 24.3,58.31 24.3,59.13 24.33,59.16 24.33,59.72
  BOTTOM w0.127: v5(24.49,60.5) 24.49,60.51 RT4.2
TBT_JTAG_TDI: length 3.5
  IN3 w0.076: v5(29.02,56.72) 28.94,56.63 28.14,56.63 v5(27.82,56.31)
  BOTTOM w0.076: v5(29.02,56.72) 29.02,57.45 29.11,57.54 29.13,57.54
  BOTTOM w0.127: UT2.Y4 v5(27.82,56.31) ; 29.13,57.54 29.54,57.95 RT6.2
TBT_JTAG_TDO: length 6.6
  IN3 w0.061: v5(26.83,56.17) 26.87,56.2 ; 26.31,59.71 26.31,61.29 26.59,61.57 v5(26.62,61.57)
  IN3 w0.076: 26.87,56.2 26.87,57.05 27.11,57.29 27.11,57.51 26.87,57.75 26.87,58.3 26.45,58.72 26.45,59.37 26.31,59.51 26.31,59.71
  BOTTOM w0.127: RT3.2 26.77,61.73 v5(26.62,61.57)
TBT_JTAG_TMS: length 3.8
  IN3 w0.076: v5(25.54,58.38) 25.55,58.38 25.94,57.98 25.94,56.64 25.83,56.53 25.83,56.42 v5(25.84,56.41)
  BOTTOM w0.076: UT2.V4 26.08,56.17 v5(25.84,56.41)
  BOTTOM w0.127: v5(25.54,58.38) 25.54,58.4 25.1,58.84 RT5.2
TBT_PCIE_RBIAS: length 0.7
  IN1 w0.229: v4(24,50.09) v5(24.23,50.32)
  IN3 w0.076: v5(24.23,50.32) v4(24,50.09)
TBT_PERST#: length 23.2
  TOP w0.127: v2(33.68,57.54) 34.16,57.05 RT183.1 ; v2(31.97,53.87) 32.36,53.48 RT287.2 ; v5(22.93,56.17) 23,56.17 v1(23.84,57.01) 24.43,57.6 30.35,57.6 30.52,57.77 31.68,57.77 32.19,58.29 RT190.1 v2(32.79,57.71)
  IN1 w0.061: v2(31.97,53.87) 31.97,53.87 31.8,53.87 v4(31.63,54.04) ; v2(33.68,57.54) 33.49,57.73 32.8,57.73 v2(32.79,57.71) 32.78,57.7 32.78,57.63 32.32,57.17 31.51,57.17 v4(31.32,57.36)
  IN1 w0.076: v4(22.7,56.41) v5(22.93,56.17)
  IN2 w0.061: v4(31.32,57.36) 31.42,57.26 31.42,56.67 30.49,55.74 30.49,54.09 30.72,53.85 31.44,53.85 v4(31.63,54.04)
  IN3 w0.076: v5(22.93,56.17) v4(22.7,56.41)
TBT_PERST#_R: length 2.1
  TOP w0.127: UT14.4 32.98,51.98 RT288.1 32.99,51.95 32.42,51.38 RT287.1
TBT_RBIAS: length 0.7
  IN1 w0.061: v4(21.4,55.11) 21.4,55.33 v2(21.3,55.43)
  IN3 w0.076: v5(21.63,54.87) v4(21.4,55.11)
TBT_RESET_N_EC: length 360.1
  TOP w0.127: v2(260.47,58.82) 262.62,58.82 UE1.D1 ; v6(250.34,59.43) v1(251.62,60.71)
  IN1 w0.061: v4(260.88,58.85) 260.85,58.82 v2(260.47,58.82)
  IN2 w0.061: v4(24.38,62.71) 25.08,62.01 27.13,62.01 27.37,62.25 29.06,62.25 29.4,61.91 29.4,59.99 27.61,58.19 27.61,47.27 27.16,46.83 18.06,46.83 16.46,45.23 16.46,44.65 16.99,44.11 16.99,42.03 17.78,41.24 17.98,41.24 19.22,40.01 19.22,38 18.78,37.57 18.78,32.48 17.28,30.98 17.28,24.67 17.53,24.42 17.53,24.41 17.88,24.06 17.88,20.21 20.26,17.84 20.26,16.55 25.32,11.49 26.75,11.49 27.14,11.49 27.41,11.76 27.99,11.76 30.13,9.61 38.2,9.61 38.21,9.62 119.67,9.62 121.55,11.5 121.55,13.43 124.56,16.44 126.69,16.44 128.55,15.68 130,14.23 130,11.41 130.64,10.76 151.31,10.76 151.56,10.51 184.89,10.51 185.33,10.95 185.47,10.95 186.33,11.81 201.89,11.81 203.85,13.77 206.13,13.77 v4(206.32,13.58)
  IN3 w0.061: v4(24.38,62.71) 24.55,62.54 v5(24.55,62.31) ; v4(206.32,13.58) 206.32,13.62 206.49,13.79 209.54,13.79 210.4,14.65 219.9,14.65 222.12,16.87 v5(223.9,16.87) ; v6(250.34,59.43) 260.3,59.43 v4(260.88,58.85)
  BOTTOM w0.127: v5(223.9,16.87) 223.9,19.46 232.98,28.54 232.98,35.24 227.47,40.75 227.47,43.17 236.6,52.3 243.39,52.3 250.34,59.25 v6(250.34,59.43)
TBT_RESET_N_R: length 8.3
  IN3 w0.061: v5(23.47,61.67) 23.58,61.55 23.58,60.61 23.22,60.24 23.22,59.9 23.27,59.86 23.27,59.41 21.03,57.17 21.03,56.6 21.02,56.58 21.02,56.58 v5(21.02,56.58)
  BOTTOM w0.076: v5(21.02,56.58) 20.98,56.54 UT2.F4
  BOTTOM w0.102: RT14.1 RT69.1 RT17.1 RT15.1
TBT_ROM_CLK: length 34.8
  TOP w0.127: v2(36.62,47.01) 36.99,46.64 v1(36.99,45.75) 36.99,41.81 35.05,39.87 31.21,39.87 29.37,41.71 29.37,43.26 30,43.88 31.33,43.88 31.47,43.74 UT3.6
  IN1 w0.061: v4(36.57,47.35) 36.62,47.3 v2(36.62,47.01)
  IN3 w0.061: v5(36.55,52.15) 36.55,47.38 v4(36.57,47.35) ; v5(29.22,55.38) 29.45,55.15 31.3,55.15 31.76,54.69 32.56,54.69 32.79,54.46 32.79,53.41 v5(33.07,53.14)
  BOTTOM w0.076: v5(29.22,55.38) 29.21,55.38 29.21,55.36 29.19,55.36 28.83,55.72 28.42,55.72 UT2.AB4
  BOTTOM w0.127: v5(33.07,53.14) 33.24,52.97 33.7,52.97 34.08,52.58 35.59,52.58 36.02,52.15 v5(36.55,52.15)
TBT_ROM_CS#: length 13.9
  TOP w0.127: UT3.1 34.01,49.58 34.43,50 RT45.2 34.99,51.12 v1(34.99,51.77) 34.99,53.41 v2(34.7,53.69)
  IN1 w0.061: v2(34.7,53.69) 34.7,53.74 34.92,53.95 v4(34.97,53.95)
  IN3 w0.061: v5(33.3,53.78) 33.3,53.87 33.04,54.14 33.04,54.56 32.65,54.95 31.89,54.95 31.36,55.48 29.95,55.48 v5(29.67,55.75) ; v4(34.97,53.95) v5(34.97,53.56)
  BOTTOM w0.076: v5(29.67,55.75) 29.65,55.75 29.67,55.77 29.67,55.93 29.18,56.41 UT2.AC3
  BOTTOM w0.127: v5(33.3,53.78) 33.54,53.55 34.95,53.55 v5(34.97,53.56)
TBT_ROM_DI: length 32.1
  TOP w0.127: UT3.5 29.82,43.17 29.63,42.98 29.63,41.81 31.32,40.13 34.95,40.13 36.67,41.85 v1(36.67,43.99) v2(36.67,46.17)
  IN1 w0.061: v4(36.57,46.55) 36.67,46.46 v2(36.67,46.17)
  IN3 w0.061: v4(36.57,46.55) 36.93,46.91 36.93,47.55 36.67,47.81 36.67,51.74 36.78,51.85 36.78,52.29 v5(36.55,52.51) ; v5(29.31,55.73) 29.69,55.34 31.29,55.34 31.81,54.82 32.61,54.82 32.91,54.51 32.91,53.64 v5(33.06,53.5)
  BOTTOM w0.076: UT2.AB3 28.39,56.21 29.17,56.21 29.31,56.07 v5(29.31,55.73)
  BOTTOM w0.127: v5(36.55,52.51) 36.01,52.51 35.69,52.84 34.18,52.84 33.74,53.28 33.38,53.28 33.17,53.5 v5(33.06,53.5)
TBT_ROM_DO: length 10.4
  TOP w0.127: UT3.2 32.74,50.4 v2(32.57,50.56)
  IN1 w0.061: v2(32.57,50.56) 32.57,50.67 v4(32.35,50.89)
  IN3 w0.061: v4(32.35,50.89) 32.35,51.69 32.9,52.24 32.9,52.85 32.46,53.28 31.68,53.28 31.16,53.8
  IN3 w0.076: 31.16,53.8 31.13,53.83 30.01,53.83 28.93,54.91 28.93,55.84 v5(29.01,55.93)
  BOTTOM w0.076: v5(29.01,55.93) 29.01,55.94 28.97,55.94 28.96,55.95 UT2.AC4
TBT_ROM_HOLD#: length 2.8
  TOP w0.127: v1(31.34,41.55) RT44.2 32.32,42.14 32.74,42.56 UT3.7
TBT_ROM_WP#: length 15.8
  TOP w0.127: UT3.3 31.47,49.63 31.89,50.05 RT47.2 31.89,50.99 31.95,51.05 v2(31.95,51.06)
  IN1 w0.061: v4(31.99,51.44) 31.97,51.42 31.97,51.09 v2(31.95,51.06)
  IN3 w0.061: v4(31.99,51.44) 31.99,51.98 31.79,52.19 31.5,52.19
  IN3 w0.076: 31.5,52.19 31.35,52.19 31.16,52.37 29.9,52.37 28.82,53.45 28.02,53.45 27.53,53.94 27.42,53.94 27.24,54.11 27.24,54.41 27.39,54.55 27.39,56.31 27.51,56.43 27.51,58.31 26.92,58.9 v5(26.75,58.9)
  BOTTOM w0.102: UT2.V1 26.34,58.38 26.75,58.79 v5(26.75,58.9)
TBT_RSENSE: length 0.7
  IN1 w0.254: v4(22.04,55.1) 22.17,55.23 v2(22.17,55.41)
  IN3 w0.076: v5(22.28,54.87) 22.26,54.87 v4(22.04,55.1)
TBT_RTD3_WAKE#: length 126.3
  TOP w0.127: v1(97.92,26.11) 97.37,26.66 97.37,27.41 97.56,27.6 v2(97.74,27.6) RC465.1 ; v2(99.74,32.41) 97.11,32.41 97.01,32.31 52.68,32.31 52.04,31.67 v6(52.04,31.48) ; RT294.1 30.83,56.77 v2(30.75,56.69)
  IN1 w0.061: v2(97.74,27.6) 98.07,27.6 98.72,28.25 98.72,29.07 99.11,29.47 99.11,29.89 98.95,30.05 98.95,30.76 99.75,31.56 v4(99.75,31.92) 99.75,32.4 v2(99.74,32.41) ; v2(30.75,56.69) 30.86,56.69 v4(31.06,56.89)
  IN2 w0.061: v4(28.42,38.96) 28.42,39.74 30.8,42.12 30.8,46.12 31.42,46.73 31.42,47.73 31.24,47.91 30.59,47.91 30.36,48.14 30.36,56.19 v4(31.06,56.89)
  IN3 w0.061: v5(26.55,61.14) 26.48,61.07 26.48,59.71 ; v4(28.42,38.96) 28.6,38.96 34.59,44.96 34.59,45.43 35.17,46.01 38.71,46.01 39.14,45.58 39.14,44.99 40.49,43.65 40.49,42.57 42.81,40.25 43.81,40.25 44.37,39.69 44.37,38.46 43.27,37.36 43.27,36.87 43.54,36.6 46.2,36.6 48.31,34.49 48.31,34.14 50.03,32.43 51.88,32.43 52.04,32.26 v6(52.04,31.48) ; v5(99.72,34.06) 99.94,33.84 99.94,32.11 v4(99.75,31.92)
  IN3 w0.076: v4(31.06,56.89) 30.81,56.64 29.72,56.64 29.05,57.3 29.05,57.5 28.76,57.8 28.23,57.8 26.48,59.56 26.48,59.71
  BOTTOM w0.127: UCPU1.BV35 99.96,33.82 v5(99.72,34.06)
TBT_SNK0_DDC_CLK: length 7.2
  IN3 w0.076: v5(31.08,56.31) 31.06,56.33 29.59,56.33 29.45,56.48 28.34,56.48 27.79,55.92 v5(27.79,55.84)
  BOTTOM w0.127: v1(31.79,59.04) 31.5,58.75 RT91.2 RT80.1 31.37,57.52 31.08,57.23 v5(31.08,56.31) ; UT2.Y5 v5(27.79,55.84)
TBT_SNK0_DDC_DATA: length 4.6
  IN3 w0.076: v5(24.88,56.17) 25.04,56.17 25.64,56.77 25.64,57.68 v5(25.46,57.86)
  BOTTOM w0.127: v5(25.46,57.86) 24.55,58.77 RT92.2 RT81.1
TBT_SRC_CFG1: length 3.8
  BOTTOM w0.102: UT2.AA1 27.72,57.6 28.45,58.33 28.95,58.33 29.78,59.15
  BOTTOM w0.127: RT295.1 30.43,59.36 RT97.1 29.83,59.2 29.78,59.15
TBT_SRC_HPD: length 3.1
  BOTTOM w0.066: UT2.G1 21.3,57.33
  BOTTOM w0.102: 21.3,57.33 22.31,58.34 RT8.1 RT98.1
TBT_SVR_IND:
  vias: v2(20.32,58.41) v2(20.61,58.42) v4(20.33,58.83) v5(20.31,59.44) v5(20.32,59.18)
TBT_TEST_EN: length 6.1
  IN3 w0.061: v5(20.59,57.73) 20.61,57.73 20.68,57.8 21.27,57.8 22.45,58.98 22.45,59.78 22.6,59.93 22.6,60.62 22.78,60.81 22.9,60.81 23.15,61.05 23.15,61.35 22.92,61.58 v5(22.92,61.73)
  BOTTOM w0.127: v5(22.92,61.73) 22.91,61.71 22.88,61.71 RT18.1 ; UT2.E1 20.36,57.5 v5(20.59,57.73)
TBT_TEST_PWRG: length 2.6
  BOTTOM w0.076: UT2.AB5 28.4,55.27 28.77,55.27 29.07,54.97 29.4,54.97 29.67,55.24 30.22,55.24 RT21.1
TBT_TMU_CLK_OUT: length 3.4
  BOTTOM w0.076: 26.56,57.54 26.56,57.51 26.56,57.5 26.56,57.09 UT2.V2
  BOTTOM w0.102: RT32.1 CT141.1
  BOTTOM w0.127: 26.56,57.54 26.56,58.25 27.11,58.8 CT141.1
THERMTRIP1#: length 3.4
  TOP w0.127: RE122.1 271.75,62.09 271.04,61.38 271.04,60.81 271.44,60.41 271.44,60.41
THERMTRIP2#: length 210
  TOP w0.127: v6(246.58,60.22) 246.23,59.86 246.23,54.86 246.84,54.25 RE197.2 250.48,55.95 v2(249.95,56.48) ; QE5.1 108.64,66.77 CE41.1 109.23,66.36 110.92,64.68 v1(110.92,64.26) v2(110.92,63.5)
  IN1 w0.061: v2(249.95,56.48) 254.16,56.48 254.73,55.91 257.06,55.91 257.94,55.03 259.55,55.03 260.16,55.65 261.69,55.65 262.01,55.33 263.96,55.33 v2(264.24,55.61) ; v2(110.92,63.5) 110.92,63.24 110.96,63.19 v4(110.96,62.39)
  IN2 w0.061: v6(246.58,60.22) 235.93,60.22 228.05,52.34 223.52,52.34 213.47,42.29 207.44,42.29 203.8,38.65 197.07,38.65 197.05,38.63 197.04,38.63 193.7,35.29 189.93,35.29 188.94,34.3 188.94,34.01 175.87,20.95 155.96,20.95 155.71,21.2 149.86,21.2 145.6,25.46 143.2,25.46 133.39,35.27 130.6,35.27 127.52,38.35 127.52,39.79 126.54,40.76 124.97,40.76 122.15,43.59 121.16,43.59 119.92,44.82 119.92,47.73 119.22,48.43 118.58,48.43 117.81,49.2 117.81,50.03 117.42,50.41 117.42,55.46 110.96,61.91 v4(110.96,62.39)
TOUCH_SCREEN_PD#: length 8.2
  BOTTOM w0.076: UCPU1.CN3 108.62,54.37 108.62,54.91 108.27,55.26 108.27,55.57 108.46,55.76
  BOTTOM w0.127: DC5.1 110.63,59.47 110.9,59.2 RC516.1 RC517.1 111.53,58.83 108.46,55.76
TOUCH_SCREEN_PD#_R: length 195.3
  TOP w0.127: v6(131.99,64.53) 131.99,65.79 132.21,66.01 132.21,76.31 131.78,76.74 120.94,76.74 120.66,77.03 103.14,77.03 102.68,76.57 99.02,76.57 97.69,75.25 96.98,73.53 96.46,72.89 94.78,71.21 90.89,71.21 88.34,73.76 88.34,75.08 88.2,75.22 v2(88.2,76.41) ; v3(126.96,26.96) 126.95,26.96 126.66,27.25 v2(126.66,28)
  IN1 w0.061: v2(39.18,77.64) 39.09,77.64 v4(38.78,77.34) ; v2(126.66,28) 126.66,27.7 126.61,27.66 v4(126.61,27.61) ; v4(62.14,73.69) 63.05,73.69 63.54,74.17 63.54,76.02 63.76,76.24 69.28,76.24 70.54,74.97 71.9,74.97 72.53,75.6 72.53,76.16 72.94,76.56 87.83,76.56 87.98,76.41 v2(88.2,76.41)
  IN2 w0.061: v4(113.37,60.97) 115.91,60.97 118.43,63.48 121.13,63.48 121.7,62.9 125.39,62.9 127.02,64.53 v6(131.99,64.53) ; v4(126.61,27.61) 126.88,27.88 126.88,33.83 126.53,34.18 126.53,36.46 121.34,41.65 119.44,41.65 114.28,46.81 113.47,46.81 112.33,47.95 v4(111.4,47.95)
  IN3 w0.061: v5(112.36,61.17) 113.17,61.17 v4(113.37,60.97) ; v4(38.78,77.34) 38.87,77.25 v5(39.22,77.25) 39.22,77.08 38.86,76.71 38.86,73.23 v5(39.27,72.81) ; v4(62.14,73.69) 62.14,73.64 v5(61.92,73.42) ; v5(109.95,51.71) 110.46,51.2 111.4,48.57 v4(111.4,47.95)
  BOTTOM w0.127: RC517.2 112.11,59.2 112.33,59.42 DC5.2 112.33,60.65 112.36,60.67 v5(112.36,61.17) 113.22,61.17 113.97,60.42 113.97,58.31 113.52,57.85 112.91,57.85 110.63,55.57 110.63,54.09 109.84,53.31 109.33,53.31 109.15,53.13 109.15,52.69 109.38,52.46 109.38,52.17 109.83,51.71 v5(109.95,51.71) ; v5(39.27,72.81) 39.48,73.03 52.33,73.03 53.13,72.23 61.12,72.23 61.92,73.03 v5(61.92,73.42) ; v5(39.22,77.25) JEDP1.19
TOUCHPAD_INTR#: length 152
  IN2 w0.061: v4(214.15,29.3) 213.71,28.87 198.18,28.87 197.82,29.23 189.54,29.23 177.47,17.15 154.32,17.15 154.05,17.42 148.29,17.42 144.03,21.68 141.5,21.68 139.82,23.36 129.71,23.36 129.26,22.91 126.05,22.91 125.62,22.48 118.42,22.48 116.21,24.69 115.74,24.69 110.85,29.58 107.28,29.58 105.43,31.44 v4(103.08,31.44)
  IN3 w0.061: v5(197.06,19.73) 197.38,20.04 200.14,20.04 200.51,19.67 207.7,19.67 208.58,20.55 208.58,23.68 208.84,23.93 209.13,23.93 214.15,28.95 v4(214.15,29.3) ; v5(102.67,29.39) 102.67,30.77 103.01,31.11 103.01,31.36 v4(103.08,31.44) 102.93,31.59 102.78,31.59 v5(102.75,31.62)
  BOTTOM w0.127: v5(102.75,31.62) 102.79,31.66 102.79,34.06 UCPU1.CB34
TOUCHPAD_INTR#_R: length 11.3
  IN1 w0.061: v4(197.37,18.89) v2(197.37,18.42)
  IN3 w0.061: v5(197.07,18.7) 197.18,18.7 v4(197.37,18.89)
  BOTTOM w0.127: JTP1.6 193.62,17.01 193.86,16.77 194.75,16.77 196.69,18.7 v5(197.07,18.7) 197.38,18.7 197.8,18.28 199.02,18.28 199.27,18.54 199.27,20.03 198.78,20.53 RP15.2 198.61,20.07 198.67,20.02 Q3.1
TP_DISABLE#: length 10.3
  TOP w0.127: v2(194.63,21.74) v3(194.63,23.41)
  IN1 w0.061: v4(195.08,21.74) v2(194.63,21.74)
  IN3 w0.061: v4(195.08,21.74) 195.16,21.66 v5(195.73,21.66)
  BOTTOM w0.127: JTP1.7 194.13,18.57 194.27,18.71 194.72,18.71 194.92,18.92 DP1.1 194.92,19.82 RP13.2 194.42,19.89 194.16,20.16 RP8.2 194.37,20.52 194.58,20.72 Q13.1 195.45,20.72 195.73,21 v5(195.73,21.66) RP16.1
