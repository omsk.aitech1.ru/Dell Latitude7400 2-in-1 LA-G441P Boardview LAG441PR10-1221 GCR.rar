# Allegro board LAG441PR10-1221_GCR.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_WAKE#_AR: length 15.2
  TOP w0.127: v2(26.48,55.34) 26.75,55.62 28.9,55.62 29.23,55.29 29.23,53.41 28.72,52.89 28.72,52.08 29.42,51.38 RT292.2
  IN1 w0.061: v4(26.48,55.77) v2(26.48,55.34)
  IN3 w0.076: v4(26.48,55.77) 26.55,55.85 26.55,57.08 v5(26.8,57.33)
  BOTTOM w0.076: 26.8,57.54 v5(26.8,57.33)
  BOTTOM w0.102: RT186.1 RT185.1 RT188.1 ; RT186.1 27.44,60.2 27.44,58.79 26.8,58.15 26.8,57.54 ; RT186.1 RT187.1
PCIE_WAKE#_AR_R: length 2.9
  TOP w0.127: v1(29.07,52.74) 29.63,52.18 RT292.1 RT293.1 30.25,52.01 UT15.4
PCIE_WAKE#_R: length 28.6
  TOP w0.102: 273.66,50.18 v2(273.21,50.63)
  TOP w0.127: RE188.1 257.83,52.65 v2(257.34,52.15) ; 273.66,50.18 274.04,49.8 RE124.1 ; v2(273.21,50.63) UE1.N13
  IN1 w0.061: v2(273.21,50.63) 272.26,49.69 272.26,48.87 271.77,48.37 271.77,46.51 270.65,45.4 v4(268.01,45.4) ; v2(257.34,52.15) v4(257.34,52.61)
  IN3 w0.061: v4(257.34,52.61) 257.52,52.79 258.32,52.79 260.55,50.55 264.97,50.55 266.14,49.38 266.14,46.5 267.24,45.4 v4(268.01,45.4)
PD1_GPIO0: length 1.8
  IN1 w0.061: v2(28.6,70.1) 28.78,69.92 v4(28.9,69.92)
  IN3 w0.061: v4(28.9,69.92) 28.89,69.94 28.33,69.94 27.8,69.42 v5(27.73,69.42)
PD1_GPIO1: length 1.3
  TOP w0.127: v2(27.6,69.1) 27.76,68.94 RT103.1
  IN1 w0.061: v2(27.6,69.1) 27.6,69.1 27.69,69.01 v4(28.06,69.01)
  IN3 w0.061: v5(27.73,68.92) 27.82,69.01 v4(28.06,69.01)
PD1_GPIO2: length 2.5
  TOP w0.127: RT152.1 24.04,69.96 23.88,69.8 v2(23.88,69.23)
  IN1 w0.061: v4(24.19,69.35) 24,69.35 23.89,69.24 23.88,69.24 v2(23.88,69.23)
  IN3 w0.061: v5(24.1,68.92) 24.19,69.01 v4(24.19,69.35)
  BOTTOM w0.127: v5(24.1,68.92) 24.1,68.79 UT1.D10
PD1_GPIO4: length 0.9
  IN1 w0.061: v2(23.27,68.9) 23.39,69.02 23.39,69.21 v4(23.41,69.23)
  IN3 w0.061: v4(23.41,69.23) 23.39,69.23 23.39,69.23 23.43,69.23 23.72,68.94 v5(23.72,68.92)
PD1_GPIO5: length 1.2
  IN1 w0.061: v2(23.3,67.81) 24.02,67.81 v4(24.08,67.87)
  IN3 w0.061: v5(23.72,67.92) 24.03,67.92 v4(24.08,67.87)
PD1_GPIO6: length 1
  IN1 w0.061: v2(23.31,67.16) v4(23.59,67.44)
  IN3 w0.061: v4(23.59,67.44) 23.59,67.05 v5(23.72,66.92)
PD1_GPIO7: length 1.8
  TOP w0.127: RT105.1 25.29,69.55 25.4,69.44 v2(25.41,69.44)
  IN1 w0.061: v2(25.41,69.44) 25.41,69.11 25.4,69.09 25.4,69.07 25.41,69.07 25.41,69.08 v4(25.42,69.08)
  IN3 w0.061: v5(25.23,68.43) 25.23,68.72 25.42,68.91 v4(25.42,69.08)
  BOTTOM w0.127: UT1.D7 v5(25.23,68.43)
PD1_GPIO8: length 1.4
  TOP w0.127: v2(25.77,66.82) 25.74,66.79 25.69,66.79 25.44,66.54 RT107.1
  IN1 w0.061: v2(25.77,66.82) 25.93,66.65 25.93,66.52 v4(26.04,66.52)
  IN3 w0.061: v4(26.04,66.52) 25.93,66.52 25.93,66.48 25.86,66.41 v5(25.73,66.41)
  BOTTOM w0.127: v5(25.73,66.41) UT1.H6
PD1_GPIO8_EXT: length 1.2
  TOP w0.127: RT155.2 RT159.1 RT107.2
PD1_HOLD#: length 1.4
  TOP w0.127: UT4.7 31.94,60.98 32.14,60.78 RT102.2
PD1_LPS1: length 35.6
  TOP w0.127: PR1508.2 28.6,53.36 28.21,52.96 v1(28.21,49.66) 28.21,48.92 29.25,47.87 29.25,43.6 v2(29.13,43.48) ; v2(18.11,46.5) 18,46.39 17.17,46.39 16.69,46.87 16.69,49.62 16.1,50.21 PR149.2 14.7,49.57 PQ119.6 13.5,48.66 13.1,49.06 12.29,49.06 12.13,49.22 PR165.2
  IN1 w0.061: v2(18.11,46.5) 18.11,45.93 19.46,44.58 19.46,44.2 21.21,42.45 25.63,42.45 26.19,43.01 27.74,43.01 28.24,43.5 29.11,43.5 v2(29.13,43.48)
PD1_LPS2: length 15.5
  TOP w0.254: v2(12.77,46.52) 13.11,46.86 14.54,46.86 v1(15.33,46.07) 22.33,46.07 23.19,46.93 23.76,46.93 24.02,47.2 25.76,47.2 26.25,46.71 PR183.1
  IN1 w0.254: v4(12.82,46.17) 12.82,46.47 v2(12.77,46.52)
  IN3 w0.254: v4(12.82,46.17) 12.87,46.22 13.13,46.22 v5(13.15,46.2)
PD1_ROM_CLK: length 20.4
  TOP w0.127: UT4.6 30.94,59.71 30.65,59.42 30.65,58.13 v2(30.69,58.09)
  IN1 w0.061: v2(30.69,58.09) 30.7,58.1 30.71,58.1 v4(30.93,58.32) ; v4(31.05,69.82) 30.68,69.46 29.97,69.46 29.75,69.68 29.75,70.06 29.5,70.31 28.99,70.31 28.54,70.76 27.45,70.76 v2(27.36,70.67)
  IN3 w0.061: 31.01,59.71 31.35,60.05 31.35,61.82 29.53,63.64 29.53,65.03 30.13,65.63 30.13,66.51 30.59,66.97 30.59,67.62 30.87,67.9 30.87,69.65 v4(31.05,69.82)
  IN3 w0.076: 31.01,59.71 31.01,59.15 30.8,58.93 30.8,58.46 v4(30.93,58.32)
PD1_ROM_CLK_R: length 1.2
  IN1 w0.061: v2(27.3,70.19) 27.3,70.25 27.37,70.33 v4(27.6,70.33)
  IN3 w0.061: v4(27.6,70.33) 27.6,70.33 27.19,70.27 v5(27.17,70.25)
  BOTTOM w0.127: UT1.A3 27.17,69.97 v5(27.17,70.25)
PD1_ROM_CS#: length 12.3
  TOP w0.127: RT99.2 24.4,62.71 24.85,62.25 UT4.1
  IN1 w0.061: v2(26.79,70.72) 26.37,70.72 25.99,70.34 25.83,70.34 25.66,70.18 25.4,70.18 24.79,69.56 24.79,69.12 24.64,68.98 24.64,68.77 v4(24.42,68.55) ; v2(25.51,62.19) 25.51,62.26 25.83,62.58 v4(25.83,62.61)
  IN2 w0.061: v4(25.83,62.61) 25.83,65.7 24.66,66.86 24.66,68.31 v4(24.42,68.55)
PD1_ROM_CS#_R: length 0.8
  IN1 w0.061: v4(27.23,69.77) 27.2,69.77 v2(26.88,70.08)
  IN3 w0.061: v4(27.23,69.77) 27.23,69.76 v5(27.23,69.42)
PD1_ROM_DI: length 18.1
  TOP w0.127: v1(32.68,59.2) 32.53,59.05 v2(31.65,59.05) 31.39,58.79 UT4.5 ; v2(27.2,69.03) 27.11,68.94 RT169.1
  IN1 w0.061: v4(31.27,58.71) 31.32,58.71 v2(31.65,59.05) ; v4(29.41,69.83) 29.17,69.6 28.73,69.6 28.54,69.79 27.82,69.79 27.2,69.17 v2(27.2,69.03)
  IN2 w0.061: v4(29.41,69.83) 30.24,69 30.24,68 30.55,67.69 30.55,66.24 29.88,65.58 29.88,64.59 v4(29.93,64.54)
  IN3 w0.061: v4(29.93,64.54) 29.93,63.53 31.47,61.99 31.47,58.94 31.27,58.75 v4(31.27,58.71)
PD1_ROM_DI_R: length 0.8
  IN1 w0.061: v2(26.78,69.46) 26.72,69.4 v4(26.72,69.08)
  IN3 w0.061: v5(26.72,69.42) 26.72,69.08 v4(26.72,69.08)
PD1_ROM_DO: length 13.4
  TOP w0.127: RT100.2 24.15,60.86 25.37,60.86 UT4.2 25.49,61.25 v2(24.79,61.96) ; RT170.1 26.1,70.73 25.91,70.55 25.91,70.03 v2(25.82,69.94)
  IN1 w0.061: v2(24.79,61.96) 24.79,62.01 25.63,62.85 25.63,63.6 25.93,63.89 25.93,65.95 24.73,67.15 24.73,67.47 24.66,67.54 24.66,68.16 24.88,68.38 24.88,68.87 25.03,69.02 25.03,69.46 25.24,69.67 25.56,69.67 25.69,69.81 25.69,69.81 v2(25.82,69.94)
PD1_ROM_DO_R: length 0.9
  IN1 w0.061: v2(26.23,70.21) 26.37,70.35 v4(26.57,70.35)
  IN3 w0.061: v5(26.73,69.92) 26.57,70.08 v4(26.57,70.35)
PD1_ROM_WP#: length 1.4
  TOP w0.127: RT101.2 24.18,59.71 UT4.3
PD2_GPIO0: length 1.5
  IN1 w0.061: v2(28.55,77.32) 28.36,77.32 28.12,77.08 v4(27.82,77.08)
  IN3 w0.061: v4(27.82,77.08) 27.82,76.6 27.73,76.5 v5(27.73,76.43)
PD2_GPIO1: length 0.9
  IN1 w0.061: v2(27.93,76.19) 28.05,76.19 28.17,76.08 28.17,76.05 v4(28.21,76.02)
  IN3 w0.061: v4(28.21,76.02) 27.81,76.02 v5(27.73,75.93)
PD2_GPIO2: length 2.3
  IN1 w0.061: v4(24.07,75.43) 24.07,77.1 v2(24.29,77.32)
  IN3 w0.061: v5(23.72,75.43) v4(24.07,75.43)
PD2_GPIO4: length 1.1
  TOP w0.127: RT121.1 23.52,75.9 v2(23.53,75.92)
  IN1 w0.061: v4(23.61,76.25) 23.53,76.17 v2(23.53,75.92)
  IN3 w0.061: v5(23.72,75.93) 23.72,76.14 v4(23.61,76.25)
PD2_GPIO5: length 0.9
  TOP w0.127: RT274.1 23.08,74.81 v2(23.07,74.81)
  IN1 w0.061: 23.1,74.77 v2(23.07,74.81)
  IN1 w0.076: 23.1,74.77 23.15,74.72 v4(23.47,74.72)
  IN3 w0.061: v5(23.72,74.93) 23.68,74.93 v4(23.47,74.72)
PD2_GPIO6: length 2.3
  TOP w0.127: v2(23.01,74.3) 23.13,74.19 RT275.1 23.13,73.37 v1(22.81,73.06)
  IN1 w0.076: v4(23.33,74.06) 23.26,74.06 v2(23.01,74.3)
  IN3 w0.061: v4(23.33,74.06) 23.45,73.94 23.72,73.94 v5(23.72,73.93)
PD2_GPIO7: length 2.1
  TOP w0.127: v2(24.84,76.73) 24.88,76.76 RT122.1
  IN1 w0.061: v4(25.27,75.82) 25.32,75.88 25.32,76.45 25.04,76.73 v2(24.84,76.73)
  IN3 w0.061: v4(25.27,75.82) 25.22,75.78 v5(25.22,75.43)
PD2_GPIO8: length 1
  TOP w0.127: v2(25.39,73.78) 25.39,73.76 RT124.1
  IN1 w0.061: v4(25.7,73.94) 25.4,73.82 v2(25.39,73.78)
  IN3 w0.061: v5(25.73,73.43) 25.72,73.44 25.72,73.92 v4(25.7,73.94)
PD2_GPIO8_EXT: length 1.2
  TOP w0.254: RT124.2 RT147.1 RT165.2
PD2_LPS1: length 12.2
  TOP w0.127: v2(22.05,67.02) 21.02,66 PR1510.2 ; PR125.2 15.3,67.27 v2(16.04,67.27) 16.04,66.52 PR110.2
  IN1 w0.061: v2(22.05,67.02) 21.55,66.53 18.53,66.53 18.05,67.01 18.05,67.57 17.86,67.76 17.23,67.76 16.74,67.27 v2(16.04,67.27)
PD2_LPS2: length 44.6
  TOP w0.127: v2(21.2,40.9) 21.2,40.44 v1(20.48,39.72)
  IN1 w0.254: v2(21.2,40.9) 21.2,41.12 20.7,41.62 17.37,41.62 17.02,41.97 17.02,43.12 v4(16.62,43.52)
  IN3 w0.254: v5(10.65,58.56) 9.42,58.56 8.28,59.71 5.21,59.71 4.11,58.61 4.11,49.7 5,48.81 8.33,48.81 9.13,48.01 9.13,46.46 8.85,46.18 8.85,43.62 9.44,43.03 9.62,43.03 11.86,40.79 12.93,40.79 15.67,43.52 v4(16.62,43.52)
PD2_ROM_CLK: length 1.3
  IN1 w0.061: v2(27.47,77.44) 27.41,77.44 27.23,77.26 v4(27.23,77.2)
  IN3 w0.061: v5(27.47,77.44) 27.41,77.44 27.23,77.26 v4(27.23,77.2)
  BOTTOM w0.127: UT5.A3 27.23,76.94 27.47,77.41 v5(27.47,77.44)
PD2_ROM_CS#: length 1.3
  IN1 w0.061: v2(26.83,77.39) 26.92,77.3 26.92,77.07 27.27,76.72 27.39,76.72 v4(27.4,76.72)
  IN3 w0.061: v5(27.23,76.43) 27.4,76.6 v4(27.4,76.72)
PD2_ROM_DI: length 0.8
  IN1 w0.061: v2(26.93,76.62) 26.91,76.64 26.88,76.64 v4(26.68,76.85)
  IN3 w0.061: v5(26.73,76.43) 26.73,76.68 26.66,76.74 26.66,76.83 v4(26.68,76.85)
PD2_ROM_DO: length 1.7
  TOP w0.127: RT180.2 26.17,77.23 v2(25.9,77.23)
  IN1 w0.061: v4(26.3,77.39) 26.3,77.38 26.15,77.23 v2(25.9,77.23)
  IN3 w0.061: v5(26.64,77.35) 26.62,77.37 26.32,77.37 v4(26.3,77.39)
  BOTTOM w0.127: v5(26.64,77.35) 26.75,77.21 UT5.A4
PECI_EC: length 4.9
  BOTTOM w0.127: v1(86.1,59.49) 86.74,58.86 RE151.2 86.74,57.41 85.59,56.26 UCPU1.AR1
PECI_EC_R: length 241.4
  TOP w0.127: UE1.K13 272.92,54.01 273.72,53.21 v2(273.72,52.85)
  IN1 w0.061: v4(185.09,32.09) 185.15,32.03 185.34,32.03 186.05,31.32 193.33,31.32 194.64,32.63 195.09,32.63 206.74,44.28 211.69,44.28 212.38,44.97 223.68,44.97 225.29,46.58 255.62,46.58 256.07,46.13 260.5,46.13 261.65,44.98 270.68,44.98 272.08,46.38 272.08,48.28 272.55,48.75 272.55,49.38 273.61,50.44 273.61,52.74 v2(273.72,52.85)
  IN3 w0.061: v5(111.85,66.31) 108.37,66.31 107.81,66.88 102.55,66.88 100.53,64.85 92.01,64.85 89.1,61.94 89.1,60.39 89.58,59.91 89.58,58.51 88.92,57.85 87.37,57.85 v5(87.32,57.8) ; v4(185.09,32.09) 184.93,32 184.91,31.96 182.01,29.06 181.2,28.3 180.81,27.96 179.8,27.14 177.75,25.77 177.36,25.53 176.54,25.06 176.25,24.92 175.36,24.4 174.96,24.21 174.8,24.14 174.38,23.92 174.26,23.87 173.72,23.62 172.66,23.2 172.52,23.15 172.1,22.97 170.97,22.58 169,22.03 168.73,21.98 168.73,21.98 168.61,21.95 168.16,21.85 167.34,21.7 167.33,21.7 166.54,21.54 165.8,21.46 165.15,21.35 163.69,21.27 160.17,21.27 159.78,21.28 159.3,21.32 158.63,21.38 157.95,21.47 157.53,21.53 157.05,21.61 155.52,21.92 154.34,22.21 153.83,22.34 152.68,22.71 151.79,23.01 151.44,23.14 150.03,23.72 149.69,23.88 148.27,24.59 147.41,25.06 147.02,25.28 146.31,25.71 145.75,26.08 144.57,26.89 144.3,27.08 143.89,27.4 143.23,27.94 arc(142.74,28.36) 142.26,28.8 141.68,29.36 140.24,30.84 139.67,31.49 133.74,38.72 130.27,42.19 130.27,44.39 131.47,45.59 131.47,46.36 130.24,47.58 129.32,47.58 127.86,49.04 127.86,51.92 126.51,53.27 124.34,53.27 124.1,53.04 124.1,52.38 123.94,52.22 121.63,52.22 120.46,53.38 120.46,56.57 120.04,56.99 120.04,58.66 117.6,61.1 117.6,62.47 v5(113.74,66.33)
  BOTTOM w0.127: v5(113.74,66.33) 111.87,66.33 v5(111.85,66.31) ; v5(87.32,57.8) v1(87.32,58.69)
PG_PRIM_CORE: length 4.2
  BOTTOM w0.254: PU1401.13 127.35,49.39 127.74,49.77 128.41,49.77 128.7,50.06 PR1425.1 129.34,50.29 130.01,50.96 RE167.2
PG_VCCIO: length 186.1
  TOP w0.127: RE508.2 254.39,57.42 253.71,58.11 249.96,58.11 v1(247.95,56.1) v6(247.5,55.64)
  IN2 w0.061: v4(106.11,16.64) 106.89,17.43 109.89,17.43 113.2,20.74 122.25,20.74 122.83,21.32 126.93,21.32 127.89,20.37 128.15,20.26 131.34,20.26 131.63,20.55 139.83,20.55 140.46,19.93 143.34,19.93 147.57,15.7 153.34,15.7 153.6,15.43 178.18,15.43 188.52,25.77 196.11,25.77 197.39,27.06 205.82,27.06 208.54,24.33 215.24,24.33 218.25,27.34 219.62,27.34 221.66,29.38 224.08,29.38 237.78,43.08 247.63,43.08 v4(247.98,42.73)
  IN3 w0.061: v6(247.5,55.64) 247.5,43.88 247.98,43.4 v4(247.98,42.73) ; v4(106.11,16.64) 106.98,16.64 v5(107,16.63)
  BOTTOM w0.127: PR1402.1 106.98,16.64 106.53,17.1 106.53,17.52 106.02,18.02 PU1400.13
PM_SYS_RESET#: length 1.1
  TOP w0.127: RC89.1 RC87.1 RC248.2
POWER_SW_IN#: length 143.9
  TOP w0.127: RE187.2 v2(266.04,64.69) 266.13,64.69 266.55,65.11 RE190.2 ; v6(193.79,34.24) 193.05,34.24 v1(192.92,34.11) ; v2(266.16,63.04) 266.16,61.4 266.27,61.3 266.27,59.24 UE1.D5 265.52,59.17 v2(265.52,59.21)
  IN1 w0.061: v4(265.47,58.81) 265.47,59.16 v2(265.52,59.21) ; v2(266.16,63.04) 266.04,63.17 v2(266.04,64.69)
  IN2 w0.061: v6(193.79,34.24) 193.79,34.6 196.76,37.57 205.04,37.57 206.42,38.96 206.42,40.15 207.8,41.53 213.79,41.53 215.4,43.15 219.11,43.15 225.84,49.88 244.74,49.88 251.15,56.29 259.8,56.29 262.01,58.5 263.18,58.5 263.66,58.02 264.68,58.02 v4(265.47,58.81)
  BOTTOM w0.127: v6(193.79,34.24) 193.79,32.33 189.87,28.41 186.27,28.41 175.41,17.56 154.7,17.56 153.23,19.03 151.63,19.03 QZ21.3
PRIM_PWRGD: length 194.2
  TOP w0.102: 266.78,49.71 267.05,49.99 267.05,52.49 267.44,52.87 UE1.L7
  TOP w0.127: v2(265.76,47.03) v1(266.25,47.52) 266.78,48.05 266.78,49.71
  IN1 w0.061: v4(221.81,49.57) 222.11,49.27 239.85,49.27 240.79,48.33 249.18,48.33 250.07,47.44 255.96,47.44 256.42,46.98 261.01,46.98 261.4,46.59 264.16,46.59 264.6,47.03 v2(265.76,47.03)
  IN2 w0.061: v6(115.3,54.41) 114.69,53.8 114.69,52 114.76,51.93 114.76,49.74 116.2,48.3 119.17,48.3 119.8,47.67 119.8,44.77 121.1,43.46 122.09,43.46 124.92,40.64 126.49,40.64 127.39,39.74 127.39,38.3 130.55,35.14 133.34,35.14 143.15,25.34 145.55,25.34 149.81,21.07 155.66,21.07 155.91,20.82 175.92,20.82 189.06,33.96 189.06,34.25 189.98,35.16 193.75,35.16 197.1,38.51 205.19,38.51 205.87,39.19 205.87,40.31 207.59,42.04 213.58,42.04 221.1,49.57 v4(221.81,49.57)
  BOTTOM w0.127: RE182.1 115.02,54.13 v6(115.3,54.41) LED_PRI.1
PRIM_PWRGD_R: length 66.8
  TOP w0.127: v6(120.76,49.83) v1(121.87,49.83) 124.22,49.83 126.5,52.11 127.61,52.11 127.98,51.74 127.98,50.46 128.61,49.83 v2(130.63,49.83)
  IN1 w0.061: v4(130.44,51.72) 130.25,51.53 130.25,50.69 130.63,50.31 v2(130.63,49.83)
  IN3 w0.061: v5(108.16,31.57) 108.16,31.24 111.62,27.79 112.74,27.79 114.46,26.06 114.46,23.01 113.05,21.6 v5(113.05,20.44) ; v5(130.01,51.72) v4(130.44,51.72)
  BOTTOM w0.127: 118.36,49.78 118.15,49.78 117.84,50.08 117.84,50.89 117.03,51.71 114.88,51.71 114.71,51.89 114.71,52.25 114.43,52.53 RE473.2 114.43,53.03 114.44,53.04 RE182.2 ; 118.36,49.78 118.36,48.2 117.74,47.58 117.74,45.03 118.05,44.72 118.85,44.72 119.05,44.52 119.05,43.94 118.78,43.67 118.78,41.76 116.25,39.24 116.25,35.85 115.56,35.16 112.62,35.16 109.86,32.4 108.53,32.4 108.16,32.04 v5(108.16,31.57) ; 118.36,49.78 118.55,49.78 118.79,50.02 119.98,50.02 120.17,49.83 v6(120.76,49.83) 120.94,50.01 RE507.1
PROCHOT#_R1: length 2.2
  TOP w0.127: RE161.1 274.19,55.61 UE1.H13
PS_SMBCLK: length 6.9
  IN3 w0.061: v5(201.62,66.99) 200.93,66.99 200.87,67.05 200.87,67.32 200.73,67.46 199.71,67.46 199.4,67.15 199.4,66.74 199.75,66.4 199.75,65.65 199.62,65.52 198.86,65.52 v5(198.8,65.46)
  BOTTOM w0.127: U16.A1 200.91,67.8 200.91,67.13 RS11.1 v5(201.62,66.99)
PS_SMBDAT: length 7.3
  IN3 w0.061: v5(199.92,66.99) 200.62,66.99 200.68,67.05 200.68,67.24 200.65,67.27 199.78,67.27 199.59,67.07 199.59,66.82 199.94,66.48 199.94,65.57 199.64,65.28 199.64,64.78 v5(199.8,64.62)
  BOTTOM w0.127: Q12.4 v5(199.8,64.62) ; v5(199.92,66.99) RS12.1 200.66,67.16 200.66,67.52 200.43,67.74 U16.B1
PSENSOR_CS0: length 47.7
  IN3 w0.061: v5(243.39,70.41) 243.02,70.41 239.07,74.37 225.02,74.37 224.4,73.75 221.25,73.75 219.5,72 219.5,71.53 218.92,70.95 v5(206.6,70.95)
  BOTTOM w0.127: LS3.1 205.99,71.56 v5(206.6,70.95) 207.28,71.63 JLTE1.1 ; v5(243.39,70.41) T146.1
PSENSOR_CS2: length 7.9
  TOP w0.127: v1(197.24,69.4) v2(197.24,68.46) 197.24,67.89 LS6.1
  IN1 w0.061: v4(198.32,72.29) 198.73,71.89 198.73,68.93 198.26,68.46 v2(197.24,68.46)
  IN3 w0.061: v5(198.32,71.9) v4(198.32,72.29)
  BOTTOM w0.127: JLTE2.5 198.38,71.95 v5(198.32,71.9)
PWM1_IA: length 2.5
  TOP w0.127: PR903.1 41.46,57.7 v1(41.68,57.92) 41.96,58.2 v2(42.2,58.2)
  IN1 w0.061: v4(42.24,58.53) 42.24,58.23 v2(42.2,58.2)
  IN3 w0.061: v5(42.43,58.88) 42.43,58.72 v4(42.24,58.53)
PWM2_IA: length 3.7
  TOP w0.127: PR904.1 41.32,56.92 42.2,57.8 42.52,57.8 v2(43.02,58.29)
  IN1 w0.061: v2(43.02,58.29) 42.8,58.29 v4(42.64,58.13)
  IN3 w0.061: v5(42.67,58.48) 42.67,58.17 v4(42.64,58.13)
PWM5_GT: length 3.3
  TOP w0.127: PR906.1 41,56.13 41.84,56.96 v2(42.24,56.96) 42.64,56.96 v1(42.65,56.97)
  IN1 w0.061: v2(42.24,56.96) 42.34,57.07 v4(42.66,57.07)
  IN3 w0.061: v4(42.66,57.07) 42.43,57.29 v5(42.21,57.29)
PWM6_SA: length 2.7
  TOP w0.127: v2(41.98,56.51) v1(41.6,56.13) 40.84,55.37 PR907.1
  IN1 w0.061: v2(41.98,56.51) 42.02,56.55 v4(42.46,56.55)
  IN3 w0.061: v4(42.46,56.55) 42.46,56.63 v5(42.2,56.89)
PWM_CORE1: length 58.6
  TOP w0.127: v2(42.82,60.69) 42.82,59.86 41.17,58.21 40.02,58.21 39.74,57.93 PR903.2
  IN1 w0.127: v2(42.82,60.69) 42.8,60.71 42.8,61.43 v4(42.49,61.74)
  IN1 w0.203: v6(77.86,69.19) 77.66,69.39 77.66,71.83 75.63,73.86 74.99,73.86 74.64,74.21 73.49,74.21 73.11,74.59 v4(73.11,74.95)
  IN3 w0.203: v5(64.05,63.72) 63.59,63.72 61.85,61.99 56.22,61.99 55.52,62.69 55.14,62.69 53.68,64.15 53.2,64.15 52.21,65.14 44.11,65.14 42.24,63.28 42.24,61.99 v4(42.49,61.74) ; v5(72.71,74.97) 73.09,74.97 v4(73.11,74.95)
  BOTTOM w0.203: v5(64.05,63.72) 64.05,65.39 64.72,66.06 74.72,66.06 v6(77.86,69.19)
PWM_CORE2: length 92.9
  TOP w0.127: PR904.2 39.2,56.92 v1(38.75,57.37)
  IN1 w0.127: v2(39.74,57.04) 39.62,57.17 39.05,57.17 38.58,57.64 38.58,58.67 39.51,59.6 v4(42.81,59.6)
  IN1 w0.203: v4(87.3,65.55) 87.56,65.3 101.87,65.3 103.15,66.58 108.12,66.58 110.06,68.51 v4(110.06,69.27)
  IN3 w0.203: v4(87.3,65.55) 87.22,65.63 85.83,65.63 v5(85.48,65.99) ; v4(42.81,59.6) 42.99,59.6 43.24,59.85 43.24,60.69 42.8,61.13 42.8,61.5 42.89,61.59 42.89,61.89 42.53,62.25 42.53,63.09 44.28,64.84 51.95,64.84 52.97,63.82 53.61,63.82 55.04,62.39 55.44,62.39 56.11,61.72 61.96,61.72 63.48,63.24 v5(64.05,63.24) ; v5(80.45,68.22) 78.8,68.22 78.33,68.69 v5(78.14,68.69) ; v5(112.75,70.57) 112.62,70.69 111,70.69 110.06,69.76 v4(110.06,69.27)
  BOTTOM w0.203: v5(85.48,65.99) 85.46,66.01 82.83,66.01 80.62,68.22 v5(80.45,68.22) ; v5(78.14,68.69) 78.01,68.69 75.06,65.73 64.91,65.73 64.38,65.2 64.38,63.54 64.07,63.24 v5(64.05,63.24)
PWM_FAN1: length 104
  TOP w0.127: v2(208.25,26.85) v1(208.25,27.51) ; v2(269.77,52.81) 269.84,52.87 UE1.L10
  IN1 w0.061: v2(208.25,26.85) v4(208.51,27.11) ; v4(263.12,48.82) 263.12,48.86 263.62,49.37 263.62,50.08 264.06,50.52 265.14,50.52 265.19,50.47 267.66,50.47 267.99,50.8 268.4,50.8 268.76,51.15 268.76,51.43 269.55,52.22 269.55,52.59 v2(269.77,52.81)
  IN3 w0.061: v4(208.51,27.11) 208.58,27.18 v5(208.58,27.45) 210.28,27.45 213.47,30.65 213.47,32.51 213.89,32.92 216.58,32.92 219.47,30.04 222.4,30.04 223.94,28.5 228.39,28.5 229.2,27.69 237.38,27.69 238.81,26.26 250.65,26.26 252.93,28.54 254.02,28.54 256.67,31.18 260.07,31.18 260.77,31.89 263.02,31.89 265.44,34.31 265.44,36.12 265.15,36.41 265.15,42.68 263.57,44.26 263.57,46.67 263.12,47.12 v4(263.12,48.82)
  BOTTOM w0.127: JFAN1.2 199.84,29.64 201.78,27.7 202.61,27.7 R24.2 205.15,28.39 205.94,27.6 208.43,27.6 v5(208.58,27.45)
PWM_GT: length 9.1
  TOP w0.127: v2(40.63,52.17) 40.45,52.34 39.85,52.34 39.52,52.67 39.52,53 39.23,53.3 38.71,53.3 38.59,53.41 v1(38.59,55.49) 39.23,56.13 PR906.2
  IN1 w0.061: v2(40.63,52.17) 41.01,52.17 v4(41.29,52.44)
  IN3 w0.061: v4(41.29,52.44) 41.15,52.3 v5(41.15,52.04)
  BOTTOM w0.127: PU1100.9 41.79,50.95 41.15,51.59 v5(41.15,52.04)
PWM_SA: length 114.1
  TOP w0.127: PR907.2 39.74,55.1 40.03,54.81 40.9,54.81 42.15,56.05 42.15,56.17 42.49,56.51 43.03,56.51 44,57.48 v1(44,59.19) 44,61.04 v2(43.76,61.27)
  IN1 w0.127: v4(42.92,62.62) 43.76,61.77 v2(43.76,61.27)
  IN1 w0.203: v4(109.17,69.25) 109.17,68.15 107.97,66.95 103.01,66.95 101.69,65.63 87.94,65.63 v4(87.9,65.68)
  IN3 w0.203: v4(109.17,69.25) 109.17,69.67 110.51,71.01 112.94,71.01 113.32,70.63 121.17,70.63 125.61,66.19 129.36,66.19 129.79,66.62 129.79,68.04 130.06,68.31 v5(130.57,68.31) ; v4(87.9,65.68) 87.64,65.94 v5(86.23,65.94) ; v5(64.71,63.7) 64.71,63.42 64.18,62.9 63.51,62.9 62.07,61.46 56,61.46 55.36,62.1 54.9,62.1 53.56,63.44 52.84,63.44 51.8,64.48 44.41,64.48 42.92,62.99 v4(42.92,62.62) ; v5(78.14,68.29) 78.19,68.29 78.7,67.79 v5(80.45,67.79)
  BOTTOM w0.203: v5(130.57,68.31) 130.32,68.06 PU1101.7 ; v5(86.23,65.94) 85.93,65.64 82.6,65.64 v5(80.45,67.79) ; v5(78.14,68.29) 75.25,65.4 65.06,65.4 64.71,65.04 v5(64.71,63.7)
PWR_DEBUG#_XDP: length 13.2
  TOP w0.127: RC256.2 59.38,65.66 59.83,66.11 59.83,66.67 60.15,66.99 RC521.2 60.24,67.68 v1(59.96,67.96) 59.26,68.66 58.33,68.66 v2(58.25,68.58) ; JXDP1.45 56.38,72.03 55.62,71.27 54.13,71.27 v2(53.89,71.02)
  IN1 w0.061: v2(58.25,68.58) 58.22,68.6 57.97,68.81 57.66,68.95 57.42,68.99 57.11,69.1 54.46,70.48 54.37,70.53 54.27,70.6 v2(53.89,71.02)
PWR_LED#: length 4
  BOTTOM w0.254: QN11.1 289.29,71.45 290.3,72.46 R20.1 v1(292.35,72.46)
PWR_LED#_R: length 3.5
  TOP w0.127: v6(292.17,73.79) v3(291.4,73.79)
  BOTTOM w0.127: R20.2 291.76,73.37 v6(292.17,73.79) 292.67,74.29 JPTN1.2
PWRBTN#: length 308.4
  TOP w0.127: v6(259.47,68.01) 259.47,66.84 259.1,66.48 251.99,66.48 v6(251.53,66.94) ; JAPS1.11 129.49,38.61 v2(129.92,38.18) 130.36,38.63 131.42,38.63 133.31,36.73 133.31,33.86 134.48,32.68 134.48,30.77 141.83,23.42 149.98,20.89 153.92,19.75 178.01,19.75 187.56,29.3 187.87,29.3 v3(188.4,29.83) v2(190.18,31.61) ; v6(289.15,72.28) 288.77,71.9 284.36,71.9 280.19,76.07 277.97,76.07 v2(277.97,72.17) ; v2(267.9,65.55) 267.9,65.32 267.84,65.26 CE34.1 267.78,65.11 RE190.1
  IN1 w0.061: v4(130.95,37.78) 130.33,37.78 v2(129.92,38.18) ; v4(268.33,65.55) 268.21,65.44 268.02,65.44 v2(267.9,65.55) ; v2(190.18,31.61) 189.95,31.84 189.95,34.4 190.66,35.11 193.25,35.11 194.22,36.08 194.54,36.08 194.55,36.09 196.08,36.09 202.69,42.7 202.69,55.91 201.31,57.29 v6(197.66,57.29) ; v2(277.97,72.17) v4(277.39,72.17)
  IN2 w0.061: v4(277.39,72.17) 275.71,72.17 269.09,65.55 v4(268.33,65.55) 268.27,65.61 265.46,65.61 264.73,66.34 261.15,66.34 v6(259.47,68.01)
  IN3 w0.061: v5(193.64,58.2) 193.64,58.77 198.1,63.23 200.56,63.23 205.16,67.84 213.49,67.84 214.11,67.21 251.25,67.21 v6(251.53,66.94) ; v5(130.36,38.11) 130.39,38.11 130.56,37.94 130.95,37.78 v4(130.95,37.78) ; v5(278.05,18.85) 278.05,23.91 279.14,25.01 279.14,33.33 280.22,34.41 280.22,35.27 279.63,35.86 279.63,51.98 279.26,52.35 279.26,62.43 279.01,62.67 279.01,64.84 286.46,72.28 v6(289.15,72.28)
  BOTTOM w0.127: v5(193.64,58.2) 192.54,58.2 192.33,57.99 SW2.2 SW2.1 v6(197.66,57.29) ; PU700.1 125.99,37.81 126.39,37.41 128.57,37.41 128.74,37.57 128.74,38.33 128.85,38.45 130.02,38.45 v5(130.36,38.11)
  BOTTOM w0.254: JPTN1.3 292.23,74.79 291.52,74.07 DE4.1 290.8,74.07 290.39,73.66 290.39,73.56 289.15,72.32 v6(289.15,72.28)
PWRGD_XDP: length 9.5
  TOP w0.127: v2(62.18,68.31) 61.94,68.06 RC250.2 RC371.2
  IN1 w0.061: v2(62.18,68.31) v4(62.24,68.63) ; v2(58.17,72.31) 58.09,72.24 58.09,71.96 58.11,71.94 v4(58.11,71.94)
  IN3 w0.061: v5(58.56,71.91) 58.14,71.91 v4(58.11,71.94) ; v4(62.24,68.63) v5(61.9,68.56)
  BOTTOM w0.127: v5(58.56,71.91) 60.64,71.91 61.63,70.93 61.63,68.84 v5(61.9,68.56)
REFCLK_CNV: length 159.4
  TOP w0.127: v6(213.96,38.66) 213.95,38.66 213.27,37.99 213.27,29.99 212.75,29.47 212.75,27.57 214.6,25.71 214.6,21.77 214.34,21.51 214.34,20.53 215.04,19.83 218.18,19.83 219.98,21.62 RN55.2 ; v2(194.27,34.38) 194.27,34.16 193.14,33.03 191.9,33.03 v1(191.36,32.49) 191.11,32.24 190.14,32.24 177.91,20.01 153.95,20.01 150.06,21.13 141.96,23.64 134.74,30.87 134.74,32.79 133.56,33.96 133.56,36.84 129.79,40.61 129.79,42.6 127.87,44.52 124.9,44.52 124.15,45.27 121.65,45.27 121.17,45.75 121.17,48.79 119.58,50.37 118.87,50.37 115.94,53.31 113.64,53.31 112.64,52.3 111.16,52.3 L3.2
  IN1 w0.061: v4(194.51,34.68) 194.27,34.44 v2(194.27,34.38)
  IN2 w0.061: v4(194.51,34.68) 194.95,34.68 197.6,37.32 204.9,37.32 205.32,36.9 205.32,36.72 205.53,36.5 206.23,36.5 207.86,38.13 213.42,38.13 213.95,38.66 v6(213.96,38.66)
REFCLK_CNV_L: length 4.2
  TOP w0.127: L3.1 CC260.1 109.93,53 v2(109.22,53)
  IN1 w0.061: v4(108.56,53.51) 108.71,53.36 108.86,53.36 v2(109.22,53)
  IN3 w0.061: v4(108.56,53.51) 108.51,53.51 108.4,53.62 108.37,53.64 108.37,53.64 108.24,53.78 108.16,53.83 107.72,53.83 v5(107.61,53.94)
  BOTTOM w0.127: UCPU1.CM3 v5(107.61,53.94)
REFCLK_CNV_R: length 2.9
  TOP w0.127: RN55.1 RN79.1 v6(218.87,24.53) v1(218.27,24.53)
  BOTTOM w0.127: JNGFF3.64 218.85,24.55 v6(218.87,24.53)
REM_DIODE1_N: length 279.6
  TOP w0.127: v2(79.56,42.94) 79.73,42.78 79.73,42.14 QE12.3 ; v2(94.8,18.43) 94.87,18.37 95.2,18.37 95.5,18.07 95.5,15.54 CE58.2 95.56,15.27 QE14.2 95.56,14 QE14.1 ; v2(198.92,18.5) 198.84,18.42 198.84,17.85 196.55,15.56 183.18,15.56 180.82,13.2 152.08,13.2 150.91,13.38 150.67,13.46 150.64,13.46 146.41,14.78 137.87,14.78 133.81,18.84 123.9,18.84 122.59,17.53 122.59,17.39 122.67,17.31 v2(122.67,17.31) ; UE1.A8 267.94,61.5 267.94,61.99 268.55,62.59 268.55,63.07 CE22.1
  IN1 w0.127: v4(271.01,62.54) 270.86,62.39 269.07,62.39 268.7,62.76 268.7,63.05 v2(268.9,63.24) ; v4(198.98,18.85) 198.92,18.79 v2(198.92,18.5) ; v2(79.56,42.94) v4(79.56,43.28) ; v2(94.8,18.43) 94.87,18.37 95,18.37 95.09,18.46 95.09,19.34 95.79,20.04 96.08,20.04 96.48,20.45 96.48,20.79 v4(96.34,20.93) 96.49,21.08 96.49,21.43 96.75,21.68 98.08,21.68 98.44,22.05 103.19,22.05 107.23,18 113.13,18 114.17,19.04 120.34,19.04 120.86,18.52 121.97,18.52 122.59,17.9 122.59,17.38 v2(122.67,17.31)
  IN2 w0.127: v4(79.56,43.28) 79.74,43.1 79.74,41.47 78.75,40.48 78.75,38.64 79.26,38.13 79.26,34.85 82.51,31.59 92.78,31.59 96.23,28.15 96.23,23.18 96.79,22.62 96.79,21.65 96.5,21.37 96.5,21.09 v4(96.34,20.93)
  IN3 w0.127: v4(271.01,62.54) 271.17,62.38 271.75,62.38 272.95,61.18 272.95,57.03 273.39,56.58 273.39,50.65 272.05,49.31 272.05,35.26 271.96,35.17 271.96,32.81 270.14,30.99 270.14,30.28 261.95,22.09 239.21,22.09 236.31,25 212.05,25 210.35,23.3 210.35,20.86 208.19,18.7 199.97,18.7 199.63,19.04 199.17,19.04 v4(198.98,18.85)
REM_DIODE1_P: length 279.3
  TOP w0.127: v2(122.23,17.32) 122.34,17.43 122.34,17.64 123.79,19.09 133.91,19.09 137.98,15.03 146.45,15.03 150.68,13.71 150.71,13.71 150.97,13.63 152.1,13.46 180.72,13.46 183.08,15.82 196.44,15.82 198.58,17.96 198.58,18.46 v2(198.53,18.51) ; CE22.2 268.29,63.05 268.29,62.7 267.69,62.09 267.69,61.46 UE1.A7 ; v2(94.8,18.05) 94.87,18.12 95.1,18.12 95.25,17.96 95.25,15.54 CE58.1 95.11,15.34 QE14.3 ; v2(80.15,42.94) 79.98,42.78 79.98,42.12 QE12.2 80.07,41.56 QE12.1
  IN1 w0.127: v2(94.8,18.05) 94.87,18.12 95.1,18.12 95.34,18.35 95.34,19.23 95.89,19.78 96.18,19.78 96.74,20.34 96.74,20.78 v4(96.88,20.93) 96.75,21.06 96.75,21.32 96.86,21.43 98.18,21.43 98.54,21.79 103.08,21.79 107.13,17.75 113.24,17.75 114.28,18.79 120.23,18.79 120.76,18.27 121.87,18.27 122.34,17.8 122.34,17.43 v2(122.23,17.32) ; v2(267.99,63.24) 268.2,63.24 268.45,63 268.45,62.66 268.97,62.14 270.85,62.14 v4(271.02,61.97) ; v2(198.53,18.51) 198.55,18.54 198.55,18.75 v4(198.43,18.87) ; v4(80.15,43.3) v2(80.15,42.94)
  IN2 w0.127: v4(80.15,43.3) 80,43.15 80,41.36 79,40.37 79,38.74 79.51,38.24 79.51,34.96 82.62,31.85 92.89,31.85 96.48,28.25 96.48,23.28 97.04,22.73 97.04,21.54 96.76,21.26 96.76,21.05 v4(96.88,20.93)
  IN3 w0.127: v4(271.02,61.97) 271.17,62.12 271.65,62.12 272.69,61.08 272.69,56.92 273.14,56.48 273.14,50.76 271.79,49.41 271.79,35.36 271.7,35.27 271.7,32.91 269.89,31.1 269.89,30.38 261.85,22.35 239.32,22.35 236.41,25.25 211.94,25.25 210.1,23.41 210.1,20.97 208.09,18.95 200.07,18.95 199.73,19.3 198.77,19.3 198.43,18.96 v4(198.43,18.87)
REM_DIODE2_N: length 106.3
  TOP w0.127: v2(254.15,64.99) 254.06,64.9 254.06,63.05 v7(254.46,62.65) 255.75,61.36 255.75,61.08 CE55.2 255.92,60.46 255.85,60.39 QE8.2 255.85,59.82 255.62,59.59 QE8.1 ; UE1.A10 269.56,61.48 269.56,61.7 270.42,62.55 270.42,63.65 270.55,63.78 270.8,63.78 270.93,63.65 v2(270.93,63.44)
  IN1 w0.127: v4(254.25,65.35) 254.15,65.24 v2(254.15,64.99) 254.04,64.88 254.04,64.76 254.17,64.64 254.95,64.64 257.75,67.43 264.12,67.43 265.42,66.59 266.35,66.3 271.61,66.3 272.13,65.78 272.13,65.18 270.93,63.98 v2(270.93,63.44)
  IN3 w0.127: v4(254.25,65.35) 254.06,65.55 254.06,65.98 251.94,68.09 214.88,68.09 214.37,68.6 204.87,68.6 200.26,63.99 197.83,63.99 192.75,58.92 192.75,55.56 193.03,55.28 193.53,55.28 v5(193.71,55.1)
  BOTTOM w0.127: QE17.3 192.89,55.26 193.55,55.26 v5(193.71,55.1)
REM_DIODE2_P: length 104.3
  TOP w0.127: UE1.A9 269.31,61.48 269.31,61.8 270.17,62.66 270.17,63.76 270.44,64.04 270.61,64.04 CE23.2 ; QE8.3 255.4,60.42 255.33,60.49 CE55.1 255.5,61.08 255.5,61.25 253.81,62.94 253.81,64.9 253.8,64.9 253.8,64.92 v2(253.73,65)
  IN1 w0.127: v4(253.63,65.36) 253.73,65.26 v2(253.73,65) 253.79,64.94 253.79,64.66 254.06,64.38 255.06,64.38 256.53,65.85 256.53,65.85 257.85,67.18 264.04,67.18 265.31,66.36 266.31,66.05 271.5,66.05 271.87,65.67 271.87,65.29 271,64.41 v2(270.85,64.41)
  IN3 w0.127: v4(253.63,65.36) 253.8,65.53 253.8,65.87 251.84,67.84 214.78,67.84 214.27,68.34 204.98,68.34 200.37,63.73 197.93,63.73 193.01,58.81 193.01,55.67 193.13,55.54 193.57,55.54 v5(193.71,55.68)
  BOTTOM w0.127: QE17.1 192.32,55.62 QE17.2 192.89,55.52 193.55,55.52 v5(193.71,55.68)
REM_DIODE3_N: length 404
  TOP w0.076: 269.04,60.41 268.74,60.71 268.74,61.52 268.76,61.54 268.76,61.56
  TOP w0.127: v2(118.64,12.18) 118.55,12.27 118.55,12.87 120.13,14.45 120.92,14.45 123.43,16.95 123.43,17.24 124.27,18.08 132.84,18.08 136.93,13.99 145.5,13.99 151.28,12.44 181.3,12.44 183.28,14.42 196.71,14.42 199.52,17.23 208.53,17.23 212.18,20.87 212.18,23.01 v6(212.37,23.21) ; 268.76,61.56 268.76,61.74 269.55,62.53 269.55,64.1 CE112.1 269.4,64.61 269.4,64.79 269.55,64.94 271.35,64.94 271.77,64.52 272.6,64.52 272.92,64.2 273.63,64.2 v2(273.76,64.08) ; QE23.1 36.35,15.54 QE23.2 36.35,14.81 36.48,14.68 36.48,14.31 v2(36.31,14.14)
  IN1 w0.127: v2(36.31,14.14) 36.51,13.94 36.51,12.08 37.99,10.6 48.36,10.6 48.87,11.11 50.73,11.11 50.85,10.99 50.85,10.75 v4(50.69,10.59) ; v4(118.69,11.85) 118.64,11.91 v2(118.64,12.18) ; v4(273.38,64.08) v2(273.76,64.08)
  IN3 w0.127: v4(273.38,64.08) 273.25,64.2 273.07,64.2 272.94,64.07 272.94,62.45 274.17,61.23 274.17,48.09 272.81,46.73 272.81,34.89 272.72,34.8 272.72,32.27 271.37,30.93 271.37,30.19 262.28,21.1 238.86,21.1 236.24,23.72 221.72,23.72 218.44,23.72 218.05,24.1 212.43,24.1 212.18,23.86 212.18,23.4 v6(212.37,23.21) ; v5(42.91,77.21) 42.87,77.24 42.87,77.82 42.56,78.14 36.41,78.14 35.88,77.6 35.88,75.82 36.21,75.49 36.21,72.38 37.16,71.43 37.16,67.15 36.65,66.65 36.65,64.01 36.66,64.01 36.66,61.94 36.66,57.76 36.89,57.53 36.89,55.27 37.08,55.08 37.08,52.77 37.25,52.59 37.25,51.11 38.87,49.5 40.7,49.5 41.4,48.8 41.4,46.88 41.73,46.55 41.73,42.33 43.21,40.85 44.52,40.85 46.72,38.65 48.36,38.65 48.94,38.07 48.94,36.62 49.07,36.49 49.07,34.24 50.17,33.14 52.62,33.14 53.87,31.89 53.87,30.63 53.72,30.48 53.72,26.11 54.69,25.15 54.69,22.09 53.2,20.61 53.2,17.25 57.82,12.63 57.82,11.62 57.28,11.09 53.85,11.09 53.49,11.45 51.15,11.45 50.86,11.15 50.86,10.75 v4(50.69,10.59) 50.87,10.41 50.87,10.02 51.25,9.65 117.9,9.65 118.55,10.3 118.55,11.75 118.66,11.85 v4(118.69,11.85)
  BOTTOM w0.127: v5(42.91,77.21) 42.8,77.31 42.8,77.44 42.83,77.47 JEDP1.28
REM_DIODE3_P: length 402.5
  TOP w0.076: 268.24,60.41 268.53,60.71 268.53,61.52 268.51,61.54 268.51,61.56
  TOP w0.127: v2(36.9,14.14) 36.73,14.31 36.73,14.99 QE23.3 ; 268.51,61.56 268.51,61.85 269.3,62.64 269.3,63.8 CE112.2 269.15,64.61 269.15,64.9 269.45,65.19 271.45,65.19 271.87,64.78 272.71,64.78 273.03,64.46 273.63,64.46 v2(273.76,64.58) ; v2(118.18,12.18) 118.3,12.29 118.3,12.98 120.02,14.7 120.82,14.7 123.18,17.06 123.18,17.34 124.17,18.33 132.94,18.33 137.03,14.24 145.53,14.24 151.31,12.69 181.19,12.69 183.17,14.67 196.61,14.67 199.41,17.48 208.43,17.48 211.92,20.98 211.92,23.04 v6(211.75,23.21)
  IN1 w0.127: v2(273.76,64.58) 273.72,64.62 v4(273.38,64.62) ; v4(118.12,11.84) 118.18,11.91 v2(118.18,12.18) ; v4(51.27,10.59) 51.1,10.76 51.1,11.09 50.84,11.36 48.77,11.36 48.26,10.85 38.1,10.85 36.77,12.18 36.77,14.01 v2(36.9,14.14)
  IN3 w0.127: v5(42.47,77.21) 42.62,77.36 42.62,77.71 42.45,77.88 36.52,77.88 36.13,77.5 36.13,75.93 36.46,75.6 36.46,72.49 37.41,71.54 37.41,67.05 36.91,66.54 36.91,64.11 36.91,64.11 36.91,57.87 37.15,57.63 37.15,55.37 37.33,55.19 37.33,52.87 37.51,52.7 37.51,51.22 38.98,49.75 40.8,49.75 41.65,48.9 41.65,46.98 41.99,46.65 41.99,42.44 43.32,41.1 44.63,41.1 46.82,38.91 48.47,38.91 49.2,38.17 49.2,36.73 49.33,36.6 49.33,34.35 50.28,33.39 52.73,33.39 54.13,32 54.13,30.52 53.97,30.37 53.97,26.22 54.94,25.25 54.94,21.99 53.45,20.5 53.45,17.35 58.07,12.74 58.07,11.52 57.39,10.84 53.74,10.84 53.39,11.19 51.26,11.19 51.11,11.05 51.11,10.76 v4(51.27,10.59) 51.12,10.44 51.12,10.13 51.35,9.9 117.79,9.9 118.3,10.41 118.3,11.66 v4(118.12,11.84) ; v4(273.38,64.62) 273.22,64.45 272.97,64.45 272.69,64.18 272.69,62.35 273.91,61.12 273.91,48.19 272.55,46.83 272.55,34.99 272.46,34.91 272.46,32.38 271.12,31.03 271.12,30.3 262.18,21.35 238.96,21.35 236.35,23.97 221.72,23.97 218.55,23.97 218.16,24.36 212.32,24.36 211.93,23.97 211.93,23.4 211.92,23.39 211.92,23.38 v6(211.75,23.21)
  BOTTOM w0.127: v5(42.47,77.21) 42.55,77.29 42.55,77.41 42.43,77.53 JEDP1.27
RESET_IN#: length 2.4
  TOP w0.127: UE1.C1 262.5,59.61 262.37,59.73 261.58,59.73 261.35,59.96 RE138.2
RESET_OUT: length 8.5
  TOP w0.127: UE1.G4 265.04,56.37 264.69,56.03 263.94,56.03 v2(263.77,55.86) ; v2(258.25,55.37) 258.01,55.12 RE158.2
  IN1 w0.061: v2(258.25,55.37) 258.25,55.62 258.6,55.96 261.83,55.96 262.17,55.62 263.44,55.62 263.67,55.86 v2(263.77,55.86)
RESET_OUT#_R: length 10.9
  TOP w0.127: RC370.2 RC241.2 58.48,66.69 RC522.2 CC89.1 58.48,67.92 58.36,68.05 v2(57.75,68.65) ; v2(53.41,71) 53.98,71.57 55.42,71.57 55.78,71.93 JXDP1.47
  IN1 w0.061: v2(53.41,71) 54.37,70.39 54.4,70.37 57.06,68.99 57.71,68.75 v2(57.75,68.65)
RING2: length 2.4
  IN2 w1.016: 289.91,21.19 289.64,21.19 288.71,22.12 288.71,22.92
  vias: v1(290.35,21.14) v6(287.44,23.73) v6(287.87,23.36) v6(290.7,21.48) v6(291.31,21.48)
RING2_CONN:
  vias: v1(294.42,20.55) v2(293.47,20.85) v2(293.56,21.35) v2(293.76,20.85) v2(305.71,24.37) v2(305.92,24.15) v2(306.17,24.53) v4(293.34,21.99) v4(293.98,21.99) v4(306.3,24.15) v4(306.68,24.53)
RREF: length 2.9
  TOP w0.127: v1(290.57,30.99) RR10.2
  TOP w0.203: 291.48,32.73 291.69,32.95 UR1.9
  TOP w0.305: RR10.2 291.29,32.73 291.48,32.73
RTCRST_ON: length 102.6
  TOP w0.127: v2(270.99,57.57) 270.64,57.22 UE1.F11 ; RB34.1 276.54,62.75 278.57,62.75 v1(278.58,62.75) 278.99,62.75 v2(279.73,63.49) ; v6(309.6,3.96) 309.03,3.96 308.77,3.69 QB6.5
  IN1 w0.061: v2(279.73,63.49) 279.73,63.46 279.56,63.29 v4(279.56,63.18) ; v2(270.99,57.57) 270.99,57.7 271.37,58.08 v4(271.37,58.18)
  IN2 w0.061: v6(309.6,3.96) 309.61,3.94 310.17,3.94 311.02,4.79 311.02,8.77 308.92,10.86 301.74,10.86 301.03,11.58 298.19,11.58 297.03,12.74 294.29,12.74 290.6,16.43 284.07,16.43 283.46,17.04 283.46,20.74 v4(282.17,22.04) ; v4(279.56,63.18) 279.45,63.18 277.19,60.92 276.36,60.92 273.71,58.27 271.46,58.27 v4(271.37,58.18)
  IN3 w0.061: v4(282.17,22.04) 279.43,24.77 279.43,33.21 280.51,34.29 280.51,35.39 279.92,35.98 279.92,62.82 v4(279.56,63.18)
RTCRST_ON_POWER: length 101
  TOP w0.127: RB24.2 v6(313.73,1.8) ; 272.24,60.41 272.24,60.53 272.81,61.11 272.81,61.28 273.98,62.45 274.43,62.45 275.07,63.1 278.44,63.1 v1(279.62,64.28) v2(280.27,64.94)
  IN1 w0.061: v2(280.27,64.94) 280.29,64.92 v4(280.61,64.92)
  IN3 w0.061: v4(280.61,64.92) 280.21,64.52 280.21,36.1 280.8,35.51 280.8,34.17 279.72,33.09 279.72,25 282.73,22 282.73,13.91 283.26,13.38 283.26,11.98 284.5,10.74 299.49,10.74 301.15,10.31 301.99,9.88 308.92,2.95 308.92,2.43 309.55,1.8 v6(313.73,1.8)
RTCRST_ON_R: length 5.4
  TOP w0.127: QB6.2 308.77,1.42 308.94,1.25 310.41,1.25 310.62,1.45 CB17.1 311.24,1.69 RB23.2 311.42,1.87 DB5.2 v1(311.42,3.79)
RTD3_CIO_PWR_EN: length 153.1
  TOP w0.127: v2(103.19,37.28) 102.84,37.28 102.82,37.31 99.87,37.31 99.3,36.73 97.26,36.73 94.49,33.97 v1(89.56,33.97) 89.5,33.91 51.64,33.91 50.09,32.35 49.44,32.35 49.02,31.93 v2(49.02,31.69)
  IN1 w0.061: v2(103.19,37.28) 103.2,37.27 v4(103.68,37.27) ; v4(15.6,41.71) 16.23,41.08 18.45,41.08 19.33,40.2 20.66,40.2 20.81,40.35 23.51,40.35 24.21,39.65 24.87,39.65 25.25,40.04 27.11,40.04 27.61,39.54 29.22,39.54 32.58,42.9 39.76,42.9 41.24,41.42 41.24,37.79 41.24,37.79 41.24,37.65 42.84,36.05 45.8,36.05 47.47,34.38 47.47,33.05 48.6,31.92 48.8,31.92 v2(49.02,31.69)
  IN2 w0.061: v4(15.6,41.71) 15.91,42.02 15.91,42.33 15.58,42.66 15.58,44.34 16.01,44.77 16.01,46.66 18.64,49.3 21.23,49.3 21.71,49.78 21.71,50.31 21.83,50.43 22.18,50.43 22.38,50.63 22.38,51.5 22.6,51.73 23.54,51.73 23.68,51.87 23.68,52.16 23.9,52.38 24.13,52.38 24.31,52.56 24.31,55.9 24.14,56.08 22.22,56.08 v4(21.69,56.6) ; v4(24.21,61.91) 24.21,62.36 24.02,62.55 24.02,62.86 24.23,63.07 24.62,63.07 25.39,62.3 27.01,62.3 27.25,62.54 28.79,62.54 v4(29.2,62.95)
  IN3 w0.061: v4(24.21,61.91) 24.18,61.91 24.18,60.7 24.14,60.66 24.14,60.41 23.56,59.83 23.56,59.21 21.69,57.35 v4(21.69,56.6) 21.69,56.59 21.63,56.53 21.4,56.53 21.19,56.32 20.89,56.32 20.74,56.47 20.74,56.79 20.83,56.88 20.83,57.27 v5(20.82,57.28) ; v5(30.95,61.15) 30.95,61.78 29.78,62.95 v4(29.2,62.95) ; v4(103.68,37.27) 103.87,37.46 103.87,38.31 104.95,39.39 v5(105.27,39.39)
  BOTTOM w0.066: v5(20.82,57.28) 20.82,57.28 UT2.F1 20.82,57.58
  BOTTOM w0.102: RT34.1 RT19.1 21.39,60.2 21.39,59.16 21.54,59.02 21.54,58.5 20.92,57.88 20.92,57.67 20.82,57.58
  BOTTOM w0.127: UCPU1.CN26 108.2,39.58 107.86,39.25 107.41,39.25 107.28,39.39 v5(105.27,39.39)
RTD3_SELECT: length 331.1
  TOP w0.127: v2(35.82,48.95) v1(35.82,49.95) 35.82,53.12 34.78,54.16 31.77,54.16 31.55,53.94 UT15.6 31.55,51.98 RT291.1
  IN1 w0.061: v4(272.48,56.53) 272.48,56.92 v2(272.23,57.17) ; v2(35.82,48.95) 35.68,48.95 33.6,46.87 v4(33.4,46.87)
  IN2 w0.061: v4(33.4,46.87) 32.78,46.87 31.63,45.72 31.63,44.02 31.55,43.94 31.55,41.81 29.54,39.8 29.54,38.56 27.86,36.88 27.86,36.25 27.47,35.86 27.47,30.32 27.17,30.03 27.17,25.71 24.91,23.44 24.75,23.44 24.13,23.44 23.39,22.7 23.39,20.22 23.39,19.19 27.33,15.25 27.35,15.25 27.46,15.25 27.46,15.25 35.16,15.25 38.48,11.93 43.66,11.93 44.53,12.79 47.97,12.79 48.24,12.53 52.79,12.53 52.97,12.71 55.83,12.71 56.06,12.47 56.44,12.47 56.65,12.68 56.99,12.68 57.58,12.1 97.19,12.1 97.65,12.55 101.39,12.55 101.59,12.76 103.17,12.76 103.47,12.45 109.86,12.45 114.43,17.02 123.45,17.02 123.88,17.44 126.67,17.44 129.07,16.46 130.92,14.61 130.92,14 132.65,12.26 151.93,12.26 152.18,12.01 179.66,12.01 182.01,14.36 200.1,14.36 200.6,13.86 201.77,13.86 203.25,15.35 210.5,15.35 212.74,17.58 217.66,17.58 236.77,36.69 255.93,36.69 258.76,39.52 263.87,39.52 265.75,41.4 266.08,41.4 267.8,43.11 268.95,43.11 273.61,47.77 273.61,54.34 273.61,54.35 273.61,55.4 v4(272.48,56.53)
RTD3_USB_PWR_EN: length 0.8
  IN1 w0.061: v2(19.77,56.04) 19.53,55.8 v4(19.49,55.8)
  IN3 w0.076: v4(19.49,55.8) 19.68,56 v5(19.68,56.17)
RUN_ON_EC: length 237.8
  TOP w0.127: v2(275.64,61.34) 275.63,61.34 275.61,61.34 RE500.1 ; v6(234.92,58.18) 235.47,57.63 235.47,50.68 234.35,49.56 v1(234.35,45.47) 234.35,37.74 223.32,26.71 223.32,23.73 222.36,22.78 222.36,21.06 220.34,19.04 220.34,14.66 218.15,12.46 209.99,12.46 208.41,14.04 v2(201.84,14.04) ; v2(269.29,59.25) 269.19,59.15 268.07,59.15 267.87,58.95 267.87,58.38 UE1.E8 ; U11.2 97.38,18.56 97.56,18.38 98.45,18.38 98.6,18.54 99.24,18.54 99.55,18.22 99.55,12.54 99.77,12.33 102.07,12.33 102.63,11.76 102.63,10.93 102.98,10.57 112.37,10.57 112.56,10.76 119.39,10.76 120.99,12.36 120.99,13.79 124.02,16.83 124.16,16.83 124.47,17.14 131.2,17.14 132.17,16.17 v2(132.17,15.84)
  IN1 w0.061: v2(269.29,59.25) 269.49,59.25 v4(269.62,59.38) 269.7,59.45 270.25,59.45 271.16,60.36 272.68,60.36 273.3,60.98 275.29,60.98 v2(275.64,61.34) ; v4(201.61,14.39) 201.61,14.26 v2(201.84,14.04) ; v4(132.13,15.44) 132.17,15.47 v2(132.17,15.84)
  IN2 w0.061: v4(201.61,14.39) 201.52,14.48 181.96,14.48 179.61,12.14 152.23,12.14 151.98,12.39 133.38,12.39 132.13,13.64 v4(132.13,15.44) ; v4(269.62,59.38) 269.46,59.54 267.22,59.54 266.57,58.89 265.99,58.89 265.34,59.54 262.67,59.54 259.68,56.55 250.91,56.55 249.27,58.18 v6(234.92,58.18)
RUN_ON_P: length 347.5
  TOP w0.127: v2(227.13,51.8) 227.13,51.61 226.27,50.75 U19.3 ; v2(227.13,51.8) 227.27,51.8 227.75,51.33 229.5,51.33 230.59,50.23 230.59,45.51 v2(230.47,45.38) ; v2(227.13,51.8) 227.13,55.3 R268.1 226.23,55.35 225.65,54.78 U32.2 ; QE1.2 252.27,54.68 252.27,51.76 v2(252.06,51.54) ; v2(130.4,38.19) 130.42,38.21 131.48,38.21 133.06,36.63 133.06,33.75 134.13,32.68 134.23,32.58 134.23,30.66 141.69,23.2 149.91,20.65 153.88,19.5 178.12,19.5 186.75,28.14 188.1,28.14 v1(188.82,27.42) 189.47,26.76 190.62,26.76 v2(190.85,27) 190.85,31.02 192.32,32.48 196.17,32.48 v2(196.18,32.47) 196.24,32.47 196.26,32.49 U6.3 ; U6.5 196.29,31.69 v2(196.25,31.65) ; R250.2 v2(97.4,20.82)
  IN1 w0.061: 196.24,32.47 196.26,32.45 196.26,31.66 v2(196.25,31.65) ; 196.24,32.47 v2(196.18,32.47) ; 196.24,32.47 196.24,32.97 206.98,43.7 211.93,43.7 212.62,44.39 223.92,44.39 224.76,45.24 230.32,45.24 v2(230.47,45.38) ; v4(130.19,38.55) 130.29,38.45 130.29,38.31 v2(130.4,38.19) ; v2(227.13,51.8) 227.14,51.8 227.76,51.18 228.2,51.18 228.86,50.53 245.12,50.53 246.15,51.56 252.04,51.56 v2(252.06,51.54) ; v4(106.55,17.65) 102.88,21.32 98.87,21.32 98.44,20.88 97.46,20.88 v2(97.4,20.82) ; v2(190.85,27) 190.89,26.97 v4(191.69,26.97)
  IN2 w0.061: v4(106.55,17.65) 109.93,17.65 113.15,20.87 122.19,20.87 122.78,21.45 126.99,21.45 127.96,20.48 128.17,20.39 131.29,20.39 131.58,20.68 139.89,20.68 140.51,20.06 143.39,20.06 147.63,15.83 153.39,15.83 153.66,15.56 178.13,15.56 189.54,26.97 v4(191.69,26.97) ; v4(120.04,62.84) 118.08,60.88 118.08,50.68 118.93,49.83 119.37,49.83 119.56,49.64 119.56,49.06 120.57,48.05 120.57,45.08 121.38,44.26 123.47,44.26 125.9,41.83 127.47,41.83 130.19,39.11 v4(130.19,38.55)
  IN3 w0.061: v5(119.92,63.63) 119.92,62.97 v4(120.04,62.84)
  BOTTOM w0.127: R282.1 88.66,63.05 96.96,63.05 97.52,63.61 97.52,64.42 98.22,65.12 101.84,65.12 R247.1 102.08,65.36 102.75,65.36 103.49,66.1 111.21,66.1 111.66,65.64 117.46,65.64 119.14,63.96 119.59,63.96 v5(119.92,63.63)
RUN_ON_P#: length 7.5
  TOP w0.127: v1(250.44,56.84) 250.82,56.46 QE1.1 251.5,54.59 QE10.2 250.85,53.95 250.85,52.59 QE11.2 250.88,51.38 RE177.2
RUN_ON_R: length 7.2
  TOP w0.127: U11.4 96.73,17.86 96.34,18.26 96.34,19.41 96.61,19.68 97.17,19.68 97.98,20.49 R250.1 98.34,21.37 R249.1 98.59,20.68 98.75,20.52 R238.1
RUNPWROK: length 281.2
  TOP w0.127: v6(198.67,58.98) 202.48,55.17 202.48,50.59 204,49.07 v1(207.49,49.07) 208.06,49.07 212.86,53.87 224.23,53.87 v2(224.9,53.2) ; v2(263.85,56.43) 264.21,56.43 UE1.G3
  IN1 w0.061: v2(224.9,53.2) 228.42,53.2 228.69,53.46 232.27,53.46 236.77,57.95 246,57.95 246.61,57.34 254.52,57.34 v2(255.71,56.15) 255.82,56.25 262.03,56.25 262.37,55.91 263.31,55.91 263.83,56.43 v2(263.85,56.43) 264.32,55.95 266.11,55.95 266.61,55.45 266.61,54.5 267.32,53.79 267.32,53.6 266.58,52.86 266.58,52.75 v4(266.46,52.63) ; v4(104.25,15.22) 103.39,14.36 97.7,14.36 v2(97.26,13.91)
  IN2 w0.061: v4(104.25,15.22) 104.74,14.73 108.91,14.73 113.48,19.3 122.51,19.3 122.98,19.77 127,19.77 128.78,19.04 132.16,19.04 133.81,17.39 144.41,17.39 147.12,14.68 152.92,14.68 153.18,14.42 178.6,14.42 183.75,19.56 211.38,19.56 214.74,22.93 219.6,22.93 237.77,41.1 250.67,41.1 253.69,44.13 255.79,44.13 256.43,44.77 260.08,44.77 260.47,44.38 263.57,44.38 263.62,44.43 265.49,44.43 267.11,46.04 267.11,48.19 268,49.09 268,51.65 267.01,52.63 v4(266.46,52.63)
  BOTTOM w0.127: LED_RUN.1 v6(198.67,58.98)
SA_B+:
  vias: v2(128.59,68.38) v2(128.59,68.08) v2(128.59,67.47) v2(128.59,67.16) v4(128.97,68.2) v4(128.97,67.53) v5(128.97,68.53) v5(128.97,67.87) v5(128.97,67.19)
SAR_ACT#: length 83.5
  TOP w0.127: v6(199.05,67.81) 199.35,67.81 199.57,67.6 223.21,67.6 229.65,61.15 v1(229.65,58.39) v2(229.65,53.71) ; v2(266.96,54.5) 266.98,54.49 UE1.K7
  IN1 w0.061: v2(229.65,53.71) 232.36,53.71 236.71,58.07 246.05,58.07 246.66,57.46 254.85,57.46 255.89,56.43 262.73,56.43 263.01,56.71 264.02,56.71 264.66,56.07 266.16,56.07 266.73,55.5 266.73,54.73 266.96,54.5 v2(266.96,54.5)
  BOTTOM w0.127: RS10.2 198.69,68.17 v6(199.05,67.81)
SAR_DPR#: length 34.8
  TOP w0.102: v2(263.79,50.83) 263.92,50.83 264.67,51.59 264.67,52.04 UE1.M4
  TOP w0.127: QN7.6 265.02,24.45 265.02,26.96 v1(263.73,28.24) 262.75,29.23 v6(262.75,29.85)
  IN1 w0.061: v2(263.79,50.83) 263.43,50.83 v4(262.26,49.66) 262.04,49.43 v2(262.04,49.33)
  IN3 w0.061: v6(262.75,29.85) 262.75,30.44 263.44,31.14 264.2,31.14 265.68,32.62 265.68,36.25 265.47,36.47 265.47,41.2 265.86,41.6 265.86,42.16 263.73,44.29 263.73,46.69 263.43,46.98 263.43,49.14 262.92,49.66 v4(262.26,49.66)
SAR_DPR_R: length 4.2
  TOP w0.127: RN3.2 263.94,25.72 263.64,25.42 v1(263.64,25.36) v2(263.64,24.65) 263.64,24.48 263.44,24.28 QN7.1
  IN1 w0.061: v4(263.24,24.73) 263.57,24.73 v2(263.64,24.65)
  IN3 w0.061: v5(263.4,25.04) 263.4,24.89 v4(263.24,24.73)
  BOTTOM w0.127: JNGFF1.25 263.65,24.78 v5(263.4,25.04)
SBIOS_TX: length 191.9
  TOP w0.127: RE96.1 231.18,72.62 230.58,72.03 230.58,69.28 234.87,64.99 236.8,64.99 237.67,64.13 237.67,63.04 235.73,61.1 v1(235.73,59.11) 235.73,50.6 238,48.33 v6(238,47.52)
  IN2 w0.061: v4(108.7,47.02) 108.94,46.78 111.24,46.78 111.92,46.11 113.99,46.11 119.15,40.95 121.05,40.95 125.06,36.94 125.06,32.73 125.72,32.07 125.72,29.37 124.89,28.55 124.89,27.28 125.5,26.68 127.07,26.68 127.42,27.02 128.84,27.02 128.89,26.97 130.62,26.97 130.86,26.73 139.97,26.73 142.53,24.16 145.06,24.16 149.32,19.9 155.11,19.9 155.36,19.65 176.41,19.65 188.48,31.71 198.46,31.71 199.22,32.48 209.27,32.48 209.99,33.19 214.92,33.19 218.18,36.45 220.13,36.45 231.9,48.22 237.3,48.22 v6(238,47.52)
  IN3 w0.061: v5(109.04,47.23) 108.91,47.11 v4(108.7,47.02)
SD_CD#: length 17.7
  TOP w0.127: UR1.30 292.49,37.86 v2(292.32,38.03)
  IN1 w0.061: v2(298.66,29.62) 296.82,29.62 295.96,30.49 293.63,30.49 293.26,30.12 292,30.12 289.93,32.18 289.93,33.79 292.32,36.18 v2(292.32,38.03)
SD_CD#_R: length 2.8
  TOP w0.127: RR12.1 299.22,28.9 v1(299.41,28.71) 299.46,28.66 JCR1.9
SD_CLK: length 2.1
  TOP w0.127: RR4.1 296.11,33.29 295.48,33.92 UR1.17
SD_CLK_R: length 5.6
  TOP w0.127: JCR1.5 300.57,32.96 300.21,32.6 300.21,32.35 299.47,31.61 298.27,31.61 v1(298.25,31.63) 297.57,32.3 CR8.1 RR4.2
SD_CMD: length 1.9
  TOP w0.127: UR1.19 296.83,34.72 RR5.1
SD_CMD_R: length 5.1
  TOP w0.127: JCR1.3 300.43,34.76 300.2,34.52 300.02,34.52 299.89,34.65 299.89,34.98 299.76,35.1 v1(299.6,35.1) 299.52,35.1 299.38,34.96 299.38,34.81 299.25,34.68 299.07,34.68 298.72,35.03 298.24,35.03 298.05,34.84 298.05,34.53 297.92,34.4 297.74,34.4 RR5.2
SD_D0: length 1.5
  TOP w0.127: UR1.16 294.49,32.9 295.12,32.26 RR3.1
SD_D0_R: length 7.9
  TOP w0.127: JCR1.7 300.28,31.16 299.95,30.83 299.11,30.83 298.78,30.5 298.38,30.5 298.23,30.65 298.23,30.76 298.11,30.88 297.85,30.88 297.72,30.76 297.72,30.65 297.58,30.5 297.24,30.5 297.18,30.56 296.81,30.56 296.75,30.5 295.96,30.5 295.8,30.66 v1(295.39,30.66) 295.08,30.66 294.91,30.84 294.91,31.22 RR3.2
SD_D1: length 1.5
  TOP w0.127: UR1.15 294.09,32.88 294.61,32.36 294.61,32.15 RR2.1
SD_D1_R: length 7.8
  TOP w0.127: JCR1.8 300.26,30.26 299.94,30.58 299.22,30.58 298.86,30.22 v1(297.04,30.22) 295.88,30.22 295.78,30.32 295.07,30.32 294.65,30.73 294.65,31.27 RR2.2
SD_D2: length 2.1
  TOP w0.127: RR7.1 296.93,35.83 296.52,35.43 295.65,35.43 295.55,35.52 UR1.21
SD_D2_R: length 5.2
  TOP w0.127: RR7.2 298.34,36.6 299.33,36.6 v1(299.43,36.51) 299.43,35.95 299.56,35.81 299.87,35.81 300.02,35.96 300.02,36.41 300.17,36.56 JCR1.1
SD_D3: length 1.9
  TOP w0.127: RR6.1 296.86,35.07 v1(296.23,35.07) 295.63,35.07 295.58,35.12 UR1.20
SD_D3_R: length 5.3
  TOP w0.127: RR6.2 297.7,35.07 297.91,35.07 298.2,35.36 298.32,35.36 298.42,35.46 v1(298.42,35.65) 298.42,36.15 298.55,36.29 298.82,36.29 298.96,36.15 298.96,35.63 299.11,35.48 300.08,35.48 300.26,35.66 JCR1.2
SD_LN0_M: length 26.2
  TOP w0.086: JCR1.19 314.31,32.38 313.96,32.73 313.79,32.73 v6(313.61,32.55) ; UR1.25 294.49,37.8 294.39,37.9 294.39,38.14 294.17,38.37 294.17,38.74 294.29,38.86 294.38,38.86 294.47,38.77 294.47,38.53 294.57,38.44 294.74,38.44 v6(294.76,38.46)
  IN1 w0.061: v6(294.76,38.46) 294.98,38.68 297.23,38.68 298.16,39.61 305.5,39.61 312.34,32.77 313.39,32.77 v6(313.61,32.55)
SD_LN0_P: length 26.2
  TOP w0.086: v6(294.76,39.07) 294.21,39.07 293.96,38.82 293.96,38.28 294.18,38.06 294.18,37.87 294.09,37.77 UR1.26 ; JCR1.18 314.31,33.29 313.96,32.94 313.82,32.94 v6(313.61,33.15)
  IN1 w0.061: v6(313.61,33.15) 313.44,32.99 312.42,32.99 305.59,39.82 298.07,39.82 297.14,38.89 294.94,38.89 v6(294.76,39.07)
SD_LN1_M: length 22.7
  TOP w0.086: JCR1.21 314.29,30.56 313.94,30.21 313.82,30.21 v6(313.63,30.4) ; v6(296.23,36.42) 296.03,36.21 295.75,36.21 295.63,36.32 UR1.23
  IN1 w0.061: v6(296.23,36.42) 296.42,36.23 306.94,36.23 312.93,30.24 313.46,30.24 v6(313.63,30.4)
SD_LN1_P: length 22.7
  TOP w0.086: UR1.22 295.62,35.92 295.69,36 296.06,36 v6(296.24,35.83) ; v6(313.62,29.81) 313.81,30 313.96,30 314.31,29.65 JCR1.22
  IN1 w0.061: v6(296.24,35.83) 296.42,36.02 306.85,36.02 312.84,30.02 313.42,30.02 v6(313.62,29.81)
SD_RCOMP: length 7.8
  IN3 w0.305: v5(106.98,32.39) 106.68,32.7 106.68,33.88 v5(106.2,34.36)
  BOTTOM w0.305: v5(106.98,32.39) 107.53,31.84 107.53,31.41 107.73,31.21 107.73,30.21 108.37,29.57 RC116.1 ; v5(106.2,34.36) 106.2,34.37 106.74,34.91 UCPU1.CK33 107.34,34.91 UCPU1.CM34
SD_REG2:
  vias: v1(296.34,37.78)
SENSOR_DET#: length 338.9
  TOP w0.127: RE532.2 v2(273.84,48.88) ; v2(249.34,44.02) v3(249.97,43.4)
  IN1 w0.061: v2(273.84,48.88) 273.84,46.79 271.13,44.09 260.34,44.09 259.87,44.57 253.75,44.57 253.58,44.74 249.36,44.74 249.2,44.58 249.2,44.16 v2(249.34,44.02) 249.34,43.33 249.98,42.69 v4(250.27,42.69)
  IN2 w0.061: v4(41.39,77.49) 41.44,77.54 42.75,77.54 46.37,73.92 46.37,72.89 45.36,71.89 45.19,71.89 41.95,68.64 41.95,66.98 40.01,65.05 40.01,63.37 39.25,62.61 39.25,59.71 37.73,58.2 37.73,54.43 37.15,53.84 37.15,50.87 37.53,50.48 37.53,50.02 37.2,49.69 37.2,49.21 37.12,49.13 37.12,45.79 33.92,42.59 33.92,40.78 32.45,39.31 32.45,37.17 29.81,34.53 29.81,29.32 29.52,29.02 29.52,24.64 33.82,20.33 35.5,20.33 35.98,20.81 37.96,20.81 38.29,20.47 40.6,20.47 41.09,19.99 41.09,19.25 41.69,18.65 46.88,18.65 49.37,16.15 51.43,16.15 51.44,16.15 52.7,16.15 52.81,16.26 91.16,16.26 91.66,15.76 97.09,15.76 97.54,16.21 99.97,16.21 100.69,16.93 104.31,16.93 105.11,16.13 106.07,16.13 107.11,17.18 110.09,17.18 113.53,20.61 122.3,20.61 122.88,21.2 126.88,21.2 127.82,20.26 128.93,19.81 132.51,19.81 132.99,20.29 139.92,20.29 140.4,19.81 143.29,19.81 147.52,15.57 153.29,15.57 153.55,15.31 178.23,15.31 183.38,20.45 211,20.45 214.38,23.83 219.24,23.83 237.44,42.03 249.6,42.03 v4(250.27,42.69)
  IN3 w0.061: v5(41.22,77.18) 41.22,77.32 v4(41.39,77.49)
  BOTTOM w0.127: JEDP1.24 v5(41.22,77.18)
