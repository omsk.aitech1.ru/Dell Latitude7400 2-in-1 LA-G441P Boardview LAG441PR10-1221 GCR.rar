# Allegro board LAG441PR10-1221_GCR.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EDP_HPD: length 104.8
  TOP w0.127: v2(88.16,60.36) v1(87.49,60.36)
  IN1 w0.061: v4(97.07,59.4) 96.8,59.67 96.8,59.67 96.62,59.84 96.62,60.1 96.24,60.48 91.99,60.48 91.31,59.81 88.71,59.81 v2(88.16,60.36) 88.06,60.45 v4(87.74,60.45) ; v4(35.71,75.37) 35.29,75.79 35.29,76.13 v2(35.47,76.31)
  IN2 w0.061: v4(97.07,59.4) 97.77,59.4 98.03,59.66 101.87,59.66 102.18,59.36 102.77,59.36 103.06,59.66 105.71,59.66 105.88,59.48 110.07,59.48 110.56,58.99 110.56,57.74 106.49,53.67 106.49,52.87 107.88,51.48 108.63,51.48 v4(108.82,51.67)
  IN3 w0.061: v4(108.82,51.67) 108.65,51.85 v5(108.38,51.85) ; v4(87.74,60.45) 87.74,61.12 87.33,61.53 84.33,61.53 80.05,65.8 78.71,65.8 76.66,67.85 76.6,67.85 76.6,67.85 74.49,67.85 69.15,73.18 63.53,73.18 62.11,71.76 59.51,71.76 59.33,71.58 57.01,71.58 56.7,71.28 v5(52.88,71.28) ; v4(35.71,75.37) 35.58,75.24 35.58,71.84 v5(36.15,71.28)
  BOTTOM w0.127: v5(36.15,71.28) v5(52.88,71.28) ; RC2.1 111.29,52.29 110.34,51.34 108.35,51.34 UCPU1.CM7 v5(108.38,51.85)
EDP_HPD_EC: length 346
  TOP w0.102: UE1.J10 v2(269.83,54.8)
  IN1 w0.061: v2(269.83,54.8) 270.13,54.8 v4(270.18,54.85) ; v4(35.2,75.37) 34.9,75.68 v2(34.9,76.31)
  IN2 w0.061: v4(35.2,75.37) 35.2,75.05 36.07,74.19 36.22,74.19 38.43,71.98 38.43,66.97 37.79,66.33 37.79,64.82 36.43,63.46 36.43,63.06 36.15,62.79 36.15,55.28 35.3,54.43 35.3,53.84 35.03,53.57 35.03,49.47 34.2,48.63 34.2,45.59 32.05,43.45 32.05,41.6 30.04,39.6 30.04,38.35 28.36,36.67 28.36,36.04 27.97,35.65 27.97,30.11 27.68,29.82 27.68,25.5 25.11,22.94 24.55,22.94 24.33,22.94 23.89,22.49 23.89,19.42 27.56,15.75 39.94,15.75 42.43,13.26 44.1,13.26 44.26,13.42 48.24,13.42 48.5,13.16 52.53,13.16 53.03,13.65 53.64,13.65 53.79,13.8 56.76,13.8 57.84,12.73 96.93,12.73 97.39,13.18 101.08,13.18 101.28,13.39 103.43,13.39 103.73,13.08 109.6,13.08 114.17,17.65 123.19,17.65 123.67,18.12 126.67,18.12 128.45,17.39 131.47,17.39 132.96,15.91 132.96,13.71 133.65,13.02 152.24,13.02 152.5,12.77 179.35,12.77 182.89,16.31 201.16,16.31 202.76,17.91 212.07,17.91 212.38,18.23 217.42,18.23 238.11,38.93 255.47,38.93 257.26,40.72 262.45,40.72 263.69,41.96 264.54,41.96 265.23,42.65 266.35,42.65 267.44,43.74 268.69,43.74 272.16,47.21 272.16,53.65 270.97,54.85 v4(270.18,54.85)
EDP_HPD_R: length 3
  TOP w0.127: RV71.2 v2(35.47,76.89)
  IN1 w0.061: v2(35.47,76.89) 35.34,77.02 v4(35.34,77.69)
  IN3 w0.061: v4(35.34,77.69) 35.34,77.31 v5(35.52,77.13)
  BOTTOM w0.127: v5(35.52,77.13) 35.7,77.13 36.03,77.46 JEDP1.11
EDP_RCOMP: length 0.8
  IN1 w0.127: v4(83.85,52.31) 83.63,52.2 83.51,52.14 v2(83.48,52.05)
  IN3 w0.127: v4(83.85,52.31) 83.85,52.2 v5(83.67,52.02)
EDP_TEST_SCL: length 2.1
  TOP w0.127: v5(39.93,77.13) 39.93,77.49 TV1.1
  IN1 w0.061: v5(39.93,77.13) v4(39.93,77.48)
  IN3 w0.061: v5(39.93,77.13) v4(39.93,77.48)
  BOTTOM w0.127: JEDP1.21 40.03,77.23 v5(39.93,77.13)
EDP_TEST_SDA: length 2.7
  TOP w0.127: TV2.1 40.93,77.65 v5(40.4,77.12)
  IN1 w0.061: v5(40.4,77.12) 40.4,77.39 v4(40.47,77.46)
  IN3 w0.061: v5(40.4,77.12) 40.4,77.39 v4(40.47,77.46)
  BOTTOM w0.127: JEDP1.22 40.43,77.15 v5(40.4,77.12)
EDP_TXN0: length 53.8
  IN1 w0.074: v2(44.72,73.48) 44.53,73.28 44.53,73.16 v4(44.68,73.01)
  IN3 w0.074: v4(44.68,73.01) 44.77,72.92 44.77,72.84 44.66,72.74 44.49,72.74 44.37,72.62 44.37,72.12 44.59,71.9 48.81,71.9 51.38,69.33 60.92,69.33 61.24,69.66 62.95,69.66 64.39,71.09 68.29,71.09 73.62,65.77 75.77,65.77 81.66,59.88 81.66,58.29 81.74,58.21 81.85,58.21 v5(81.94,58.3)
  BOTTOM w0.076: UCPU1.AG4 80.59,53.43 80.27,53.74 80.27,54.19 80.33,54.33 80.33,54.43 80.29,54.59 80.29,54.89 80.33,55.02 80.32,55.19 80.28,55.31 80.28,55.59 80.97,56.28 80.97,57.94 81.25,58.21 81.85,58.21 v5(81.94,58.3)
EDP_TXN0_R: length 8
  TOP w0.112: CV5.2 44.52,74.26 44.52,74.49 44.26,74.75 v7(44.26,75.35) 44.26,76.38 v2(44.49,76.61)
  IN1 w0.074: v4(46.48,78.38) 46.27,78.17 46.27,77.76 45.96,77.45 45.44,77.45 45.15,77.16 44.46,77.16 44.27,76.97 44.27,76.83 v2(44.49,76.61)
  IN3 w0.074: v4(46.48,78.38) 46.3,78.21 46.3,77.42 v5(46.41,77.31)
  BOTTOM w0.112: v5(46.41,77.31) 46.43,77.32 JEDP1.37
EDP_TXN1: length 51
  IN1 w0.074: v4(45.99,73.13) 45.93,73.2 45.93,73.43 v2(46.01,73.51)
  IN3 w0.074: v5(82.81,58.1) 82.71,58.2 82.71,59.5 75.97,66.25 73.81,66.25 68.49,71.57 64.19,71.57 62.77,70.15 61.04,70.15 60.7,69.81 51.58,69.81 48.41,72.98 46.87,72.98 46.48,72.59 45.95,72.59 45.82,72.72 45.82,72.96 v4(45.99,73.13)
  BOTTOM w0.076: v5(82.81,58.1) 82.69,57.97 82.69,57.81 82.56,57.68 82.56,56.66 82.15,56.25 81.8,56.25 81.15,55.6 81.15,55.06 80.96,54.87 80.86,54.87 UCPU1.AG2
EDP_TXN1_R: length 7.6
  TOP w0.112: CV7.2 45.81,74.29 45.81,74.58 45.73,74.66 v7(45.73,75.3) 45.73,76.46 v2(45.88,76.61)
  IN1 w0.074: v4(47.72,78.4) 47.56,78.24 47.56,77.95 47.11,77.5 46.9,77.5 46.35,76.96 45.79,76.96 45.69,76.86 45.69,76.79 v2(45.88,76.61)
  IN3 w0.074: v5(47.62,77.31) 47.53,77.4 47.53,78.21 v4(47.72,78.4)
  BOTTOM w0.112: JEDP1.40 v5(47.62,77.31)
EDP_TXP0: length 53.8
  IN1 w0.074: v2(44.14,73.48) 44.32,73.29 44.32,73.18 v4(44.17,73.02)
  IN3 w0.074: v4(44.17,73.02) 44.17,72.04 44.51,71.7 48.73,71.7 51.3,69.13 61,69.13 61.33,69.45 63.03,69.45 64.47,70.89 68.21,70.89 73.53,65.57 75.69,65.57 81.46,59.8 81.46,58.2 81.65,58.01 81.82,58.01 v5(81.93,57.91)
  BOTTOM w0.076: v5(81.93,57.91) 81.79,58.04 81.32,58.04 81.14,57.87 81.14,56.22 80.44,55.52 80.44,55.33 80.48,55.22 80.49,55.01 80.49,54.99 80.45,54.87 80.45,54.61 80.5,54.46 80.5,54.29 80.44,54.16 80.44,53.81 80.54,53.71 80.83,53.71 80.91,53.79 80.91,53.88 UCPU1.AG3
EDP_TXP0_R: length 8
  TOP w0.112: CV6.2 44.31,74.23 44.31,74.41 44.06,74.67 44.06,75.03 44.02,75.06 44.02,75.63 44.06,75.66 44.06,76.5 43.94,76.61 v2(43.85,76.61)
  IN1 w0.074: v2(43.85,76.61) 44.07,76.83 44.07,77.05 44.38,77.36 45.07,77.36 45.36,77.65 45.88,77.65 46.06,77.84 46.06,78.26 v4(45.94,78.38)
  IN3 w0.074: v4(45.94,78.38) 46.1,78.23 46.1,77.39 v5(46.01,77.31)
  BOTTOM w0.112: v5(46.01,77.31) 46.03,77.32 JEDP1.36
EDP_TXP1: length 51
  IN1 w0.074: v2(45.44,73.51) 45.59,73.36 45.59,73.25 v4(45.47,73.13)
  IN3 w0.074: v4(45.47,73.13) 45.62,72.98 45.62,72.63 45.87,72.39 46.56,72.39 46.95,72.78 48.33,72.78 51.5,69.61 60.79,69.61 61.13,69.95 62.85,69.95 64.27,71.37 68.41,71.37 73.73,66.05 75.88,66.05 82.51,59.42 82.51,58.21 v5(82.41,58.1)
  BOTTOM w0.076: UCPU1.AG1 80.71,55.12 80.79,55.04 80.89,55.04 80.98,55.13 80.98,55.67 81.74,56.42 82.08,56.42 82.4,56.73 82.4,57.75 82.52,57.88 82.52,57.98 v5(82.41,58.1)
EDP_TXP1_R: length 7.6
  TOP w0.112: v2(45.31,76.6) 45.53,76.38 45.53,75.62 45.5,75.58 45.5,75.01 45.53,74.98 45.53,74.58 45.61,74.49 45.61,74.27 CV8.2
  IN1 w0.074: v4(47.21,78.4) 47.36,78.25 47.36,78.04 47.03,77.7 46.82,77.7 46.27,77.16 45.7,77.16 45.49,76.94 45.49,76.85 45.49,76.79 v2(45.31,76.6)
  IN3 w0.074: v4(47.21,78.4) 47.33,78.28 47.33,77.41 v5(47.23,77.31)
  BOTTOM w0.112: v5(47.23,77.31) 47.23,77.31 JEDP1.39
EDRAM_OPIO_RCOMP: length 0.7
  IN1 w0.305: v2(70.73,52.67) v4(70.98,52.95)
  IN3 w0.305: v4(70.98,52.95) 70.75,52.72 v5(70.75,52.68)
EMMC_RCOMP: length 0.8
  IN1 w0.305: v2(107.67,46.28) 107.63,46.28 v4(107.32,46.59)
  IN3 w0.305: v5(107.09,46.35) v4(107.32,46.59)
EN_1.0VA: length 2.8
  BOTTOM w0.254: RC574.2 120.28,51.38 CC253.1 119.73,52.93 120.01,53.21 PU800.11
EN_1.8V_PRIM: length 3.8
  BOTTOM w0.127: PU500.11 115.21,24.63 115.33,24.76 115.92,24.76 116.33,25.16 116.33,25.89 116.14,26.08 CC254.1 116.7,26.61 RC575.2
EN_INVPWR: length 351.8
  TOP w0.127: 263.44,60.41 262.99,60.85 262.44,60.85 261.05,62.25 RE153.1 260.43,62.43 260.26,62.59 259.31,62.59 259.07,62.83 258.61,62.83 257.97,63.47 v2(257.97,63.62) ; v2(32.7,67.65) 32.87,67.48 32.87,67.16 32.99,67.04 QV11.5 ; v6(250.73,63.47) v1(249.82,63.47)
  IN1 w0.061: v6(250.73,63.47) 250.77,63.47 251.11,63.14 255.27,63.14 256.07,63.93 257.66,63.93 v2(257.97,63.62) ; v2(32.7,67.65) 32.67,67.68 v4(32.29,67.68)
  IN2 w0.061: v4(32.29,67.68) 32.29,67.68 31.39,67.68 31.09,67.38 31.09,66.16 30.29,65.36 30.29,64.96 30.48,64.76 30.48,64.3 29.88,63.69 29.88,59.79 28.09,57.99 28.09,46.42 28.48,46.03 28.48,45.55 26.32,43.4 22.62,43.4 22.02,42.8 22,42.8 21.21,42 21.21,41.79 21.21,41.69 21.21,41.02 21.77,40.46 21.77,35.72 19.33,33.28 19.33,32.34 17.76,30.77 17.76,24.87 18.01,24.62 18.01,24.61 18.36,24.26 18.36,20.41 20.76,18.01 20.76,16.73 25.52,11.97 26.95,11.97 27.77,12.79 35.11,12.79 37.81,10.1 53.01,10.1 53.78,10.87 54.99,10.87 55.56,10.29 119.4,10.29 120.89,11.78 120.89,13.71 124.28,17.1 126.83,17.1 128.92,16.24 130.66,14.51 130.66,13.04 130.74,12.96 130.74,12.95 130.92,12.76 131.44,12.76 132.32,11.88 151.77,11.88 152.02,11.63 184.43,11.63 185.72,12.92 186.73,12.92 186.73,12.92 201.43,12.92 203.47,14.97 216.29,14.97 235.87,34.55 239.42,34.55 v6(240.45,35.58)
  BOTTOM w0.127: v6(240.45,35.58) 240.46,35.59 240.46,47.49 250.85,57.88 250.85,63.35 v6(250.73,63.47)
EN_INVPWR_R: length 4.2
  TOP w0.127: QV10.3 34.54,69.54 34.62,69.46 RV80.1 35.18,69.61 CV16.2 35.47,70.17 35.76,70.47 35.76,71.67 RV81.2
EN_PD_HV1: length 64.9
  TOP w0.127: v2(28.62,45.89) 27.95,45.22 27.95,44.33 27.41,43.78 27.41,42.5 27.01,42.11 v2(26.96,42.11) 26.3,41.45 PTB2.1 PRB36.1 ; PR157.1 15.68,47.39 v2(16.44,46.63) ; PR1432.1 8.6,42.69 v6(8.97,42.69)
  IN1 w0.061: v2(26.96,42.11) 26.73,41.88 24.76,41.88 23.51,40.62 21.02,40.62 20.92,40.72 20.92,41.09 20.62,41.4 16.69,41.4 16.24,41.84 16.24,42.35 v4(16.61,42.73) 16.19,43.15 16.19,43.74 16.5,44.05 16.5,45.33 16.63,45.46 16.63,45.91 16.44,46.1 v2(16.44,46.63) ; v4(28.55,46.41) 28.57,46.4 28.57,45.94 v2(28.62,45.89) ; v4(31.18,68.58) 31.18,68.76 31.01,68.93 30.44,68.93 30.35,68.83 29.93,68.83 29.28,69.48 28.68,69.48 28.49,69.67 28.12,69.67 v2(27.98,69.53)
  IN2 w0.061: v4(30.62,65.19) 30.61,65.18 30.61,64.24 30.01,63.64 30.01,59.74 28.21,57.94 28.21,46.75 v4(28.55,46.41)
  IN3 w0.061: v4(16.61,42.73) 15.35,42.73 13.07,40.44 11.69,40.44 9.45,42.69 v6(8.97,42.69) ; v4(31.18,68.58) 31.18,68.04 30.71,67.57 30.71,66.91 30.26,66.46 30.26,65.55 v4(30.62,65.19)
EN_PD_HV2: length 80.4
  TOP w0.127: v2(10.88,40.51) 11.64,40.51 13.33,38.82 15.49,38.82 16.23,38.08 16.41,38.08 16.7,37.79 17.52,37.79 17.91,38.18 19.14,38.18 20.24,39.29 22.59,39.29 PR199.2 23.06,38.82 23.06,37.37 23.28,37.15 PRB37.1 v1(23.6,36.12) ; PR1431.1 18.87,64.45 18.87,65.36 PR120.1 18.01,66.69 18.45,67.14 18.45,68.52 18.79,68.86 21.72,68.86 v2(22.05,68.54) ; RT120.2 28.11,76.7 28.32,76.49 28.32,75.4 v2(28.28,75.35)
  IN1 w0.061: v2(22.05,68.54) v4(22.05,68.05) 22.35,68.36 22.35,68.66 22.45,68.75 22.99,68.75 23.13,68.61 23.37,68.61 23.75,68.99 24.31,68.99 24.52,69.21 24.52,69.64 25.11,70.23 25.11,70.5 25.3,70.7 25.52,70.7 25.63,70.59 25.89,70.59 26.07,70.77 26.07,71.04 25.79,71.31 25.79,72.98 26.14,73.33 27.19,73.33 27.8,73.94 27.8,74.87 v2(28.28,75.35) ; v4(8.97,41.93) 9.59,41.31 10.09,41.31 v2(10.88,40.51)
  IN2 w0.061: v4(22.05,68.05) 22.11,67.99 22.11,67.41 21.08,66.39 21.08,63.16 20.28,62.36 17.34,62.36 16.89,61.91 16.89,57.07 16.8,56.98 16.8,48.3 15.33,46.83 15.33,45.31 12.92,42.89 9.71,42.89 9.54,43.07 8.5,43.07 8.25,42.83 8.25,42.12 8.44,41.93 v4(8.97,41.93)
EN_PRIM_CORE: length 2.1
  BOTTOM w0.254: PU1401.5 126.35,44.72 126.6,44.48 CC255.1 RC576.2
EN_VCCIO: length 7.3
  TOP w0.127: v1(98.73,22.88) 99.17,22.43 C88.1 R249.2 99.45,21.11 99.62,20.95 v2(99.62,19.64)
  IN1 w0.061: v2(99.62,19.64) 99.69,19.71 102.34,19.71 v4(102.55,19.5)
  IN3 w0.061: v5(102.55,19.02) v4(102.55,19.5)
ENABLE_DS#: length 4.2
  TOP w0.127: UE1.L2 263.12,53.21 262.69,52.77 262.41,52.77 261.15,51.52 RE163.2 RE166.1
ENVDD: length 4.4
  TOP w0.127: UV1.3 40.79,69.82 41.26,69.35 42.33,69.35 42.53,69.14 RV3.1 RV92.2
ENVDD_PCH: length 238.4
  TOP w0.127: DV1.2 45.94,69.75 v2(46.86,68.83) ; v2(119.96,16.78) 119.96,16.87 120.45,17.36 120.45,18.58 v1(120.91,19.05) 122.92,21.06 122.92,23.89 126.2,27.17 v2(126.2,27.25)
  IN1 w0.061: v2(46.86,68.83) 46.49,68.83 v4(46.48,68.84) ; v4(126.28,28.29) 126.2,28.22 v2(126.2,27.25) ; v2(105.6,49.29) 105.75,49.14 105.75,48.99 105.9,48.84 v4(105.92,48.84) ; v4(119.73,16.3) 119.96,16.53 v2(119.96,16.78)
  IN2 w0.061: v4(32.43,72.17) 31.98,71.71 31.98,68.79 32.86,67.91 32.86,67.36 31.67,66.17 31.67,65.22 31.18,64.74 31.18,64.1 30.51,63.43 30.51,59.52 28.86,57.87 28.86,47.3 29.24,46.91 29.24,45.57 25.96,42.3 22.22,42.3 21.72,41.79 21.72,41.23 22.3,40.65 22.3,35.53 19.83,33.07 19.83,32.13 18.27,30.56 18.27,25.08 18.52,24.83 18.52,24.82 19.04,24.3 19.04,20.45 21.27,18.22 21.27,16.94 23.39,14.83 25.18,14.83 26.83,13.18 35.27,13.18 37.96,10.48 48.26,10.48 48.85,11.08 53.44,11.08 53.61,11.25 55.14,11.25 55.72,10.67 110.16,10.67 110.27,10.67 112.18,10.67 116.58,15.07 118.96,15.07 119.73,15.84 v4(119.73,16.3) ; v4(126.28,28.29) 126.76,28.77 126.76,33.78 126.41,34.13 126.41,36.41 121.29,41.53 119.39,41.53 114.23,46.69 112.16,46.69 111.46,47.38 110.16,47.38 109.74,47.81 108.03,47.81 107.63,48.2 106.6,48.2 105.97,48.84 v4(105.92,48.84)
  IN3 w0.061: v5(105.42,49.24) 105.52,49.24 v4(105.92,48.84) ; v4(32.43,72.17) 33.55,72.17 36.19,69.53 v5(36.51,69.53) ; v4(46.48,68.84) 46.06,68.84 v5(46,68.9)
  BOTTOM w0.127: v5(105.42,49.24) 105.33,49.24 UCPU1.CG11 ; v5(46,68.9) 37.14,68.9 v5(36.51,69.53)
EOPIO_RCOMP: length 0.7
  IN1 w0.305: v2(71.67,52.67) v4(71.89,52.93)
  IN3 w0.305: v5(71.67,52.68) 71.89,52.9 v4(71.89,52.93)
ESPI_ALERT#: length 234.4
  TOP w0.102: UE1.H7 267.61,55.43 267.61,55.25 v2(267.85,55.01)
  TOP w0.127: v2(183.45,12.38) 184.71,12.38 185.89,13.56 197.31,13.56 198.45,14.7 208.72,14.7 210.27,13.15 217.69,13.15 219.73,15.19 219.73,19.29 221.64,21.2 221.64,23.21 222.52,24.09 222.52,26.88 233.31,37.67 233.31,60.2 v1(235.16,62.06) v6(236.85,63.74) ; RC24.2 101.05,39.85 101.05,39.14 v6(100.58,38.67)
  IN1 w0.061: v2(267.85,55.01) 267.78,54.93 267.78,54.45 267.55,54.22 267.55,53.38 267.02,52.85 267.02,52.68 266.62,52.28 266.17,52.28 265.94,52.05 v4(265.83,52.05) ; v2(183.45,12.38) 183.39,12.31 v4(183.02,12.31) ; v6(100.58,38.67) 100.71,38.8 101.75,38.8 102.32,38.23 102.32,37.89 102.68,37.53 102.68,36.62 102.6,36.54 102.6,36.16 102.75,36.01 102.75,34.51 103.72,33.55 103.72,32.21 104.26,31.67 104.55,31.67 105.39,30.83 106.13,30.83 106.44,30.52 106.44,30.07 107.34,29.17 110.28,29.17 111.53,27.92 112.13,27.92 115.32,24.73 120.94,24.73 v4(121.13,24.92)
  IN3 w0.061: v4(265.83,52.05) 265.83,52.44 265.09,53.18 263.66,53.18 262.04,54.8 260.82,54.8 260.51,55.11 259.88,55.11 259.63,54.86 258.1,54.86 257.82,55.14 253.78,55.14 245.05,63.87 236.98,63.87 v6(236.85,63.74) ; v5(182.71,12.07) 182.95,12.31 v4(183.02,12.31) ; v5(142.35,11.86) 141.67,12.54 138.89,12.54 136.1,15.33 134.75,15.33 133.43,16.65 132.55,16.65 131.61,17.6 130.88,17.6 129.07,19.4 127.42,19.4 126.32,20.5 126.32,21.85 123.64,24.53 121.51,24.53 v4(121.13,24.92)
  BOTTOM w0.127: v5(142.35,11.86) 142.86,11.35 181.82,11.35 182.54,12.07 v5(182.71,12.07) ; UCPU1.BV28 100.25,38.34 v6(100.58,38.67)
ESPI_CLK: length 5.1
  TOP w0.127: v2(100.67,34.6) 100.67,34.28 v1(100.99,33.97) 102.42,32.53 102.42,31.84 RC19.1
  IN1 w0.061: v2(100.67,34.6) 100.67,35.12 100.58,35.21 v4(100.44,35.21)
  IN3 w0.076: v4(100.44,35.21) 100.44,35.42 100.13,35.73 v5(100.13,35.74)
ESPI_CLK_5105: length 217.8
  TOP w0.127: RE180.1 257.4,58.2 256.87,57.66 v2(256.87,57.37) ; RC19.2 102.36,31.07 102.36,30.59 v2(102.31,30.54) ; UE1.G7 v2(266.97,56.71)
  IN1 w0.061: v2(266.97,56.71) 266.76,56.91 265.04,56.91 264.65,57.3 262.95,57.3 262.88,57.37 v2(256.87,57.37) 256.4,57.37 255.35,58.43 250.33,58.43 246.86,61.89 234.19,61.89 232.24,63.83 221.63,63.83 v6(220.8,64.66) ; v4(122.29,23.73) 122.29,23.89 121.82,24.36 115.17,24.36 111.98,27.55 111.38,27.55 110.13,28.8 107.19,28.8 106.67,29.32 106.31,29.32 104.53,31.09 103.86,31.09 103.3,30.54 v2(102.31,30.54)
  IN3 w0.061: v5(195.98,28.96) 196.23,29.22 197.07,29.22 197.84,29.5 198.28,29.81 200.26,31.45 201.31,31.96 205,31.96 208.48,35.44 208.48,37.64 210.44,39.6 210.44,41.93 212.83,44.32 212.83,56.69 v6(220.8,64.66) ; v5(132.91,15.78) 132.71,15.98 132.29,15.98 131.34,16.94 130.61,16.94 128.8,18.75 127.14,18.75 125.67,20.22 125.67,21.58 123.51,23.73 v4(122.29,23.73)
  BOTTOM w0.127: v5(132.91,15.78) 132.91,15.43 133.03,15.31 134.76,15.31 135.19,15.74 136.92,15.74 137.08,15.58 138.46,15.58 139.06,16.18 176.21,16.18 v1(185.73,25.7) 186.92,26.89 190.44,26.89 192.51,28.96 v5(195.98,28.96) ; JESPI1.10 224.63,68.49 v6(220.8,64.66)
ESPI_CS#: length 226.5
  TOP w0.102: UE1.H6 266.64,55.94 v2(266.67,55.97)
  TOP w0.127: v2(130.68,23.01) 131.04,23.01 131.52,23.49 134.82,23.49 138.4,19.91 138.91,19.91 139.44,19.38 152.63,15.28 179.96,15.28 183.23,18.56 194.24,18.56 196.73,21.06 196.73,22.38 202.11,27.76 205.73,27.76 v1(209.56,31.59) 212.2,34.23 212.2,37.64 214.16,39.6 214.16,41.12 220.57,47.53 220.57,50.67 v6(219.71,51.53)
  IN1 w0.061: v4(103.64,38.78) 103.8,38.63 104.94,38.63 106.41,37.15 106.41,36.03 106.96,35.49 107.9,35.49 109.16,34.23 109.16,33.39 112.13,30.42 112.29,30.42 113.66,29.04 114.71,29.04 116.31,27.44 117.1,27.44 117.32,27.22 119.51,27.22 119.67,27.38 121.18,27.38 121.49,27.07 123.93,27.07 125.28,25.72 125.28,24.78 127.1,22.97 130.64,22.97 v2(130.68,23.01) ; v2(266.67,55.97) 266.67,55.97 266.28,56.36 264.67,56.36 264.12,56.91 262.8,56.91 262.61,56.72 256.13,56.72 255.08,57.77 246.76,57.77 246.17,58.36 236.59,58.36 232.38,54.15 222.33,54.15 v6(219.71,51.53)
  IN3 w0.061: v4(103.64,38.78) 103.1,38.23 102.07,38.23 v5(101.96,38.34)
  BOTTOM w0.127: v6(219.71,51.53) 218.81,52.43 218.81,61.27 226.13,68.59 JESPI1.7
ESPI_IO0: length 227.2
  TOP w0.102: UE1.K5 265.83,54 v2(265.83,53.99)
  TOP w0.127: v2(130.35,24.5) 130.83,24.99 135.34,24.99 138.99,21.33 139.5,21.33 140.18,20.65 152.88,16.71 179.34,16.71 182.64,20 193.64,20 195.21,21.57 195.21,22.87 201.52,29.18 205.11,29.18 210.43,34.49 v1(210.43,37.64) 210.43,39.42 218.43,47.42 218.43,50.29 v6(218.81,50.67)
  IN1 w0.061: v2(130.35,24.5) 129.42,24.5 128.15,25.78 128.15,26.43 127.54,27.04 127.54,27.52 126.63,28.43 126.63,28.67 126.3,29.01 123.2,29.01 122.57,29.63 119,29.63 118.66,29.29 116.46,29.29 115.56,30.2 114.15,30.2 112.77,31.58 112.61,31.58 110.32,33.86 110.32,35.64 108.2,37.76 108.2,38.19 107.7,38.69 106.64,38.69 105.61,39.72 104.73,39.72 104.27,40.19 103.12,40.19 v2(102.87,40.45) ; v2(265.83,53.99) 265.55,54.27 262.67,54.27 262.27,53.87 259.72,53.87 259.51,54.08 258.31,54.08 256.9,55.49 254.57,55.49 254.27,55.79 248.22,55.79 246.52,54.09 244.46,54.09 243.27,52.91 221.99,52.91 220.17,51.09 219.23,51.09 v6(218.81,50.67)
  BOTTOM w0.127: v6(218.81,50.67) 218.81,49.43 219.05,49.19 220.57,49.19 221.63,50.25 221.63,52.57 220.57,53.63 220.57,60.41 228.13,67.96 JESPI1.3
ESPI_IO0_R: length 2.6
  TOP w0.127: v6(102.39,38.7) 102.38,38.71 102.91,39.23 RC366.1
  BOTTOM w0.127: v6(102.39,38.7) 102.39,38.13 UCPU1.CA29
ESPI_IO1: length 222
  TOP w0.102: v2(264.63,53.32) 264.68,53.27 264.97,53.27 UE1.L4
  TOP w0.127: v2(130.35,24.12) 130.57,24.12 131.05,24.61 135.21,24.61 138.85,20.97 139.35,20.97 140.01,20.32 152.8,16.35 179.52,16.35 182.79,19.63 193.8,19.63 195.59,21.42 195.59,22.75 201.67,28.82 205.28,28.82 v1(210.11,33.65) 211.14,34.67 211.14,38.08 213.09,40.04 213.09,41.56 219.25,47.72 v6(219.25,49.74)
  IN1 w0.061: v2(264.63,53.32) 264.15,53.32 264.15,53.32 262.71,53.32 262.1,52.71 259.87,52.71 259.64,52.94 258.01,52.94 257.5,53.45 248.26,53.45 247.14,52.33 222.41,52.33 219.82,49.74 v6(219.25,49.74) ; v2(102.37,40.45) 102.92,39.9 104.06,39.9 104.47,39.49 105.5,39.49 106.49,38.5 107.48,38.5 107.85,38.13 107.85,37.61 108.51,36.94 108.51,36.13 110.04,34.61 110.04,33.74 112.49,31.29 112.65,31.29 114.03,29.91 115.44,29.91 116.34,29.01 118.78,29.01 119.12,29.34 122.45,29.34 123.08,28.72 124.3,28.72 125.39,27.63 125.39,26.95 127.65,24.68 128.83,24.68 129.39,24.12 v2(130.35,24.12)
  BOTTOM w0.127: JESPI1.4 227.63,67.97 220.22,60.56 220.22,53.48 221.27,52.42 221.27,50.92 220.09,49.74 v6(219.25,49.74)
ESPI_IO1_R: length 3.5
  TOP w0.127: v2(101.62,38.51) 101.62,38.66 102.34,39.38 RC367.1
  IN1 w0.061: v4(101.28,37.46) 101.54,37.46 101.72,37.64 101.72,38.42 v2(101.62,38.51)
  IN3 w0.076: v5(101.05,37.69) v4(101.28,37.46)
ESPI_IO2: length 230.1
  TOP w0.102: UE1.G6 266.63,56.41 v2(266.63,56.42)
  TOP w0.127: v6(218.81,51.52) 219.26,51.06 219.26,50.41 219.72,49.95 219.72,47.68 213.45,41.41 213.45,39.89 211.49,37.94 211.49,34.53 v1(207.7,30.73) 205.43,28.47 201.81,28.47 195.99,22.64 195.99,21.31 193.94,19.27 182.94,19.27 179.66,16 152.74,16 139.82,20.01 139.2,20.62 138.7,20.62 135.09,24.22 131.19,24.22 130.71,23.74 v2(130.35,23.74)
  IN1 w0.061: v6(218.81,51.52) 218.86,51.52 221.78,54.44 232.26,54.44 236.47,58.65 246.34,58.65 246.93,58.06 255.2,58.06 256.25,57.01 262.49,57.01 262.6,57.12 264.45,57.12 264.95,56.62 266.43,56.62 v2(266.63,56.42) ; v2(130.35,23.74) 129.36,23.74 128.71,24.39 127.53,24.39 125.1,26.83 125.1,27.51 124.18,28.43 122.96,28.43 122.33,29.05 119.24,29.05 118.9,28.72 116.22,28.72 115.32,29.62 113.91,29.62 112.53,31 112.37,31 109.75,33.62 109.75,34.49 108.17,36.07 107.2,36.07 107.06,36.2 107.06,37.34 106.72,37.69 106.62,37.69 105.09,39.21 104.31,39.21 103.99,39.53 102.31,39.53 102.02,39.82 102.02,40.25 v2(101.81,40.46)
  BOTTOM w0.127: JESPI1.5 227.13,68.18 224.24,65.29 219.72,60.77 219.72,53.27 220.77,52.22 220.77,50.94 220.08,50.25 219.47,50.25 219.29,50.42 219.29,51.03 v6(218.81,51.52)
ESPI_IO2_R: length 1.4
  TOP w0.127: v6(101.51,39.19) 101.76,39.44 RC368.1
  BOTTOM w0.127: v6(101.51,39.19) 101.32,38.99 UCPU1.BY27
ESPI_IO3: length 227.5
  TOP w0.102: UE1.L5 265.84,53.45 265.66,53.62 v2(265.66,53.62)
  TOP w0.127: v2(130.53,23.36) 130.86,23.36 131.34,23.85 134.97,23.85 138.55,20.26 139.06,20.26 139.63,19.69 152.69,15.64 179.81,15.64 183.09,18.92 194.09,18.92 196.38,21.2 196.38,22.53 201.96,28.11 205.58,28.11 211.85,34.38 v1(211.85,35.43) 211.85,37.79 213.8,39.75 213.8,41.26 220.09,47.55 220.09,50.3 v6(219.71,50.68) ; RC369.2 100.56,40.65 100.24,40.96 v2(100.19,40.96)
  IN1 w0.061: v2(100.19,40.96) 100.19,40.07 100.54,39.72 100.67,39.72 100.8,39.59 101.79,39.59 102.22,39.16 103.82,39.16 104.08,38.91 104.99,38.91 106.49,37.41 106.57,37.41 106.72,37.26 106.72,36.14 107.08,35.78 108.02,35.78 109.46,34.34 109.46,33.5 112.25,30.71 112.41,30.71 113.78,29.33 114.85,29.33 116.45,27.73 117.22,27.73 117.44,27.51 119.32,27.51 119.48,27.67 121.33,27.67 121.64,27.36 124.06,27.36 127.32,24.1 128.6,24.1 129.33,23.36 v2(130.53,23.36) ; v2(265.66,53.62) 265.59,53.69 265.59,53.84 265.37,54.07 262.93,54.07 261.94,53.08 260.36,53.08 259.8,53.64 259.54,53.64 259.39,53.79 258.19,53.79 256.78,55.2 254.45,55.2 254.18,55.47 248.31,55.47 246.64,53.8 244.58,53.8 243.39,52.62 222.22,52.62 220.28,50.68 v6(219.71,50.68)
  BOTTOM w0.127: JESPI1.6 226.63,68.38 219.26,61.02 219.26,53.02 220.22,52.06 220.22,51.19 v6(219.71,50.68)
ESPI_IO3_R: length 1.7
  TOP w0.127: v1(100.11,39.07) 100.34,39.07 v6(100.56,39.29) RC369.1
  BOTTOM w0.127: UCPU1.BV27 100.26,38.99 v6(100.56,39.29)
ESPI_RESET#: length 253.2
  TOP w0.127: v6(117.16,13.6) 117.09,13.53 116.2,13.53 115.68,14.05 115.68,16 115.73,16.06 115.73,17.76 113.35,20.15 113.35,21.91 113.56,22.12 113.56,25.33 113.36,25.52 113.36,28.92 v2(112.54,29.74) ; v2(266.16,53.58) 266.58,54.01 UE1.K6 ; RE99.2 225.13,68.43 225.45,68.12 230.61,68.12 234.28,64.45 234.28,63 232.23,60.95 232.23,51.06 v6(232.14,50.97) 232.23,50.88 232.23,50.42 232.88,49.78 v1(232.88,43.83) 232.88,37.85 222.09,27.06 222.09,24.28 221.14,23.33 221.14,21.31 219.29,19.46 219.29,15.27 217.56,13.54 210.49,13.54 208.98,15.06 198.2,15.06 197.05,13.91 184.25,13.91 v6(183.93,13.59) ; v2(105.82,37.35) 105.9,37.43 108.56,37.43 110.34,39.21 110.73,39.21 RC614.1
  IN1 w0.061: v2(112.54,29.74) 112.19,30.09 112.01,30.09 108.8,33.3 108.8,33.9 107.5,35.2 106.84,35.2 106.09,35.94 106.09,37.07 v2(105.82,37.35) 105.38,37.79 104.08,37.79 103.11,38.75 v4(103.11,38.78) ; v6(232.14,50.97) 232.57,51.4 245.38,51.4 245.94,51.97 249.09,51.97 249.35,52.23 253.07,52.23 254,53.16 257.35,53.16 257.86,52.65 259.52,52.65 259.75,52.42 262.22,52.42 262.83,53.03 265.55,53.03 266.11,53.58 v2(266.16,53.58)
  IN3 w0.061: v4(103.11,38.78) 102.78,39.11 102.07,39.11 v5(101.96,38.99)
  BOTTOM w0.127: v6(183.93,13.59) 183.44,13.59 182.76,12.92 182.48,12.92 181.96,12.4 181.51,12.4 181.29,12.18 142,12.18 141.18,11.35 133.43,11.35 132.56,12.23 131.98,12.23 131.48,12.73 130.25,14.32 130.25,14.32 129.89,14.79 129.31,15.48 128.8,15.98 128.16,16.37 127.86,16.5 127.79,16.53 127.4,16.69 126.59,16.85 126.47,16.85 126.44,16.86 125.77,16.86 125.15,16.77 124.25,16.41 123.63,16.04 122.84,15.58 122.78,15.56 121.67,14.92 118.47,14.92 v6(117.16,13.6)
F4_LED: length 31.7
  TOP w0.254: v6(248.09,19) 248.53,19 v1(248.84,18.69) RK11.2
  BOTTOM w0.254: v6(248.09,19) 242.98,24.11 229.14,24.11 224.53,19.49 JKB1.32
F4_LED#: length 2.4
  TOP w0.127: QK4.3 v1(238.49,14.99) 238.34,14.84 UK1.42
F4_LED#_R: length 6.3
  TOP w0.127: v1(241.16,17.53) 241.16,16.01 QK4.1
  TOP w0.254: QK4.1 241.86,15.97 241.86,16.35 242.33,16.82 RK12.2 CK13.1 242.81,17.51 243.31,18 QK5.2
F4_LED_R: length 3.7
  TOP w0.254: QK5.1 RK11.1 247.93,17.94 v1(247.14,18.73)
FAULT_EVENT: length 194.3
  IN1 w0.061: v4(273.51,58.92) 274.06,58.92 274.44,58.54 275.93,58.54 276.36,58.11 277.92,58.11 278.7,58.89 279.55,58.89 279.83,58.62 279.83,54.46 278.31,52.95 v2(275.35,52.95)
  IN2 w0.061: v4(273.51,58.92) 272.07,60.36 269.75,60.36 269.06,59.67 267.17,59.67 266.52,59.02 266.05,59.02 264.16,60.9 260.43,60.9 259.47,61.87 258.06,61.87 255.85,64.08 249.15,64.08 245.41,60.34 235.87,60.34 228,52.47 223.47,52.47 213.42,42.42 207.38,42.42 203.75,38.78 197.01,38.78 196.99,38.76 196.99,38.76 193.65,35.42 189.87,35.42 188.81,34.35 188.81,34.07 175.82,21.08 156.02,21.08 155.76,21.33 149.91,21.33 145.65,25.59 143.25,25.59 133.45,35.4 130.66,35.4 130.29,35.77 130.29,36.4 130.55,36.67 v4(130.55,36.76)
  IN3 w0.061: v5(130.94,36.76) v4(130.55,36.76)
  BOTTOM w0.127: PQ1506.2 130.74,35.27 PR1519.2 131.45,36.07 130.94,36.58 v5(130.94,36.76) 130.94,37.8 PD1505.1 PD1504.1
FB_1.0V: length 3.1
  BOTTOM w0.254: PR803.2 118.93,53.67 PR806.1 ; PR803.2 119.34,54.44 119.46,54.56 PU800.14 ; PR803.2 118.91,54.46 PC806.2
FB_1.2V_DDR: length 3.6
  TOP w0.254: v2(48.67,25.25) 48.86,25.05 PR606.1 49.7,24.3 PR605.2 PC609.2
  IN1 w0.254: v4(48.21,25.25) v2(48.67,25.25)
  IN3 w0.254: v5(47.88,25.27) 48.2,25.27 v4(48.21,25.25)
FP_USB+: length 63.7
  IN3 w0.074: v5(280.62,26.76) 280.85,26.53 280.99,26.53 281.1,26.64 281.1,31.39 283.03,33.33 283.03,42.34 285.42,44.72 289.33,44.72 290.73,46.13 290.73,49.27 298.6,57.15 298.6,58.34 300.12,59.86 307.25,59.86 308.37,60.98 308.37,61.29 308.24,61.42 308.11,61.42 v5(308.08,61.38)
  BOTTOM w0.112: v5(280.62,26.76) 279.81,26.76 279.49,26.45 279.49,25.01 279.46,24.98 279.46,24.41 279.49,24.38 279.49,23.89 276.2,20.6 276.2,19.58 276.06,19.43 JUSH1.5
FP_USB-: length 63.7
  IN3 w0.074: v5(308.65,61.38) 308.57,61.31 308.57,60.9 307.34,59.66 300.21,59.66 298.8,58.26 298.8,57.06 290.93,49.19 290.93,46.04 289.41,44.52 285.5,44.52 283.23,42.25 283.23,33.24 281.3,31.31 281.3,26.56 281.07,26.33 v5(280.62,26.33)
  BOTTOM w0.112: JUSH1.4 276.55,19.43 276.41,19.58 276.41,20.51 279.7,23.8 v7(279.7,24.69) 279.7,26.36 279.89,26.56 280.13,26.56 280.24,26.44 280.24,26.27 280.36,26.16 280.49,26.16 280.62,26.28 v5(280.62,26.33)
FPR_DET#: length 68.7
  TOP w0.102: v2(269.47,60.66) 269.48,60.64 269.48,59.49 269.57,59.4 269.57,59.12 269.25,58.81 UE1.D9
  TOP w0.127: v6(309.59,64.31) D3.4 D3.7 309.59,67.31 v2(309.68,67.4) ; v2(295.13,73.27) 294.82,73.27 293.67,72.13 290.69,72.13 287.47,68.91 283.2,68.91 278.27,63.98 v1(277.05,63.98) v2(275.86,63.98) 274.2,65.64 RE121.1
  IN1 w0.061: v2(309.68,67.4) 309.68,65.33 309.32,64.96 304.82,64.96 304.01,65.77 296.24,65.77 294.77,67.24 294.77,71.98 295.4,72.61 295.4,73.01 v2(295.13,73.27) ; v2(275.86,63.98) 275.26,63.98 273.39,62.1 272.07,62.1 271.19,61.22 270.74,61.22 270.12,60.6 269.61,60.6 v2(269.47,60.66)
  BOTTOM w0.102: v6(309.59,64.31) 309.58,64.32 JFP1.16
FPR_LP_MODE#: length 40.1
  TOP w0.127: Q14.3 295.79,69.99 294.36,71.42 290.91,71.42 287.82,68.33 v1(286.46,68.33) 285.47,68.33 279.85,62.71 279.85,60.05 278.81,59.02 278.81,57.93 279.17,57.57 v2(279.17,57.35) ; v2(274.38,52.09) 274,52.09 272.48,53.61 271.83,53.61 UE1.K12
  IN1 w0.061: v2(279.17,57.35) 279.27,57.25 279.27,54.43 278.75,53.91 275.93,53.91 275.5,53.47 274.71,53.47 274.38,53.14 v2(274.38,52.09)
FPR_LP_MODE#_R: length 15.8
  TOP w0.127: v2(295.03,68.17) v1(293.9,68.17)
  IN1 w0.061: v2(295.03,68.17) 295.13,68.27 v4(295.13,68.68) 295.13,69.94 v2(295.08,69.99)
  IN3 w0.061: v4(295.13,68.68) 295.67,68.14 298.35,68.14 300.64,65.84 304.19,65.84 305.16,66.82 v5(306.31,66.82)
FPR_PWR_EN#: length 47.9
  TOP w0.076: UE1.M11 270.64,52.23 270.95,51.92 270.95,51.42 270.85,51.33 270.85,50.88 271.38,50.35
  TOP w0.127: 271.38,50.35 271.82,49.91 v2(271.82,49.46) ; v2(300.49,58.49) 300.24,58.74 299.19,58.74 299.01,58.57 297.31,58.57 296.25,59.62 295.61,59.62 291.16,64.06 289.69,64.06 288.11,65.64 284.06,65.64 280.68,62.26 v1(280.68,61.96) 280.68,59.36 279.48,58.16 v2(279.4,58.16)
  IN1 w0.061: v2(279.4,58.16) 278.89,57.65 278.89,57.14 279.14,56.89 279.14,54.48 278.74,54.07 274.5,54.07 273.09,52.66 273.09,51.18 271.82,49.9 v2(271.82,49.46) ; v4(300.77,58.22) v2(300.49,58.49)
  IN3 w0.061: v5(300.93,57.8) 300.77,57.96 v4(300.77,58.22)
FPR_RESET#: length 83.1
  TOP w0.127: v6(310.94,67.05) 310.94,68.29 310.12,69.11 308.55,69.11 306.39,66.95 306.39,66 v1(306.09,65.7) 305.88,65.49 v6(305.07,65.49)
  IN3 w0.061: v6(310.94,67.05) 310.45,66.56 310.45,63.64 310.11,63.3 310.11,62.29 309.66,61.84 306.67,61.84 305.09,60.26 297.79,60.26 296.98,59.46 296.98,56.23 288.71,47.96 285.09,47.96 282.01,44.88 282.01,33.9 280.73,32.62 280.73,30.26 v5(280.78,30.21)
  BOTTOM w0.127: JUSH1.2 277.55,20.18 281.05,23.67 281.05,26.91 279.89,28.07 279.89,29.32 v5(280.78,30.21) ; R220.1 303.93,65.35 304.93,65.35 v6(305.07,65.49) ; v6(310.94,67.05) 311.16,66.82 JFP1.5
FPR_SCAN_INT#: length 112.1
  TOP w0.127: v6(309.6,63.68) R221.2 310.11,63.94 310.09,63.95 D3.5 D3.6 310.09,67.59 v6(310.3,67.79)
  IN1 w0.061: v6(309.6,63.68) 308.44,64.84 304.77,64.84 303.96,65.65 296.19,65.65 294.65,67.19 294.65,72.35 v2(295.07,72.77)
  IN3 w0.061: v6(309.6,63.68) 307.9,63.68 304.77,60.55 297.28,60.55 296.48,59.76 296.48,56.36 288.53,48.41 284.91,48.41 281.57,45.07 281.57,34.01 280.41,32.85 280.41,30.01 280.6,29.82 v5(280.6,27.88)
  BOTTOM w0.102: v6(310.3,67.79) 309.72,68.37 307.8,68.37 307.25,67.82 JFP1.2
  BOTTOM w0.127: v5(280.6,27.88) 280.86,27.88 282.16,26.57 282.16,24.09 278.4,20.33 278.4,18.26 277.55,17.42 276.85,17.42 275.17,15.74 273.34,15.74 272,17.08 268.64,17.08 268.06,17.67 JUSH1.21
FPR_SCAN_INT#_EC: length 43.4
  TOP w0.127: v2(295.85,72.76) 295.86,72.78 Q15.3 ; UE1.L8 268.42,53.21 268.62,53.4 268.62,54.89 268.93,55.2 269.26,55.2 v2(269.47,55.41) ; v2(279.4,58.51) 280.36,59.48 v1(280.36,59.51) 280.36,62.5 285.51,67.65 294.97,67.65 v2(295.01,67.69)
  IN1 w0.061: v2(279.4,58.51) 279.35,58.51 278.13,57.3 277.54,57.3 v2(277.52,57.27) 278,56.79 278,56.48 277.67,56.15 276.18,56.15 275.56,56.77 273.72,56.77 272.85,55.9 270.35,55.9 269.81,55.37 269.52,55.37 v2(269.47,55.41) ; v2(295.85,72.76) 295.85,72.32 295.48,71.95 295.48,68.16 v2(295.01,67.69)
FPR_SSO_EN#: length 35.9
  TOP w0.127: Q15.6 290.8,71.78 v1(289.75,70.72) 287.67,68.65 285.41,68.65 279.6,62.84 279.6,60.16 278.52,59.08 v2(278.52,58.03) 278.52,57.84 278.74,57.63 RE490.1
  IN1 w0.061: v2(269.04,55.61) 269.12,55.7 269.97,55.7 270.3,56.03 272.8,56.03 273.67,56.89 276.04,56.89 276.27,57.12 276.27,57.4 276.63,57.77 278.25,57.77 v2(278.52,58.03)
FPR_UEFI_MGMT#: length 37.2
  TOP w0.102: UE1.K9 269.48,54.45 v2(270.43,54.45)
  TOP w0.127: Q14.6 294.08,68.99 293.08,67.99 v1(290.5,67.99) 285.49,67.99 280.11,62.61 280.11,59.95 279.08,58.92 279.08,58.02 279.48,57.63 279.48,57.23 279.06,56.81 278.76,56.81 v2(278.74,56.79)
  IN1 w0.061: v2(278.74,56.79) 278.99,56.53 278.99,55.85 278.66,55.52 278.23,55.52 278.08,55.67 276.31,55.67 275.47,56.52 273.95,56.52 272.78,55.35 271.44,55.35 271.02,54.93 270.73,54.93 270.43,54.63 v2(270.43,54.45)
GPIO043: length 3.8
  TOP w0.127: RE536.1 274.43,53 273.01,54.43 271.99,54.43 271.61,54.81 UE1.J12
GPIO_5_AUDIO_0: length 167.1
  TOP w0.127: v1(257.58,67.24) 257.19,67.63 v6(257.19,68.06)
  IN2 w0.061: v6(276.16,66.31) 276.16,65.05 273.75,62.63 272.37,62.63 271.22,61.48 270.81,61.48 270.73,61.56 260.67,61.56 257.19,65.05 v6(257.19,68.06)
  IN3 w0.061: v6(276.16,66.31) 276.16,66.04 277.87,64.33 277.87,52.88 279.02,51.73 279.02,33.8 278.78,33.55 278.78,26.57 v5(278.59,26.38) ; v6(257.19,68.06) 256.68,67.55 254.97,67.55 251.73,70.8 242.98,70.8 239.17,74.61 224.92,74.61 224.3,74 221.14,74 219.44,72.3 207.07,72.3 v5(206.56,71.8) 206.56,71.68 206.39,71.5 199.66,71.5 199.25,71.91 v5(199.08,71.91)
  BOTTOM w0.127: v5(206.56,71.8) 206.58,71.81 JLTE1.3 ; JLTE2.3 v5(199.08,71.91) ; T148.1 245.39,69.87 255.99,69.87 257.19,68.67 v6(257.19,68.06) ; JNGFF1.20 262.4,30.96 261.68,30.24 261.68,28.76 261.9,28.54 263.08,28.54 264.27,27.36 273.34,27.36 274.33,26.38 v5(278.59,26.38)
GPIO_6_AUDIO_1: length 17.7
  TOP w0.127: QN12.1 272.85,27 273.26,26.59 RN115.2 v1(274.14,26.43) 274.18,26.43 v2(274.71,26.97)
  IN1 w0.061: v4(274.71,26.51) v2(274.71,26.97)
  IN3 w0.061: v5(274.45,27.03) 274.71,26.76 v4(274.71,26.51)
  BOTTOM w0.127: JNGFF1.22 262.9,30.91 265.97,27.83 273.65,27.83 v5(274.45,27.03)
GPIO_7_AUDIO_2: length 167.6
  TOP w0.127: v6(257.62,68.47) v1(257.62,70.25)
  IN2 w0.061: v6(257.62,68.47) 257.62,64.79 260.72,61.69 270.78,61.69 270.87,61.61 271.17,61.61 272.32,62.76 273.67,62.76 275.78,64.86 275.78,66.76 v6(275.78,66.77)
  IN3 w0.061: v5(278.13,27.23) 278.13,28.07 278.58,28.52 278.58,33.52 278.9,33.85 278.9,51.68 277.75,52.82 277.75,64.16 275.78,66.14 v6(275.78,66.77) ; v6(257.62,68.47) 257.62,67.98 257.06,67.42 254.93,67.42 251.68,70.68 242.93,70.68 239.12,74.49 224.97,74.49 224.35,73.88 221.19,73.88 219.49,72.18 207.31,72.18 v5(206.93,71.8) 206.93,71.72 206.59,71.38 200.22,71.38 199.96,71.12 199.03,71.12 198.7,71.45 v5(198.7,71.89)
  BOTTOM w0.051: JLTE2.4 198.73,71.91 v5(198.7,71.89)
  BOTTOM w0.127: JLTE1.2 v5(206.93,71.8) ; v6(257.62,68.47) 257.62,68.8 256.23,70.19 244.44,70.19 T147.1 ; v5(278.13,27.23) 277.9,27 275.72,27 274.58,28.15 266.12,28.15 263.4,30.87 JNGFF1.24
GPP_A7: length 12.1
  IN3 w0.061: v5(107.8,29.33) 107.08,29.33 106.7,29.71 106.7,30.95 105.77,31.87 105.77,33.69 105.53,33.93 105.53,34.85 104.41,35.97 104.41,36.55 104.15,36.8 103.53,36.8 103.46,36.87 103.17,36.87 103.08,36.79 102.86,36.79 102.55,36.47 102.55,36.15 102.87,35.83 v5(102.87,35.74)
GPP_B15: length 18.5
  TOP w0.127: v2(110.37,31.3) v1(111.05,31.3) 111.29,31.06 RC626.2
  IN1 w0.061: v2(110.37,31.3) 108.44,33.23 v4(108.44,33.38)
  IN2 w0.061: v4(108.44,33.38) 108.11,33.05 106.58,33.05 105.48,34.16 103.47,34.16 101.8,35.82 101.8,37.59 v4(101.36,38.03)
  IN3 w0.061: v5(102.39,39.4) 102.2,39.59 101.33,39.59 101.08,39.34 101.08,38.7 101.36,38.42 v4(101.36,38.03)
  BOTTOM w0.127: UCPU1.CC27 102.46,39.4 v5(102.39,39.4)
GPP_B22: length 7.6
  TOP w0.127: RC46.1 103.7,30.55 103.42,30.83 103.42,31.88 103.11,32.19 103.11,32.85 v2(102.45,33.51)
  IN1 w0.061: v2(102.45,33.51) 101.87,34.09 101.87,36.48 v4(102.19,36.81)
  IN3 w0.076: v5(101.96,37.04) v4(102.19,36.81)
GPP_B23: length 5.9
  IN3 w0.061: v5(103.16,29.39) 103.11,29.44 103.11,30.7 103.58,31.17 103.58,31.65 103.36,31.87 103.36,33.81 103.26,34.05 v5(102.87,34.44)
  BOTTOM w0.127: v5(102.87,34.44) UCPU1.CC34
GPP_C2: length 2.4
  TOP w0.127: v2(106.41,46.34) 106.47,46.28 RC606.1 107.03,46.77 v1(107.45,47.19)
  IN1 w0.061: v2(106.41,46.34) v4(106.67,46.6)
  IN3 w0.076: v5(106.44,46.35) 106.44,46.37 v4(106.67,46.6)
GPP_C5: length 2.2
  TOP w0.127: v1(106.01,45.52) 105.68,45.86 RC27.1 v2(105.12,46.37)
  IN1 w0.061: v2(105.12,46.37) v4(105.37,46.59)
  IN3 w0.076: v5(105.14,46.35) v4(105.37,46.59)
GPP_D12: length 3
  TOP w0.127: v2(110.29,41.67) 110.25,41.71 RC608.1
  IN1 w0.061: v2(110.29,41.67) 110.21,41.59 109.46,41.59 109.26,41.79 109.26,42.11 v4(108.84,42.53)
  IN3 w0.061: v5(109.04,42.19) 109.04,42.32 v4(108.84,42.53)
GPP_H17: length 2.9
  BOTTOM w0.127: RC464.2 109.95,39.85 109.85,39.95 109.32,39.95 UCPU1.CP26
GPP_H21: length 2.4
  TOP w0.127: RC443.1 RC444.1 105.19,39.24 v1(105.35,39.08)
  IN1 w0.061: v2(105.18,39.98) 104.8,40.36 v4(104.72,40.36)
  IN3 w0.076: v5(104.49,40.13) v4(104.72,40.36)
GPP_H23: length 5.4
  IN3 w0.061: v5(109.36,38.65) 108.42,38.65 107.75,39.33 v5(107.75,39.58)
  BOTTOM w0.127: RC445.1 112.32,39.25 RC446.1 110.11,39.25 109.51,38.65 v5(109.36,38.65)
GPS_DISABLE#: length 54.2
  TOP w0.127: v2(261.02,24.67) v1(261.02,25.93) 261.02,27.36 260.03,28.35 260.03,30.33 259.61,30.75 QN8.6
  IN1 w0.061: v2(261.02,24.67) 261.04,24.69 v4(261.36,24.69) ; v4(266.17,55.39) 265.96,55.6 v2(265.83,55.6) 265.45,55.21 262.57,55.21 261.56,54.2 260.18,54.2 259.75,54.63 v2(259.22,54.63)
  IN3 w0.061: v4(266.17,55.39) 266.17,55.24 267.05,54.36 268.18,54.36 269.7,52.85 269.7,49.04 269.37,48.71 268.48,48.71 267.97,48.2 267.97,46.12 269.24,44.85 269.24,42.14 269.51,41.88 269.51,35.31 269.39,35.19 269.39,33.6 268.09,32.3 268.09,29.85 263.78,25.54 262.97,25.54 262.09,24.65 261.39,24.65 v4(261.36,24.69)
GPS_DISABLE#_R: length 5.8
  TOP w0.127: QN8.1 260.6,30.75 260.43,30.57 v6(260.43,30.22) 260.43,29.85 v1(260.78,29.5)
  IN3 w0.061: v6(260.43,30.22) 261.82,31.61 v5(263.9,31.61)
GT_B+: length 1.1
  TOP w0.127: v6(39.13,52.72) 38.59,52.19 v1(38.59,51.85)
H_CATERR#: length 5.9
  BOTTOM w0.066: RC219.2 76.43,57.09
  BOTTOM w0.076: 76.43,57.09 76.05,56.71 76.05,55.79 76.26,55.57 76.26,54.84 76.11,54.69 76.11,54.25 76.3,54.06 76.55,54.06 76.68,53.93 76.68,53.87 76.95,53.59 UCPU1.AA4
H_CPU_SVIDALRT#: length 3.9
  BOTTOM w0.076: UCPU1.AA3 76.95,54.29 76.64,54.6 76.64,54.96 76.41,55.19 76.41,55.63 76.21,55.84 76.21,56.57 RC155.1
H_CPUPWRGD: length 5.9
  BOTTOM w0.127: v1(84.62,58.86) 84.62,58.21 85,57.83 CC199.1 RC85.2 86.14,57.51 85.25,56.62 85.25,55.28 85.59,54.94 UCPU1.AR2
H_PROCHOT#: length 389.7
  TOP w0.127: v6(47.31,27.2) v1(48.14,27.2) ; PR920.1 44.33,52.98 44.33,51.21 45.63,49.92 46.95,49.92 47.64,49.23 49.43,49.23 49.79,49.59 v2(49.79,50.07) 50.19,50.47 50.19,51.12 52.34,53.27 52.34,54.63 54.74,57.04 57.41,57.04 58.96,55.48 60.93,55.48 62.25,56.8 71.32,56.8 73.54,54.58 73.54,53.96 74,53.5 74,52.44 74.23,52.22 75.45,52.22 75.67,52.43 RC221.2 76.25,52.65 RC220.1
  IN1 w0.061: v2(23.65,15.94) 23.95,15.64 29.44,15.64 29.87,16.07 33.5,16.07 35.63,18.2 35.63,19.71 41.75,25.83 42.7,25.83 44.12,27.25 44.12,27.67 44.39,27.94 46.57,27.94 v6(47.31,27.2) ; v4(275.26,55.62) 275.11,55.77 v2(274.94,55.77) ; v4(57.87,27.93) 57.55,28.26 57.55,32.12 58.86,33.43 58.86,37.68 57.01,39.53 53.11,39.53 50.18,42.45 50.18,49.67 v2(49.79,50.07)
  IN2 w0.061: v6(47.31,27.2) 47.54,27.43 51.92,27.43 52.35,27.86 v4(52.91,27.86) 57.8,27.86 v4(57.87,27.93) ; v4(215.49,17) 215.94,16.55 217.27,16.55 236.99,36.27 256.41,36.27 258.98,38.84 264.75,38.84 266.86,40.96 266.86,41.58 267.97,42.69 269.16,42.69 274.08,47.61 274.08,54.44 v4(275.26,55.62)
  IN3 w0.061: v4(52.91,27.86) 52.72,27.67 52.72,17.05 53.08,16.68 53.08,14.88 51.93,13.72 49.81,13.72 v5(48.22,12.13) ; v5(103.63,12.39) 103.79,12.54 109.44,12.54 109.85,12.96 112.58,12.96 113.12,13.49 116.61,13.49 116.93,13.18 117.31,13.18 117.69,13.55 119.98,13.55 v5(119.98,13.56) ; v5(183.6,12.07) 184.29,12.76 200.97,12.76 202.59,14.37 209.3,14.37 211.5,16.57 215.06,16.57 v4(215.49,17)
  BOTTOM w0.127: v5(48.22,12.13) 103.38,12.13 v5(103.63,12.39) ; v5(119.98,13.56) 120.6,13.89 123.81,15.73 124.41,16.09 125.24,16.43 125.8,16.5 126.39,16.5 126.42,16.49 126.55,16.49 127.29,16.34 127.99,16.06 128.6,15.65 128.64,15.63 129.14,15.13 129.62,14.56 131.21,12.5 133.07,10.64 182.17,10.64 v5(183.6,12.07) ; PR600.2 v6(47.31,27.2)
H_PROCHOT#_R: length 0.7
  IN1 w0.061: v2(76.29,53.17) RC220.2 v4(76.51,53.43)
  IN3 w0.061: v5(76.39,53.75) v4(76.51,53.43)
H_THERMTRIP#: length 19.9
  TOP w0.127: v2(106.36,64.23) 106.96,63.63 v1(107.47,63.63) 107.76,63.63 108.12,63.99 QE5.3
  IN1 w0.061: v4(102.51,60.05) 102.8,60.05 103.14,60.39 104.58,60.39 105.31,61.12 105.31,63.43 106.1,64.23 v2(106.36,64.23)
  IN2 w0.061: v4(96.21,58.99) 96.1,59.1 96.1,59.5 96.34,59.74 96.34,60.09 96.55,60.29 102.27,60.29 v4(102.51,60.05)
  IN3 w0.061: v5(95.92,59.19) 96,59.19 v4(96.21,58.99)
  BOTTOM w0.127: RC222.1 94.42,58.46 94.71,58.76 94.71,58.87 95.04,59.19 v5(95.92,59.19)
H_THERMTRIP#_R: length 5.1
  BOTTOM w0.127: RC218.2 94.26,59.05 93.97,58.76 93.97,58.14 94.23,57.88 RC222.2 94.33,57.87 93.99,57.52 93.92,57.52 93.18,56.79 93.18,56.27 93.71,55.74 93.71,55.47 93.8,55.38 UCPU1.BJ1
HDA_BIT_CLK: length 4.6
  BOTTOM w0.076: RC112.2 97.2,29.3 RC613.2 96.87,29.48 97.2,29.81 97.2,30.3 CC13.1 96.89,30.64 96.89,32.65 UCPU1.BN37
HDA_BIT_CLK_R: length 207.5
  TOP w0.127: v6(278.93,20.22) 280.48,20.22 280.75,19.96 CA28.1 280.87,19.7 281.7,20.53 UA1.14
  IN3 w0.061: v5(98.5,29.13) 98.84,29.13 99.35,28.62 99.35,28.2 99.4,28.15 99.4,27.76 99.63,27.53 99.85,27.53 101.47,25.9 101.47,22.9 100.48,21.91 100.48,19.75 101.29,18.94 101.29,18.24 103.91,15.63 105.08,15.63 105.85,14.86 108.81,14.86 109.65,15.7 109.68,15.7 109.69,15.7 115.34,15.7 116.31,16.67 120.12,16.67 121.16,17.71 128.26,17.71 134.42,11.56 146.79,11.56 147.45,11.5 148.6,11.28 150.19,10.78 150.71,10.34 150.76,9.62 151.01,9.41 156.83,9.4 181.91,9.4 183.82,10.19 184.89,11.26 221.39,11.26 221.77,11.64 223.92,11.64 224.63,10.94 250.17,10.94 254.27,15.03 275.69,15.03 278.41,17.75 278.41,19.91 278.73,20.22 v6(278.93,20.22)
  BOTTOM w0.127: v5(98.5,29.13) 98.35,28.97 RC112.1
HDA_RST#: length 6.4
  BOTTOM w0.076: UCPU1.BL35 95.2,33.67 95.2,32.16
  BOTTOM w0.127: 95.2,32.16 94.33,31.3 RC559.2 94.9,30.57 RC615.2 95.11,30.63 95.33,30.41 95.33,29.52 95.16,29.36 CC17.1
HDA_RST#_R: length 208.7
  TOP w0.127: RA117.1 275.21,26.42 v6(274.73,25.94) v1(274.73,25.22)
  IN3 w0.061: v5(182.45,11.45) 183.93,11.45 184.49,12.01 201.04,12.01 202.83,13.79 205.56,13.79 206.17,13.18 206.47,13.18 206.79,13.5 220.32,13.5 221.14,14.31 248.16,14.31 251.8,17.95 264.53,17.95 267.41,20.82 271.1,20.82 273.81,23.54 273.81,25.02 v6(274.73,25.94) ; v5(132.34,11.89) 131.7,11.89 130.32,13.27 130.32,13.9 127.75,16.48 124.61,16.48 122.77,14.64 119.05,14.64 118.68,15 117.31,15 116.76,14.46 110.16,14.46 109.1,13.39 100.78,13.39 99.65,14.52 97.84,14.52 96.41,15.94 96.41,18.67 97.27,19.52 97.27,21.43 96.79,21.91 96.79,22.24 95.82,23.2 95.82,26.88 94.1,28.6 94.1,29.76 v5(94.33,29.99)
  BOTTOM w0.127: v5(182.45,11.45) 182,11 133.23,11 v5(132.34,11.89)
HDA_SDIN0: length 217.6
  TOP w0.127: RA16.2 v2(279.54,19.13)
  IN1 w0.061: v4(279.16,19.03) 279.26,19.13 v2(279.54,19.13) ; v4(222.66,11.18) 221.88,11.96 207.23,11.96 205.02,14.16 202.41,14.16 199.47,11.22 186.09,11.22 185.48,10.61 180.07,10.61 179.25,9.79 153.39,9.79 152.78,9.99 150.1,9.99 149.61,10.17 149.5,10.17 149.34,10.12 148.86,9.97 148.19,10.04 v4(148.13,10.11)
  IN3 w0.061: v4(279.16,19.03) 279.12,18.99 279.12,17.5 275.95,14.34 254.5,14.34 250.44,10.28 223.55,10.28 v4(222.66,11.18) ; v4(148.13,10.11) 148.06,10.18 146.55,10.61 134.02,10.61 127.87,16.77 124.49,16.77 122.65,14.93 119.17,14.93 118.8,15.29 117.18,15.29 116.64,14.75 110.04,14.75 108.98,13.68 100.9,13.68 99.77,14.81 97.96,14.81 96.7,16.06 96.7,18.55 97.56,19.4 97.56,21.55 97.13,21.97 97.13,22.3 96.16,23.27 96.16,26.95 94.67,28.44 v5(94.67,31.15)
  BOTTOM w0.076: v5(94.67,31.15) 95.4,31.15 96.3,32.05 96.3,32.81 96.52,33.18 96.53,33.25 96.53,33.65 96.79,33.91 UCPU1.BN35
HDA_SDIN0_R: length 3
  TOP w0.127: UA1.16 282.5,20.13 282.04,19.67 v1(281.62,19.67) 281.57,19.67 281.04,19.13 RA16.1
HDA_SDOUT: length 98.5
  TOP w0.127: v6(25.18,10.42) 24.32,9.56 v1(24.32,8.78) RC511.1
  IN3 w0.061: v6(25.18,10.42) 25.46,10.42 27.93,12.89 36.52,12.89 37.77,11.64 48.28,11.64 50.06,13.42 54.02,13.42 v5(54.96,14.36) ; v5(95.55,22.44) 94.91,21.8 94.91,19.03 94.36,18.48 94.36,15.17 92.8,13.61 62.23,13.61 v5(61.48,14.36)
  BOTTOM w0.076: 96.4,31.02 96.53,31.15 96.53,32.84 96.56,32.92 96.68,33.11 96.7,33.24 96.7,33.25 UCPU1.BN36
  BOTTOM w0.127: v5(95.55,22.44) 95.54,22.45 95.54,25.72 95.4,25.86 95.4,27.49 94.86,28.03 94.86,28.8 95.02,28.96 95.85,28.96 CC15.1 96.15,29.44 95.66,29.44 95.54,29.56 95.54,30.3 95.82,30.57 RC113.2 96.24,30.86 96.4,31.02 ; v5(61.48,14.36) v5(54.96,14.36)
HDA_SDOUT_R: length 218.1
  TOP w0.127: v2(281.74,19.25) 281.99,19.25 282.9,20.16 UA1.17
  IN1 w0.061: v4(254.29,12.59) 252.34,12.59 250.11,10.36 222.29,10.36 221.28,11.38 203.99,11.38 202.92,12.45 201.52,12.45 199.71,10.64 186.33,10.64 185.72,10.03 180.31,10.03 179.49,9.21 153.04,9.21 152.56,9.41 148.99,9.41 v4(148.81,9.6) ; v2(281.74,19.25) v4(281.27,19.25)
  IN3 w0.061: v4(254.29,12.59) 255.69,13.99 276.02,13.99 279.46,17.44 279.46,18.64 280.07,19.25 v4(281.27,19.25) ; v5(95.84,29.75) 95.72,29.63 95.72,28.21 96.75,27.18 98.4,27.18 99.52,26.07 99.92,26.07 100.53,25.46 100.53,23.3 99.73,22.5 98.74,22.5 98.13,21.89 98.13,19.16 97.28,18.31 97.28,16.61 98.7,15.2 99.8,15.2 100.94,14.05 108.93,14.05 109.92,15.04 116.52,15.04 117.06,15.58 118.92,15.58 119.29,15.22 122.53,15.22 124.37,17.06 127.99,17.06 134.14,10.9 146.73,10.9 148.31,10.45 148.81,9.95 v4(148.81,9.6)
  BOTTOM w0.127: v5(95.84,29.75) 96.08,29.99 RC113.1
HDA_SYNC: length 4.5
  BOTTOM w0.076: RC111.2 97.64,32.44 97.05,33.03 97.05,34.44 UCPU1.BN34
HDA_SYNC_R: length 217.9
  TOP w0.127: UA1.15 282.1,20.2 v2(281.91,20)
  IN1 w0.061: v4(223.3,11.18) 222.88,10.76 222.42,10.76 221.51,11.67 207.11,11.67 204.9,13.88 202.54,13.88 199.59,10.93 186.21,10.93 185.6,10.32 180.19,10.32 179.37,9.5 153.36,9.5 152.59,9.7 149.65,9.7 v4(149.55,9.8) ; v4(281.62,19.71) v2(281.91,20)
  IN3 w0.061: v4(149.55,9.8) 149.39,9.8 149.24,9.95 149.24,10.54 149.1,10.74 148.38,10.95 146.75,11.19 134.26,11.19 128.11,17.35 123.58,17.35 122.71,16.48 122.71,15.81 122.41,15.5 119.41,15.5 119.04,15.87 116.94,15.87 116.4,15.33 109.8,15.33 108.81,14.34 101.06,14.34 99.92,15.48 98.82,15.48 97.58,16.73 97.58,18.2 98.42,19.04 98.42,21.77 98.8,22.14 99.78,22.14 100.82,23.18 100.82,25.58 100.02,26.37 99.68,26.37 99,27.06 99,28 99.16,28.16 99.16,28.6 98.9,28.86 98.32,28.86 98.22,28.96 v5(98.22,29.46) ; v4(281.62,19.71) 280.91,19.71 280.53,20.1 279.4,20.1 279.11,19.81 278.88,19.81 278.78,19.7 278.78,17.57 275.83,14.63 254.38,14.63 250.32,10.57 223.92,10.57 v4(223.3,11.18)
  BOTTOM w0.127: v5(98.22,29.46) 97.69,29.99 RC111.1
HDMI_CEC: length 9.1
  TOP w0.127: v2(12.06,37.24) 13.1,38.28 v1(13.74,38.28) 15.67,38.28 16.14,37.8 RM98.2
  IN1 w0.061: v2(12.06,37.24) 12.06,37.23 12.06,34.05 JHDMI1.13
HDMI_CLKN: length 1.5
  TOP w0.112: CM20.2 17.58,32.36 17.4,32.36 RM99.1 17,32.38 16.8,32.38 RM31.1
HDMI_CLKP: length 1.5
  TOP w0.112: RM33.1 16.8,32.17 17,32.17 RM100.1 17.37,32.16 17.61,32.16 CM18.2
HDMI_CTRL_CLK: length 20.8
  BOTTOM w0.127: JHDMI1.15 11.9,34.88 11.9,35.64 12.59,36.34 13.02,36.34 13.37,35.99 13.37,34.98 13.77,34.58 13.77,27.46 13.44,27.13 13.44,24.78 14.38,23.84 14.5,23.84 v1(14.69,23.64) 14.87,23.46 14.87,23.35 15.47,22.75 15.65,22.75 RM95.2 15.91,22.73 17.42,22.73 17.67,22.97 QM1.3
HDMI_CTRL_DATA: length 19.8
  BOTTOM w0.127: JHDMI1.16 13.11,34.74 13.52,34.33 13.52,27.57 13.18,27.23 13.18,27.02 13.03,26.87 11.89,26.87 11.73,26.72 11.73,26.51 11.88,26.36 13.03,26.36 13.18,26.21 13.18,26 13.03,25.86 12.41,25.86 12.24,25.69 12.24,25.48 12.39,25.33 13.04,25.33 13.18,25.2 13.18,24.68 15.41,22.45 15.58,22.45 RM94.2 15.89,22.37 16.45,22.37 16.67,22.15 QM1.6
HDMI_HPD: length 16
  BOTTOM w0.127: QM2.1 16.16,24.87 RM97.1 15.11,24.87 14.03,25.95 14.03,34.69 13.62,35.09 13.62,36.1 13.13,36.59 11.6,36.59 JHDMI1.19
HDMI_OB: length 29
  TOP w0.127: v2(19.58,35.8) 20.21,35.8 20.51,36.1 20.51,38.04 20.29,38.26 v1(20.14,38.26) 19.72,38.26 19.39,37.93 18.03,37.93 17.37,37.27 RM101.2 ; QM3.1 17.12,25.71 RM106.2 19.49,25.81 19.79,26.1 19.79,27.23 19.46,27.56 RM105.2 v2(17.22,28.35) ; v2(18.4,35.65) 18.26,35.52 RM102.2 ; v2(17.22,30.1) 17.19,30.13 RM100.2 v2(18.81,31.4) ; RM99.2 18.8,33.15 v2(18.95,33)
  IN1 w0.061: v2(17.22,30.1) v2(17.22,28.35) ; v2(19.58,35.8) 18.55,35.8 v2(18.4,35.65) 18.4,35.47 19.09,34.78 19.09,33.15 v2(18.95,33) 18.54,32.59 18.54,31.67 v2(18.81,31.4)
HDMI_R_CLKN: length 3.8
  TOP w0.112: JHDMI1.12 13.17,32.37 13.63,32.37 13.64,32.37 14.12,32.37 14.13,32.37 14.61,32.37 DM4.1 15.07,32.36 15.26,32.36 RM32.1 15.66,32.37 15.86,32.37 RM31.2
HDMI_R_CLKP: length 3.8
  TOP w0.112: RM33.2 15.87,32.17 15.65,32.17 RM32.2 15.3,32.16 15.03,32.16 DM5.1 14.63,32.17 v7(13.88,32.17) 13.23,32.17 JHDMI1.10
HDMI_R_TX_N0: length 10.9
  TOP w0.112: RM34.2 15.86,36.49 15.67,36.49 RM35.1 15.27,36.5 15.04,36.5 DM3.1 14.62,36.5 14.41,36.5 14.22,36.69 v7(13.77,36.69) 12.44,36.69 11.92,36.17 11.92,35.3 11.92,35.29 11.92,30.95 11.81,30.84 11.65,30.84 JHDMI1.9
HDMI_R_TX_N1: length 3.8
  TOP w0.112: RM37.2 15.89,29.33 15.66,29.33 RM38.1 15.28,29.34 15.04,29.34 DM2.1 14.62,29.34 14.12,29.34 14.11,29.34 13.62,29.34 13.62,29.34 13.2,29.34 JHDMI1.6
HDMI_R_TX_N2: length 6
  TOP w0.112: JHDMI1.3 11.65,27.84 11.91,27.84 12.18,27.57 12.18,27.31 12.69,26.8 13.62,26.8 13.62,26.81 14.11,26.81 14.12,26.8 14.63,26.8 DM1.1 15.06,26.78 15.27,26.78 RM41.1 15.68,26.77 15.87,26.77 RM40.2
HDMI_R_TX_P0: length 10.9
  TOP w0.112: JHDMI1.7 11.65,30.63 11.89,30.63 12.12,30.86 12.12,35.21 12.13,35.21 12.13,36.08 12.53,36.48 13.42,36.48 13.43,36.48 14.14,36.48 14.32,36.3 14.62,36.3 DM8.1 15.04,36.3 15.28,36.3 RM35.2 15.64,36.29 15.86,36.29 16.03,36.11 RM36.2
HDMI_R_TX_P1: length 3.8
  TOP w0.112: JHDMI1.4 13.2,29.13 v7(13.87,29.13) 14.61,29.13 DM7.1 15.05,29.13 15.27,29.13 RM38.2 15.66,29.13 15.89,29.13 RM39.2
HDMI_R_TX_P2: length 6
  TOP w0.112: RM42.2 15.9,26.57 15.64,26.57 RM41.2 15.29,26.58 15.04,26.58 DM6.1 14.61,26.6 v7(13.87,26.6) 12.61,26.6 11.97,27.23 11.97,27.49 11.83,27.63 11.65,27.63 JHDMI1.1
HDMI_TX_N0: length 1.5
  TOP w0.112: CM17.2 17.59,36.5 17.38,36.5 RM101.1 17,36.49 16.8,36.49 RM34.1
HDMI_TX_N1: length 1.5
  TOP w0.112: RM37.1 16.84,29.32 17.01,29.32 RM103.1 17.39,29.35 17.62,29.35 CM15.2
HDMI_TX_N2: length 1.5
  TOP w0.112: CM7.2 17.59,26.79 17.41,26.79 RM105.1 17.03,26.79 16.83,26.79 RM40.1
