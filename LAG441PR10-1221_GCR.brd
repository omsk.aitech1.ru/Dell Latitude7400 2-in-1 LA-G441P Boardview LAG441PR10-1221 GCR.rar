# Allegro board LAG441PR10-1221_GCR.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SENSOR_DET#_R: length 10.6
  TOP w0.127: RE535.1 273.95,49.15 273.65,49.46 RE532.1 272.96,50.17 271.86,51.28 271.86,51.83 271.7,51.99 v2(271.6,51.99) ; UE1.H8 268.44,55.61 v2(268.6,55.44)
  IN1 w0.061: v2(271.6,51.99) 271.2,51.99 270.86,52.33 270.86,53.5 269.97,54.39 268.98,54.39 268.65,54.72 268.65,55.39 v2(268.6,55.44)
SIO_EXT_WAKE#: length 221.6
  TOP w0.127: RC40.1 v2(105.14,49.04)
  IN1 w0.061: v2(105.14,49.04) 105.2,49.04 v4(105.41,48.82) ; v2(274.97,50.39) 274.73,50.39 273.56,49.21 273.56,46.77 271,44.21 260.39,44.21 259.92,44.69 253.83,44.69 253.64,44.88 225.43,44.88 224.8,44.25 212.66,44.25 211.53,43.12 v4(209.98,43.12)
  IN2 w0.061: v4(124.52,25.91) 124.52,26.17 124.52,26.93 124.36,27.1 124.36,28.86 124.63,29.13 124.63,36.83 120.89,40.57 118.99,40.57 113.86,45.7 108.92,45.7 108.58,46.04 108.58,46.39 107.83,47.14 107.83,47.63 107.47,47.99 107.17,47.99 106.63,47.99 106.12,48.5 105.74,48.5 v4(105.41,48.82)
  IN3 w0.061: v5(105.43,48.22) 105.43,48.8 v4(105.41,48.82) ; v4(124.52,25.91) 124.52,25.33 127.45,22.41 128.93,22.41 130.36,20.98 130.36,19.75 131.36,18.75 132.11,18.75 133.02,17.85 v5(133.04,17.85) ; v4(209.98,43.12) 209.98,39.69 208.09,37.8 208.09,35.57 204.84,32.33 201.18,32.33 200.27,31.92 v5(197.12,29.64)
  BOTTOM w0.127: v5(133.04,17.85) 133.57,18.38 134.77,18.38 135.1,18.71 135.8,18.71 138.95,21.86 145.36,21.86 146.61,20.62 149.82,20.62 150.36,20.08 151.64,20.08 152.44,19.28 153.35,19.28 154.76,17.86 175.17,17.86 v1(184.11,26.8) 185.97,28.67 189.76,28.67 193.39,32.3 193.39,34.4 193.62,34.63 195.37,34.63 196.79,33.22 196.79,29.97 v5(197.12,29.64) ; v5(105.43,48.22) 105.36,48.22 UCPU1.CG12
SIO_EXT_WAKE#_EC: length 3.8
  TOP w0.102: 272.44,52.03 272.15,52.03 271.77,52.41 UE1.M12
  TOP w0.127: 272.44,52.03 274.09,50.37 RE482.2
SIO_PWRBTN#: length 305
  TOP w0.127: v2(58.56,34.66) 58.63,34.73 94.35,34.73 v1(94.36,34.74) 96.86,37.24 96.95,37.24 98.75,37.24 v2(98.95,37.44) ; v2(60.99,65.74) 61.02,65.74 61.38,66.1 RC247.1 ; v2(270.14,52.91) 270.18,52.95 270.18,53.55 UE1.K11
  IN1 w0.061: v2(60.99,65.74) 61.25,65.54 v4(61.26,65.55) ; v4(45.83,50.92) 46.46,50.92 49.89,47.48 49.89,42.33 52.99,39.24 56.89,39.24 58.53,37.6 58.53,34.69 v2(58.56,34.66) ; v4(99.46,38.11) 98.97,37.62 98.97,37.47 v2(98.95,37.44) ; v2(270.14,52.91) 269.98,53.07 269.68,53.07 269.41,52.79 269.41,52.25 268.63,51.48 268.63,51.2 268.35,50.92 267.94,50.92 267.61,50.59 265.24,50.59 265.19,50.64 264.01,50.64 263.5,50.13 263.5,49.9 263.09,49.5 262.6,49.5 261.6,48.5 260.06,48.5 v4(259.64,48.92)
  IN2 w0.061: v4(99.46,38.11) 99.85,38.11 100.74,37.22 100.74,36.05 101.02,35.76 101.02,34.47 101.11,34.38 101.11,33.42 102.27,32.26 106.77,32.26 108.38,30.65 111.3,30.65 115.9,26.06 116.16,26.06 118.85,23.37 125.25,23.37 126.1,24.22 140.04,24.22 141.82,22.44 144.34,22.44 148.61,18.18 154.4,18.18 154.66,17.91 177.15,17.91 189.23,29.99 198.14,29.99 198.5,29.63 212.79,29.63 213.48,30.33 215.73,30.33 220.49,35.08 223.05,35.08 234,46.03 246.5,46.03 248.14,47.67 250.36,47.67 251.19,48.49 259.21,48.49 v4(259.64,48.92)
  IN3 w0.061: v4(61.26,65.55) 58.91,63.19 55.1,63.19 53.76,64.53 53.19,64.53 52.23,65.5 44.06,65.5 41.96,63.4 41.96,61.2 42.21,60.94 42.21,60.81 42.37,60.65 42.37,60.45 42.13,60.2 42.13,59.55 43.11,58.57 43.11,55.92 42.78,55.59 42.78,54.34 43.07,54.05 44.56,54.05 46.21,52.4 46.21,51.3 v4(45.83,50.92)
  IN3 w0.076: v5(99.22,38.34) v4(99.46,38.11)
SIO_SLP_A#: length 43.3
  TOP w0.127: v2(99.22,34.03) 100.11,34.92 106.14,34.92 106.37,35.15 106.97,35.15 107.17,34.96 109.33,34.96 111.09,36.72 112.75,36.72 113.45,37.41 115.69,37.41 116.31,36.8 116.31,35.78 118.11,33.98 120.61,33.98 124.55,37.92 126.58,37.92 v1(127.25,37.24) 128.39,36.11 JAPS1.6
  IN1 w0.061: v2(99.22,34.03) 99.15,34.03 v4(98.92,34.26)
  IN3 w0.061: v4(98.92,34.26) 99.31,33.87 v5(99.31,32.75)
  BOTTOM w0.076: v5(99.31,32.75) 99.31,31.41 99.86,30.86 99.86,29.71 CC250.2 100.15,29.39 99.86,29.1 99.86,28.47
  BOTTOM w0.127: 99.86,28.47 99.86,28.4 100.43,27.83 RC571.2
SIO_SLP_S0#: length 165.1
  TOP w0.254: RZ23.1 RZ21.2 41.82,31.74 42.04,31.52 42.04,31.23 42.51,30.76 42.51,30.6 v2(42.6,30.51) ; v2(40.05,52.79) 40.04,52.79 39.98,52.85 PR911.1 ; JAPS1.15 128.14,40.61 127.88,40.87 127.88,41.43 127.53,41.78 v1(127.29,41.78) 127.15,41.78 126.22,40.85 126.22,40.6 v2(126.14,40.51) 125.77,40.51 125.3,40.04 122.06,40.04 121.37,39.35 120.52,39.35 120.24,39.63 118.3,39.63 117.41,38.74 110.46,38.74 108.73,37.01 106.07,37.01 105.99,36.94 105.63,36.94 105.4,36.71 102.44,36.71 102.32,36.84 100.14,36.84 99.57,36.26 97.46,36.26 v2(96.17,34.98) 94.58,33.39 51.79,33.39 v6(49.82,31.42)
  IN1 w0.061: v4(123.61,43.15) 123.91,43.15 124.66,42.4 124.66,41.98 v2(126.14,40.51)
  IN1 w0.076: v2(96.17,34.98) 96.17,34.39 v4(96.2,34.36)
  IN1 w0.254: v2(42.6,30.51) 43.29,29.82 45.08,29.82 v2(45.52,29.38) 45.52,28.96 v4(46.14,28.34) ; v4(39.57,52.39) 39.66,52.39 v2(40.05,52.79)
  IN2 w0.254: v4(39.57,52.39) 39.42,52.24 39.09,52.24 38.87,52.02 38.87,51.63 39.25,51.25 39.25,49.24 38.27,48.26 38.27,45.3 35.97,43 35.97,36.91 35.66,36.6 35.66,36.32 33.36,34.03 33.36,30.35 36.76,26.94 39.13,26.94 39.86,26.22 41.23,26.22 41.96,26.94 43.13,26.94 44.11,27.92 45.72,27.92 v4(46.14,28.34)
  IN3 w0.061: v5(95.19,28.54) 94.96,28.77 94.96,31.87 94.44,32.39 v5(94.23,32.39) 94.23,32.52 95.97,34.26 96.1,34.26 v4(96.2,34.36)
  IN3 w0.254: v5(124.01,43.3) 123.79,43.3 123.63,43.15 v4(123.61,43.15) ; v6(49.82,31.42) 49.79,31.46 48.4,31.46 46.14,29.19 v4(46.14,28.34)
  BOTTOM w0.127: RC582.2 124.34,43.39 124.11,43.39 v5(124.01,43.3) ; PR1401.1 99.88,19.83 99.61,20.11 99.61,21.38 99.33,21.66 98.58,21.66 98.39,21.85 98.39,22.61 98.17,22.83 96.48,22.83 96.48,22.83 96.46,22.83 96.42,22.87 96.41,22.87 95.9,23.38 95.9,27.83 v5(95.19,28.54) ; v5(94.23,32.39) 94.28,32.43 UCPU1.BJ37
  BOTTOM w0.254: PR1415.1 124.46,43.28 RC582.2
SIO_SLP_S3#: length 290.6
  TOP w0.127: QE4.2 103.54,67.41 104.3,68.17 105.95,68.17 v2(106.01,68.12) 106.73,67.39 108.71,67.39 v1(110.27,65.83) 111.43,64.67 v2(111.43,63.51) ; v2(102.25,34.05) 102.27,34.05 102.63,34.41 106.35,34.41 106.58,34.64 106.75,34.64 106.95,34.44 109.53,34.44 111.28,36.19 112.94,36.19 113.66,36.91 115.46,36.91 115.8,36.57 115.8,35.57 117.9,33.47 120.89,33.47 121.93,34.51 122.7,34.51 124.98,36.8 125.34,36.8 126.47,35.67 126.47,34.87 126.85,34.49 127.67,34.49 128.05,34.11 JAPS1.2 129.22,34.11 130.7,35.59 v6(130.7,36.14) ; v2(102.92,25.98) 103.31,25.58 103.31,19.32 v2(103.22,19.23) ; v2(83.69,67.82) 82.46,66.59 75.6,66.59 74.76,65.75 74.76,62.1 73.52,60.86 72.93,60.86 71.95,61.84 71.95,63.3 71.27,63.98 71.27,65.43 70.71,66 U10.2 ; U11.1 98.03,19.54 98.42,19.93 98.58,19.93 98.91,19.6 v2(98.91,19.53)
  IN1 w0.061: v2(106.01,68.12) 107.2,68.12 v4(107.58,68.49) ; v4(102.35,35.86) 102.25,35.75 v2(102.25,34.05) ; v4(70.98,75.43) 70.26,75.43 69.33,76.36 v4(63.24,76.36) ; v2(103.22,19.23) 103.14,19.14 102.39,19.14 101.94,19.59 99.97,19.59 99.77,19.39 99.05,19.39 v2(98.91,19.53) ; v2(102.92,25.98) 102.68,25.74 102.28,25.74 101.37,26.65 v4(101.37,27.06) ; v4(111.49,62.38) 111.49,63.19 111.43,63.25 v2(111.43,63.51) ; v2(83.69,67.82) v4(82.65,68.86)
  IN2 w0.061: v6(130.7,36.14) 130.86,36.31 130.86,37.08 130.1,37.85 129.8,37.85 129.22,38.44 127.86,38.44 127.65,38.65 127.65,39.84 126.6,40.89 125.02,40.89 122.2,43.72 121.21,43.72 120.05,44.88 120.05,47.78 119.28,48.55 118.63,48.55 117.94,49.25 117.94,50.08 117.55,50.46 117.55,55.51 111.49,61.57 v4(111.49,62.38) 113.15,64.04 v4(113.33,64.04) ; v4(52.41,76.12) 52.72,75.81 52.72,75.71 55.59,72.84 58.47,72.84 58.98,72.33 62.11,72.33 63.42,73.64 63.42,76.18 v4(63.24,76.36)
  IN3 w0.061: v4(113.33,64.04) 111.67,65.7 v5(111.12,65.7) ; v4(102.35,35.86) 102.37,35.84 v5(102.37,35.51) ; v4(101.37,27.06) 101.29,27.06 100.67,27.68 v5(100.67,28.2) 100.65,28.2 100.44,28.41 100.44,30.68 v5(100.11,31.01) ; v4(70.98,75.43) 70.98,75.16 71.27,74.87 71.94,74.87 72.17,75.1 72.17,75.82 72.53,76.18 76.58,76.18 77.04,75.72 77.04,72.56 77.88,71.72 77.88,69.91 78.27,69.52 78.59,69.52 79.17,68.94 80.03,68.94 80.34,69.25 82.47,69.25 82.65,69.06 v4(82.65,68.86) 82.65,66.71 83.17,66.19 83.93,66.19 85.51,64.61 85.51,63.76 86.1,63.16 v5(86.27,63.16) 86.7,63.59 88.81,63.59 91.41,66.2 100.02,66.2 102.01,68.18 107.27,68.18 v4(107.58,68.49) ; v5(22.06,62.22) 22.06,63.64 21.34,64.37 21.34,65.91 21.75,66.32 21.75,66.7 22.24,67.18 22.24,67.7 22.44,67.91 22.44,70.97 20.97,72.45 20.97,73.39 20.62,73.74 20.62,74.47 21.55,75.41 21.55,76.8 21.06,77.3 21.06,77.8 21.76,78.5 35.7,78.5 35.81,78.61 42.97,78.61 44.57,77.01 48.24,77.01 48.32,77.09 51.44,77.09 v4(52.41,76.12)
  BOTTOM w0.076: UT2.D2 19.9,56.95 20.12,57.16 20.12,57.61 20.18,57.67
  BOTTOM w0.102: 20.18,57.67 20.58,58.07 20.72,58.07 21.31,58.65 21.31,58.93 21.15,59.08 21.15,61.79 21.59,62.22 v5(22.06,62.22)
  BOTTOM w0.127: R281.1 86.5,62.93 v5(86.27,63.16) ; v5(111.12,65.7) 111.06,65.77 104.25,65.77 R280.1 ; RC569.2 101.07,27.81 v5(100.67,28.2) ; CC248.2 100.18,30.94 v5(100.11,31.01) 99.64,31.48 99.64,33.07 UCPU1.BU36 99.02,33.68 99.02,34.24 99.17,34.38 99.45,34.38 99.77,34.71 100.1,34.71 100.43,35.03 100.75,35.03 101.06,34.71 101.35,34.71 101.97,35.34 102.19,35.34 v5(102.37,35.51)
SIO_SLP_S4#: length 43.8
  TOP w0.127: v2(99.41,39.21) CC249.2 RC570.2
  IN1 w0.061: v2(99.41,39.21) 99.46,39.17 v4(99.46,38.76)
  IN3 w0.061: v4(99.46,38.76) 99.46,38.65 101.03,37.08 101.45,37.08 102.06,37.69 102.82,37.69 103.58,36.92 104.2,36.92 104.44,36.68 104.93,36.68 105.8,35.81 105.8,35.3 105.65,35.16 105.65,33.98 105.9,33.74 105.9,31.92 106.82,31 106.82,29.76 106.97,29.61 107.99,29.61 108.15,29.77 v5(108.15,30.32)
  IN3 w0.076: v5(99.22,38.99) v4(99.46,38.76)
  BOTTOM w0.127: UC19.1 126.99,32.43 126.08,33.33 126.08,34.08 125.89,34.27 125.4,34.27 RC621.1 124.48,33.84 124.48,34.32 122.9,35.91 121.98,35.91 120.65,34.58 116.5,34.58 116.06,34.14 113.13,34.14 112.74,33.75 112.74,33.11 109.94,30.32 v5(108.15,30.32)
SIO_SLP_S4#_AND: length 291.6
  TOP w0.127: v2(120.77,28.04) 120.77,28.03 120.77,27.87 121.01,27.64 123.35,27.64 123.55,27.84 U12.3 ; v6(122.45,35.26) 124.85,37.66 126.38,37.66 128.44,35.61 JAPS1.5 129.61,35.61 130.79,36.79 v2(131.32,36.79) 131.84,36.79 132.35,36.28 132.35,33.46 133.26,32.54 133.52,32.28 133.52,30.37 141.31,22.57 149.71,19.96 153.78,18.79 178.45,18.79 178.65,19 v1(183.01,23.36) 184.44,24.78 184.59,24.78 187.3,27.49 v2(187.3,27.76)
  IN1 w0.061: v4(120.62,28.35) 120.62,28.34 120.66,28.3 120.66,28.15 v2(120.77,28.04) ; v4(281.27,45.44) 278.37,45.44 276.73,43.8 276.03,43.8 272.13,39.9 267.45,39.9 266.87,39.32 265.59,39.32 264.2,40.71 251.59,40.71 248.37,43.93 232.18,43.93 231.51,44.6 225.6,44.6 224.88,43.89 218.15,43.89 217.7,43.43 217.14,43.43 216.84,43.73 212.48,43.73 211.44,42.69 210.86,42.69 210.47,42.3 205.75,42.3 196.48,33.03 196.48,31.48 195.68,30.68 190.21,30.68 v2(187.3,27.76) ; v2(131.32,36.79) 130.65,37.46 130.28,37.46 129.66,38.07 129.66,38.33 129.81,38.47 v4(129.81,38.96)
  IN2 w0.061: v4(119.43,62.81) 117.95,61.32 117.95,50.63 118.33,50.25 118.33,49.4 118.79,48.94 119.51,48.94 120.44,48 120.44,45.02 121.33,44.14 123.42,44.14 125.85,41.71 127.41,41.71 129.81,39.31 v4(129.81,38.96) ; v4(120.62,28.35) 120.62,28 120.82,27.81 122.08,27.81 122.24,27.97 122.24,30.31 122.73,30.8 122.73,34.98 v6(122.45,35.26)
  IN3 w0.061: v5(119.43,63.59) v4(119.43,62.81) ; v4(281.27,45.44) 281.06,45.23 281.06,36.03 281.45,35.64 281.45,34.06 280.26,32.86 280.26,25.89 v5(280.54,25.61)
  BOTTOM w0.127: JUSH1.3 277.06,20.4 280.54,23.88 v5(280.54,25.61) ; v6(122.45,35.26) 122.41,35.26 122.45,35.22 122.76,35.22 123.07,34.91 123.07,34.16 122.92,34 RC612.1 RC622.1 123.09,32.99 123.09,32.67 DC7.1 124.17,32.35 RC625.2 RC621.2 125.5,33.01 125.69,33.2 UC19.4 ; R248.1 103.17,64.08 104.48,65.39 117.36,65.39 119.15,63.59 v5(119.43,63.59)
SIO_SLP_S5#: length 41.9
  TOP w0.076: v2(101.51,34.13) 101.51,34.03 102.87,32.67 RC577.2
  TOP w0.127: JAPS1.4 128.44,35.11 126.21,37.34 v1(125.44,37.34) 125.13,37.34 122.55,34.77 121.82,34.77 120.78,33.72 118,33.72 116.05,35.67 116.05,36.69 115.58,37.16 113.55,37.16 112.86,36.47 111.2,36.47 109.43,34.7 107.05,34.7 106.86,34.9 106.48,34.9 106.25,34.67 102.04,34.67 v2(101.51,34.13)
  IN1 w0.061: v2(101.51,34.13) 101.48,34.16 v4(101.48,35.45)
  IN3 w0.061: v4(101.48,35.45) 100.72,36.21 100.72,36.85 100.27,37.31 98.7,37.31 v5(98.31,37.69)
SIO_SLP_SUS#: length 192.6
  IN1 w0.061: v4(262.71,49.14) 262.71,48.84 v2(262.61,48.74)
  IN2 w0.061: v4(262.71,49.14) 262.04,48.47 259.37,48.47 259.27,48.37 251.24,48.37 250.42,47.54 248.2,47.54 246.56,45.9 234.05,45.9 220.47,32.33 218.81,32.33 216.68,30.2 213.53,30.2 212.84,29.51 198.44,29.51 198.09,29.86 189.28,29.86 177.2,17.79 154.61,17.79 154.34,18.05 148.55,18.05 144.29,22.31 141.76,22.31 139.99,24.09 128.3,24.09 127.78,23.57 125.81,23.57 125.36,23.11 118.69,23.11 116.26,25.55 v4(116.05,25.55) 111.2,30.4 108.28,30.4 106.67,32.01 102.16,32.01 100.39,33.78 100.39,34.18 100.89,34.68 100.89,35.71 100.61,36 100.61,37.17 100.12,37.66 v4(99.73,37.66)
  IN3 w0.061: v4(116.05,25.55) 116.05,25.55 116.7,26.19 v5(117.27,26.19)
  IN3 w0.076: v5(99.22,37.69) 99.25,37.66 v4(99.73,37.66)
  BOTTOM w0.127: v5(117.27,26.19) 117.28,26.21 RC599.1 117.5,26.6 117.97,27.07 RC573.2 CC252.2
SIO_SLP_SUS#_R: length 5.3
  TOP w0.127: RE113.1 262.61,48.05 263,48.44 263,49.04 262.71,49.33 RE115.2 262.61,49.59 263.53,50.51 263.94,50.51 UE1.N4
SIO_SLP_WLAN#: length 193.5
  TOP w0.127: QN2.1 254.06,48.7 253.78,48.42 v2(253.78,48.15) ; RC572.2 CC251.2 101.98,29.9 101.93,29.95 101.93,32.41 100.67,33.67 v1(99.57,33.67) 98.93,33.67 98.49,34.12 v2(98.14,34.12) ; QN6.3 251.96,47.87 v2(251.8,48.02)
  IN1 w0.061: v4(251.39,47.93) 251.48,48.02 v2(251.8,48.02) 251.98,48.2 253.73,48.2 v2(253.78,48.15) ; v4(98.79,36.54) 98.72,36.54 98,35.83 98,35.59 97.59,35.17 97.59,34.7 98.14,34.14 v2(98.14,34.12)
  IN2 w0.061: v4(251.39,47.93) 250.87,47.41 248.31,47.41 246.64,45.75 234.08,45.75 220.53,32.2 218.86,32.2 216.74,30.07 213.59,30.07 212.89,29.38 198.39,29.38 198.04,29.74 189.33,29.74 177.26,17.66 154.53,17.66 154.26,17.92 148.5,17.92 144.24,22.19 141.71,22.19 139.94,23.96 128.35,23.96 127.83,23.44 125.87,23.44 125.41,22.99 118.63,22.99 116.39,25.24 115.92,25.24 110.89,30.27 108.22,30.27 106.61,31.88 102.11,31.88 100.26,33.73 100.26,34.23 100.77,34.73 100.77,35.56 100.48,35.85 100.48,37.08 100.25,37.31 99.33,37.31 98.79,36.77 v4(98.79,36.54)
  IN3 w0.076: v4(98.79,36.54) 98.79,36.56 v5(98.31,37.04)
SKTOCC#: length 5.8
  BOTTOM w0.127: v1(64.01,58.44) 64.35,58.11 65.38,58.11 65.47,58.19 65.47,58.37 RC223.2 65.7,58.38 65.7,58.17 65.84,58.03 65.84,56.82 UCPU1.E1
SLEEVE:
  vias: v1(290.41,22.78)
SLEEVE_CONN: length 3.4
  TOP w1.016: 305.57,23.23 307.24,23.23 JHP1.3
  vias: v1(294.63,22.51) v2(293.93,23.13) v2(294,22.83) v2(294.21,23.13) v2(303.63,24.4) v2(303.63,24.02) v2(304.01,24.02)
SLP_LAN#: length 7.5
  IN1 w0.061: v2(99.4,30.13) 99.5,30.13 100.24,30.87 100.24,33.44 99.29,34.39 99.29,35.04 98.86,35.47 98.86,35.84 v4(98.7,36.01)
  IN3 w0.076: v5(98.31,36.39) v4(98.7,36.01)
SLP_WLAN#_GATE: length 24.7
  TOP w0.102: v2(269.43,53.32) 269.84,53.72 UE1.K10
  TOP w0.127: RN70.2 252.88,46.72 QN2.2 253.41,49.82 253.35,49.88 v2(253.35,50.22) 253.48,50.35 v1(254.27,50.35)
  IN1 w0.061: v2(269.43,53.32) 269.27,53.16 269.27,52.29 268.47,51.48 268.16,51.48 267.53,50.85 265.61,50.85 265.36,51.11 264.04,51.11 263.93,51.22 263.41,51.22 263.3,51.11 262.87,51.11 261.54,49.77 254.93,49.77 254.49,50.22 v2(253.35,50.22)
SM_PG_CTRL: length 13.7
  BOTTOM w0.127: PU600.2 51.01,26.17 51.18,26.33 51.6,26.33 51.79,26.52 51.79,27.51 52.26,27.98 52.26,28.47 52.74,28.95 54.22,28.95 55.24,27.92 v1(55.69,27.92) 55.99,27.92 56.32,28.25 RE241.2 56.69,29.06 57,29.36 UC9.4 58.15,29.36 58.59,28.92 60.41,28.92 RC383.2
SM_RCOMP0: length 1.9
  IN1 w0.305: v4(96.1,38.6) 96.02,38.68 96.02,39.56 95.99,39.6 v2(95.99,39.92)
  IN3 w0.305: v4(96.1,38.6) 96.1,38.6 96.36,38.34 v5(96.49,38.34)
SM_RCOMP1: length 1.9
  TOP w0.305: v2(96.42,38.96) 96.57,39.11 RC12.1
  IN1 w0.305: v2(96.42,38.96) 96.52,39.06 96.52,39.3 v4(96.58,39.36)
  IN3 w0.305: v4(96.58,39.36) 96.58,39.09 v5(96.49,38.99)
SM_RCOMP2: length 2.5
  TOP w0.305: RC13.1 v2(97.13,39.46)
  IN1 w0.305: v4(96.94,38.12) 97.13,38.31 v2(97.13,39.46)
  IN3 w0.305: v5(96.49,37.69) 96.51,37.69 v4(96.94,38.12)
SML0_SMBCLK: length 0.8
  IN1 w0.061: v4(106.01,47.69) 105.98,47.6 v2(105.72,47.49)
  IN3 w0.076: v5(105.79,47.39) 106.01,47.61 v4(106.01,47.69)
SML0_SMBDATA: length 1.7
  TOP w0.127: RC581.1 v1(103.47,46.46)
  IN1 w0.061: v2(104.38,46.41) 104.55,46.41 v4(104.72,46.59)
  IN3 w0.076: v5(104.49,46.35) v4(104.72,46.59)
SML0B_SMBCLK: length 0.8
  TOP w0.127: RC595.1 108.45,41.54 v2(108.45,41.53)
  IN1 w0.061: v4(108.6,41.85) 108.45,41.71 v2(108.45,41.53)
  IN3 w0.061: v5(108.72,41.54) 108.72,41.73 v4(108.6,41.85)
SML0B_SMBDATA: length 2.7
  TOP w0.127: RC594.1 107.81,40.91 v2(107.75,40.98) 107.72,40.98 v1(107.28,41.42)
  IN1 w0.061: v4(108.22,40.63) 107.89,40.96 107.77,40.96 v2(107.75,40.98)
  IN3 w0.061: v4(108.22,40.63) 108.19,40.61 108.11,40.61 v5(107.75,40.97)
SML1_SMBCLK: length 231.6
  TOP w0.127: v2(269.44,57.91) 269.44,58.25 269.28,58.41 268.62,58.41 268.24,58.79 UE1.D8
  IN1 w0.061: v4(112.89,34.18) 112.74,34.18 112.62,34.07 112.62,33.93 112.89,33.66 112.89,33 113.13,32.76 113.26,32.76 114.63,31.38 116.05,31.38 116.95,30.47 118.17,30.47 118.38,30.68 124.7,30.68 125.42,29.96 127.54,29.96 129.57,27.92 129.83,27.54 131.43,25.54 133.58,23.17 134.24,21.89 139.2,16.92 148.88,13.48 155.63,11.9 156.34,11.7 156.59,11.65 156.6,11.64 156.82,11.58 178.17,11.58 182.35,15.76 198.97,15.76 199.19,15.98 199.19,15.98 201.31,18.11 206.86,18.11 210.07,21.32 210.07,24.1 212.66,26.69 215.74,26.69 218.68,29.62 220.09,29.62 220.53,30.07 230.06,30.07 230.69,29.43 230.69,27.05 234.23,23.51 252.41,23.51 255.81,26.91 259.24,26.91 260.31,27.99 260.31,28.96 262.06,30.71 267.37,30.71 267.65,30.43 268.91,30.43 269.04,30.56 269.04,30.74 v4(268.87,30.9) ; v2(269.44,57.91) 269.44,57.77 v4(269.61,57.6)
  IN3 w0.061: v4(269.61,57.6) 269.85,57.36 269.85,57.02 272.46,54.41 272.46,51.11 271.12,49.77 271.12,35.64 271.03,35.56 271.03,33.71 269.02,31.71 269.02,31.06 v4(268.87,30.9) ; v5(110.09,46.07) 110.2,45.96 110.2,43.91 111.01,43.09 111.01,40.72 111.19,40.54 111.19,37.74 111.69,37.24 111.69,35.68 111.99,35.37 111.99,34.55 112.36,34.18 v4(112.89,34.18)
  BOTTOM w0.076: v5(110.09,46.07) 110.01,46.07 109.74,46.33 109.22,46.33 108.96,46.58 UCPU1.CN15
  BOTTOM w0.127: v5(110.09,46.07) 110.22,46.2 111.1,46.2 111.37,46.46 111.6,46.46 RC23.1
SML1_SMBDATA: length 231.2
  IN1 w0.061: v4(112.51,34.56) 112.51,34.22 112.43,34.14 112.43,33.85 112.7,33.58 112.7,32.92 113.06,32.57 113.18,32.57 114.56,31.19 115.97,31.19 116.88,30.29 118.25,30.29 118.45,30.49 124.62,30.49 125.34,29.77 127.46,29.77 129.43,27.8 129.55,27.62 129.55,27.62 129.68,27.43 131.29,25.42 133.42,23.07 134.08,21.78 139.1,16.76 148.83,13.29 155.58,11.71 156.3,11.52 156.55,11.46 156.76,11.4 156.78,11.4 156.8,11.4 178.25,11.4 182.42,15.57 199.04,15.57 199.37,15.9 199.37,15.9 201.39,17.92 206.94,17.92 210.26,21.24 210.26,24.02 212.74,26.5 215.82,26.5 218.76,29.43 220.17,29.43 220.61,29.88 229.98,29.88 230.5,29.36 230.5,26.97 234.15,23.32 252.49,23.32 255.89,26.72 259.32,26.72 260.5,27.91 260.5,28.89 262.14,30.52 267.3,30.52 267.58,30.24 268.98,30.24 269.22,30.48 269.22,30.75 v4(269.4,30.93) ; v2(270.64,58.01) v4(270.37,57.74)
  IN3 w0.061: v4(112.51,34.56) 112.33,34.56 112.18,34.71 112.18,35.45 111.87,35.76 111.87,37.32 111.38,37.81 111.38,40.62 111.2,40.8 111.2,43.17 110.38,43.99 110.38,46.21 110.17,46.43 110.12,46.43 v5(110.1,46.45) ; v4(269.4,30.93) 269.21,31.12 269.21,31.63 271.22,33.64 271.22,35.48 271.31,35.57 271.31,49.69 272.65,51.03 272.65,54.48 270.04,57.1 270.04,57.41 v4(270.37,57.74)
  BOTTOM w0.076: UCPU1.CM15 108.35,46.87 109.63,46.87 110.05,46.45 v5(110.1,46.45)
  BOTTOM w0.127: v5(110.1,46.45) 111,46.45 111.48,46.93 RC25.1
SMOKE_OVP: length 4.3
  TOP w0.127: PR1503.1 89.24,69.63 88.06,70.81 v1(88.06,71.61) 88.06,72.03 87.82,72.27 PR1514.2
SMOKE_UVP: length 3.8
  TOP w0.127: PR1505.2 39.53,33.15 PR1501.1 39.53,33.83 PD1500.1 38.32,35.05 PD1501.1
SNK0_CONFIG1: length 2.1
  TOP w0.127: v2(24.28,56.15) 24.28,56.72 24.68,57.12 RT94.1
  IN1 w0.061: v2(24.28,56.15) 24.25,56.15 v4(24,56.41)
  IN3 w0.076: v5(24.23,56.17) v4(24,56.41)
SNUB_1.0V: length 1.8
  TOP w0.127: PC800.1 123.16,59.05 v1(124.27,60.15)
SNUB_1.8VPRIM: length 1.2
  BOTTOM w0.508: PC512.1 108.64,21.52 PR506.2
SNUB_CHG1: length 3.1
  TOP w0.127: PC236.2 26.29,30.42 v1(26.75,30.88)
  TOP w0.508: PR215.2 25.73,29.42 25.92,29.61 PC236.2
SNUB_CHG2: length 2.9
  TOP w0.127: v1(31.49,29.61) PC237.1
  TOP w0.508: PR216.2 32.87,29.76 PC237.1
SNUB_CORE1: length 1.1
  TOP w0.508: PC1007.1 80.27,72.02 PR1003.2
SNUB_CORE2: length 3.8
  TOP w0.127: v1(102.34,68.2) 103.61,68.2 104.21,68.81 104.21,69.24 PR1012.2
  TOP w0.508: PR1012.2 104.19,69.4 103.94,69.65 PC1022.1
SNUB_GT: length 1.4
  TOP w0.127: PC1107.1 46,45.06 v1(46.51,44.56)
SNUB_PRIM_CORE: length 2.2
  BOTTOM w0.127: PC1411.1 120.17,49.3 v1(119.85,49.62)
  BOTTOM w0.508: PR1417.2 120.82,48.62 PC1411.1
SNUB_VCCIO: length 1
  BOTTOM w0.508: PR1407.2 101.69,23.82 PC1408.1
SOLC: length 5.9
  TOP w0.127: UE1.N6 266.62,51.59 266.62,50.18 266.46,50.02 266.46,48.32 265.12,46.98 RV23.1
SOLC_R: length 152.8
  TOP w0.127: v1(264.9,44.86) 264.51,45.24 v2(264.51,45.34) RV85.1 RV23.2
  IN1 w0.061: v4(264.15,45.47) 264.39,45.47 v2(264.51,45.34)
  IN2 w0.061: v4(264.15,45.47) 264.02,45.34 261.58,45.34 261.22,45.71 253.61,45.71 252.66,44.76 250.54,44.76 249.82,44.04 247.88,44.04 247.46,44.45 237.11,44.45 231.54,38.88 228.83,38.88 221,31.06 220.34,31.06 215.87,26.59 208.03,26.59 206.64,27.98 197.81,27.98 197.45,28.34 189.91,28.34 177.84,16.26 153.95,16.26 153.68,16.53 147.92,16.53 143.66,20.79 141.1,20.79 139.42,22.47 134.68,22.47 133.54,21.33 132.09,21.33 v4(131.89,21.13)
  IN3 w0.061: v5(131.86,20.58) 131.86,21.1 v4(131.89,21.13)
  BOTTOM w0.127: JCAM1.3 131.7,20.74 v5(131.86,20.58)
SP7_SDWP: length 6
  TOP w0.127: UR1.29 292.89,37.85 292.64,38.1 292.64,40.97 QR1.1 v1(292.83,43.19)
SPI_CLK_VROM0: length 3.1
  TOP w0.127: v3(103.02,15.46) 103.9,14.59 RC474.1 104.15,14.62 UC18.6 U27.6
SPI_IO2_VROM0: length 1.5
  TOP w0.127: RC476.1 113.99,14.62 UC18.3 U27.3
SPI_IO3_VROM0: length 1.6
  TOP w0.127: RC477.1 104.15,13.35 UC18.7 U27.7
SPI_SI_VROM0: length 4.7
  TOP w0.127: U27.5 UC18.5 104.58,15.89 104.55,15.86 RC473.1 103.9,15.86 103.67,16.08 103.67,17.23 104.27,17.83 v3(104.85,17.83)
SPI_SO_VROM0: length 2.6
  TOP w0.127: U27.2 UC18.2 113.71,13.35 114.06,13.7 RC475.1 114.34,12.78 v1(114.26,12.71)
SPK-L+: length 30.9
  TOP w0.127: v6(297.33,11.58) v1(298.11,11.58)
  IN1 w1.016: 283.55,27.37 283.06,26.88 281.12,26.88 280.4,26.16 280.4,21.81 281.14,21.08 282.03,21.08 283.08,20.02 283.08,17.16 283.86,16.38 288.49,16.38 290.5,14.37 295.2,14.37 297.03,12.54
  vias: v6(283.57,29.37) v6(283.57,28.81) v6(296.62,11.58)
SPK-L-: length 30.7
  TOP w0.127: v6(295.24,11.59) v1(295.96,11.59)
  IN1 w1.016: 282.55,28.06 280.41,28.06 279.04,26.69 279.04,21.44 280.4,20.08 280.4,17.99 283.5,14.89 287.92,14.89 290.17,12.64 294.79,12.64
  vias: v6(282.97,29.39) v6(282.99,28.83) v6(294.67,11.58)
SPK-R+: length 27.2
  TOP w0.127: v6(291.06,11.58) v1(290.09,11.58)
  IN2 w1.016: 291.44,12.34 289.79,13.99 282.8,13.99 280.4,16.39 280.4,20.11 279.12,21.39 279.12,26.96 280.82,28.66
  vias: v6(281.72,29.48) v6(281.72,28.91) v6(291.69,11.58)
SPK-R-: length 26.3
  TOP w0.127: v6(292.96,11.58) v1(292.3,11.58)
  IN2 w1.016: 293.24,12.49 290.22,15.51 283.69,15.51 282.61,16.59 282.61,20.13 281.68,21.07 281.08,21.07 280.33,21.82 280.33,26.45 281.41,27.53 282,27.53
  vias: v6(282.33,29.48) v6(282.33,28.91) v6(293.6,11.58)
SPK_DET#: length 233.8
  TOP w0.127: v6(211.89,30.3) 211.89,27.59 214.07,25.4 214.07,22.05 213.83,21.82 213.83,20.32 215.01,19.14 217.66,19.14 217.91,18.9 v1(217.91,16.74) 217.91,16.48 217.04,15.61 v2(217.04,13.99) ; v2(299.99,11.78) 298.58,11.78 297.95,12.41 297.95,15.33 297.17,16.11 RA109.1
  IN1 w0.061: v2(217.04,13.99) 218.78,12.25 224.89,12.25 226.49,10.65 249.99,10.65 252.61,13.28 261.05,13.28 262.09,12.23 278.61,12.23 279.64,11.19 289.65,11.19 290.18,10.66 298.87,10.66 v2(299.99,11.78)
  IN2 w0.061: v6(211.89,30.3) 211.48,29.89 198.6,29.89 198.25,30.24 189.12,30.24 177.04,18.17 154.77,18.17 154.5,18.43 148.71,18.43 144.45,22.7 141.92,22.7 139.46,25.16 131.84,25.16 131.15,24.47 125.99,24.47 125.63,24.11 123.34,24.11 122.89,24.55 119.7,24.55 115.23,29.03 114.55,29.03 109.16,34.43 v4(107.64,34.43)
  IN3 w0.061: v5(107.95,34.87) 107.95,34.74 v4(107.64,34.43)
  BOTTOM w0.127: UCPU1.CK34 106.75,34.33 107.49,34.33 107.58,34.23 107.79,34.23 107.99,34.44 107.99,34.82 v5(107.95,34.87)
SPK_DET#_R: length 2.9
  TOP w0.127: RA109.2 RA110.2 296.37,16.85 v6(296.37,17.32) 296.76,17.71 v1(296.85,17.71)
  BOTTOM w0.127: JSPK1.5 296.57,17.12 v6(296.37,17.32)
SPK_OUT_L+: length 2.8
  TOP w0.127: v6(296.34,15.39) 296.34,15.58 295.88,16.03 295.88,16.11 v3(294.58,17.41)
  vias: v6(296.92,15.36)
SPK_OUT_L-:
  vias: v3(295.22,15.87) v6(294.97,15.39) v6(295.55,15.39)
SPK_OUT_R+:
  vias: v3(291.34,15.96) v6(291.9,15.93) v6(292.47,15.93)
SPK_OUT_R-:
  vias: v3(293.45,16.02) v6(293.09,15.51) v6(293.72,15.51)
SPKR: length 219.4
  TOP w0.127: v2(211.53,22.13) 211.37,21.96 211.37,21.55 v1(208.96,19.14) 207.85,18.03 201.64,18.03 199.74,19.93 197.66,19.93 194.14,16.41 182.96,16.41 180.51,13.96 152.14,13.96 151.08,14.12 150.44,14.32 146.2,15.64 138.12,15.64 134.16,19.6 v2(125.4,19.6)
  IN1 w0.061: v2(291.63,28.09) 291.1,28.61 291.1,30.08 287.5,33.69 278.91,33.69 273.99,28.77 262.55,28.77 262.36,28.59 262.32,28.59 260.11,26.37 257.44,26.37 253.46,22.39 239.64,22.39 239.16,22.86 233.91,22.86 229.05,27.72 222.17,27.72 221.49,28.41 219.78,28.41 216.34,24.97 212.43,24.97 211.15,23.69 211.15,22.51 v2(211.53,22.13) ; v2(125.4,19.6) 125.4,20.58 122.83,23.15 119.64,23.15 118.79,23.99 115.02,23.99 111.83,27.18 111.23,27.18 109.98,28.43 107.04,28.43 106.52,28.95 106.16,28.95 v4(104.38,30.73)
  IN3 w0.061: v5(103.91,31.05) 104.06,31.05 v4(104.38,30.73)
  BOTTOM w0.076: UCPU1.CF35 104.34,33.99 103.85,33.5 103.54,33.5 103.44,33.39 103.44,33.21 103.49,33.02 103.56,32.92 103.56,32.5 103.17,32.11 103.17,31.22 103.34,31.05 v5(103.91,31.05)
  BOTTOM w0.127: v5(103.91,31.05) 103.92,31.04 RC118.1
SRTCRST#: length 6.7
  TOP w0.127: v2(97.41,29.34) CLME1.2
  IN1 w0.061: v2(97.41,29.34) 97.73,29.67 v4(98.63,29.67)
  IN3 w0.061: v4(98.63,29.67) 98.9,29.39 v5(98.91,29.39)
  BOTTOM w0.076: v5(98.91,29.39) 98.6,29.7 98.6,30.32 CC9.1 98.65,30.88 98.65,32.19 UCPU1.BR37
SSD_EN: length 4.6
  TOP w0.127: v1(227.56,56.91) 227.56,56.32 R268.2 226.88,55.94 U32.4 225.81,56.42 224.81,57.41 U8.3
SSD_PCIE_WAKE#: length 3.2
  TOP w0.127: v1(214.63,51.33) v6(213.97,51.33) 213.91,51.39 RN24.1 RN25.1
  BOTTOM w0.127: JNGFF2.54 213.93,51.36 v6(213.97,51.33)
SSD_SCP#: length 72.9
  TOP w0.127: v2(267.02,53.68) 267.01,53.67 267.01,53.59 266.64,53.22 UE1.L6 266.2,52.77 266.2,50.49 265.91,50.2 RE141.1 ; v2(229.2,53.21) 229.2,59.25 v1(228.38,60.07) 223.29,65.16 216.85,65.16 214.42,62.72 214,62.72 213.71,63.01 RN98.2
  IN1 w0.061: v2(267.02,53.68) 267.02,53.88 266.33,54.57 266.33,54.73 266,55.06 262.75,55.06 261.73,54.04 259.98,54.04 259.66,54.37 258.43,54.37 257.01,55.79 254.68,55.79 254.39,56.08 247.7,56.08 245.95,57.83 236.82,57.83 232.19,53.21 v2(229.2,53.21)
SSD_SCP#_R: length 4.7
  TOP w0.127: v6(214.3,63.16) 214.04,63.42 212.8,63.42 212.53,63.15 RN98.1 v1(212.53,61.99)
  BOTTOM w0.127: JNGFF2.8 214,62.86 v6(214.3,63.16)
SSD_SCP_PWR_EN: length 43
  TOP w0.102: UE1.M1 v2(262.64,52.41)
  TOP w0.127: v2(225.72,51.66) v1(225.72,52.6) 225.72,53.03 225.36,53.38 R267.1 224.9,54.2 U32.1
  IN1 w0.061: v2(262.64,52.41) 261.86,51.63 261.02,51.63 260.46,51.07 259.65,51.07 259.37,51.35 259.37,51.95 259.13,52.19 258.37,52.19 257.36,51.18 249.46,51.18 249.23,51.41 246.22,51.41 245.22,50.41 228.81,50.41 228.15,51.06 226.31,51.06 v2(225.72,51.66)
SSD_SUSCLK: length 3
  TOP w0.127: RN27.1 211.63,47.9 v6(211.61,47.92) v1(210.82,47.92)
  BOTTOM w0.127: v6(211.61,47.92) 211.81,47.92 211.87,47.86 JNGFF2.68
SSO_EN#_R: length 25.2
  TOP w0.127: v3(306.48,67.87) v6(307.29,68.67) ; Q15.1 296.42,71.78 296.3,71.66 R219.2 v2(295.72,70.92)
  IN1 w0.061: v6(307.29,68.67) 304.57,65.95 296.43,65.95 295.72,66.67 v2(295.72,70.92)
  BOTTOM w0.127: JFP1.1 311.14,67.82 310.29,68.67 v6(307.29,68.67)
SUS_ON_EC: length 165.8
  TOP w0.127: RE534.2 255.45,57.79 254.47,57.79 253.83,58.43 v1(251.93,58.43) 249.57,58.43 247.03,55.89 v6(247.03,55.23)
  IN2 w0.061: v4(246.57,47.3) 246.4,47.14 237.73,47.14 236.83,48.04 231.9,48.04 220.19,36.32 218.75,36.32 215.89,33.46 215.89,33.01 214.97,32.09 214.58,32.09 213.73,32.94 210.17,32.94 209.45,32.22 199.33,32.22 198.56,31.46 188.62,31.46 176.54,19.38 155.27,19.38 155.01,19.65 149.22,19.65 144.95,23.91 142.43,23.91 139.86,26.47 130.76,26.47 130.51,26.72 128.79,26.72 128.74,26.77 127.53,26.77 127.18,26.42 125.39,26.42 124.64,27.18 124.64,28.78 125.16,29.3 v4(125.16,31.03)
  IN3 w0.061: v5(125.7,31.03) 125.16,31.03 v4(125.16,31.03) ; v4(246.57,47.3) 247.18,47.91 247.18,55.07 v6(247.03,55.23)
  BOTTOM w0.127: v5(125.7,31.03) 126.1,31.03 126.34,31.27 UC19.2 126.34,32.14 126.19,32.29 125.47,32.29 124.95,31.77 RC625.1
SUS_ON_EC_R: length 7.8
  TOP w0.127: UE1.D2 v2(263.04,58.74)
  IN1 w0.061: v2(263.04,58.74) 262.38,58.74 262.06,58.43 262.06,58.17 261.63,57.74 256.62,57.74 v2(256.3,58.06)
SUSCLK: length 252.3
  TOP w0.112: v2(274.4,27.48) 274.29,27.58 RN13.2 ; v2(219.95,27.2) 219.95,27.35 219.98,27.37 RN48.2 219.98,28.38 217.92,30.44 217.92,44.38 220.9,47.36 v2(221.02,47.36) ; v2(98.4,33.74) 98.82,33.32 100.68,33.32 101.68,32.31 101.68,28.93 101.94,28.67 RC57.1 ; RN27.2 213.36,48.14 v1(214.21,48.14) 214.53,48.14 v2(214.77,47.9)
  IN1 w0.074: v2(214.77,47.9) 220.48,47.9 v2(221.02,47.36) ; v2(274.4,27.48) 274.06,27.81 262.95,27.81 260.91,25.76 260.91,25.09 257.44,21.62 239.31,21.62 238.84,22.09 233.58,22.09 228.78,26.89 221.75,26.89 221.12,27.53 220.28,27.53 v2(219.95,27.2) 219.49,26.74 219.49,26.08 217.01,23.6 214.48,23.6 208.58,17.7 201.71,17.7 198.07,14.05 183.5,14.05 v4(183.08,13.63) ; v4(98.55,35.51) 98.4,35.36 v2(98.4,33.74)
  IN3 w0.074: v5(98.31,35.74) v4(98.55,35.51) 98.83,35.51 100.12,34.22 100.12,31.54 100.56,31.1 100.56,28.82 100.94,28.45 100.94,27.75 101.29,27.4 101.7,27.4 101.84,27.26 101.84,27.03 102.13,26.74 102.13,22.49 101.88,22.23 101.88,19.7 102.25,19.33 102.25,18.64 104.31,16.58 104.66,16.58 105.4,17.32 110.35,17.32 110.59,17.08 114.18,17.08 114.44,17.33 119.8,17.33 120.83,18.37 128.65,18.37 130.62,16.4 130.62,15.88 v5(134.52,11.98) ; v5(182.19,13.67) 182.23,13.71 183.01,13.71 v4(183.08,13.63)
  BOTTOM w0.112: v5(134.52,11.98) 134.8,11.7 141.03,11.7 141.88,12.55 180.88,12.55 181.15,12.82 181.89,12.82 182.19,13.12 v5(182.19,13.67)
SX9310_CS0: length 2.3
  BOTTOM w0.127: RS8.2 RS9.2 202.17,69.23 201.61,68.67 U16.A3
SX9310_CS0_R: length 2
  BOTTOM w0.127: v1(203.92,69.63) 203.68,69.87 RS8.1 202.89,70.33 LS3.2
SX9310_CS2: length 4.8
  TOP w0.127: v2(199,68.46) 199,68.67 198.77,68.9 197.84,68.9 197.61,69.13 197.61,69.79 v1(198.18,70.36)
  IN1 w0.061: v2(199,68.46) 199.77,68.46 200.01,68.7 v4(200.04,68.7)
  IN3 w0.061: v5(200.43,68.67) 200.4,68.7 v4(200.04,68.7)
SX9310_CS2_R: length 0.8
  TOP w0.127: RS15.1 198.41,67.69 LS6.2
SYNC: length 127.5
  TOP w0.127: PR1107.1 129.29,69.14 127.29,69.14 126.92,68.78 124.88,68.78 123.86,69.79 121.17,69.79
  TOP w0.152: v2(112.03,69.65) 112.04,69.64 112.97,69.64 113.92,70.59 119.98,70.59 120.78,69.79 121.17,69.79
  TOP w0.203: v2(75.22,75.84) 75.24,75.85 75.71,75.85 75.86,75.71 75.86,74.82 78.62,72.05 78.62,70.38 78.83,70.17 78.83,70.02 v6(79.18,69.68)
  IN1 w0.152: v2(75.22,75.84) 75.5,75.56 75.5,75.15 75.7,74.95 78.4,74.95 78.7,75.25 78.7,75.63 79.16,76.09 87.55,76.09 88.14,75.5 88.62,75.5 91.48,72.63 94.37,72.63 97.92,76.18 107.49,76.18 107.67,76 107.67,72.66 111.1,69.23 111.84,69.23 112.03,69.42 v2(112.03,69.65)
  IN3 w0.152: v5(43.86,55.02) 43.84,55.04 43.84,62.25 43.72,62.37 43.72,62.96 44.67,63.9 51.6,63.9 52.62,62.88 53.3,62.88 54.65,61.53 55.29,61.53 55.81,61.01 62.26,61.01 63.35,62.1 64.58,62.1 v5(64.86,62.38)
  BOTTOM w0.127: PR1102.1 41.67,53.34 42.91,54.58 43.42,54.58 v5(43.86,55.02) 43.99,55.14 PU900.34
  BOTTOM w0.152: v5(64.86,62.38) 64.88,62.38 65.16,62.65 65.16,63.29 66.69,64.81 75.69,64.81 79.04,68.17 79.04,69.54 v6(79.18,69.68)
SYNC_CORE1: length 2.4
  IN1 w0.254: v4(73.6,75.43) 73.98,75.81 v2(74.31,75.81)
  IN3 w0.203: v4(73.6,75.43) v5(73.21,75.43)
  BOTTOM w0.203: v5(73.21,75.43) v4(73.6,75.43) 73.74,75.29 PU1000.10
SYNC_CORE2: length 1.7
  IN1 w0.254: v4(112.37,70.19) 112.37,70.24 v2(112.03,70.58)
  IN3 w0.203: v4(112.37,70.19) 112.03,70.19 v5(112.01,70.16)
  BOTTOM w0.203: PU1001.10 v5(112.01,70.16)
SYNC_GT: length 1.5
  BOTTOM w0.254: PR1102.2 41.67,51.78 42.19,51.25 PU1100.10
SYNC_SA: length 2.3
  IN1 w0.254: v4(130.21,67.79) 130.18,67.81 130.18,68.33 130.37,68.52 v2(130.78,68.52)
  IN3 w0.254: v4(130.21,67.79) 130.56,67.79 v5(130.57,67.77)
  BOTTOM w0.203: PU1101.8 130.46,67.66 v5(130.57,67.77)
SYS_PRES#: length 131
  TOP w0.127: v2(113.26,10.41) 113.17,10.32 102.78,10.32 102.37,10.72 102.37,11.66 101.97,12.06 v6(46.61,12.06) ; v2(116.17,14.23) 116.03,14.37 116.03,15.86 116.09,15.91 116.09,17.91 113.71,20.29 113.71,21.77 113.91,21.97 113.91,25.48 113.71,25.67 v3(113.71,29.1) 113.71,31.53 112.27,32.98 v6(112.27,33.46)
  IN1 w0.061: v2(116.17,14.23) 116.07,14.23 114.91,13.07 114.91,12.06 v2(113.26,10.41)
  BOTTOM w0.127: PU700.5 124,40.06 123.86,39.92 123.29,39.92 PR705.1 122.73,39.36 118.31,39.36 117.02,38.07 117.02,35.53 115.89,34.4 113,34.4 112.26,33.65 112.26,33.47 v6(112.27,33.46) ; JBATT1.7 37.07,20.39 36.19,19.51 36.19,12.23 37.05,11.37 45.92,11.37 v6(46.61,12.06)
SYS_PWROK: length 259.9
  TOP w0.127: RE158.1 RE147.1 257.31,53.94 v2(257.01,53.94) ; v6(246.63,49.39) v3(245.97,49.39) ; v2(59.05,68.32) 59.22,68.32 59.5,68.04 59.5,66.46 59.14,66.1 RC370.1
  IN1 w0.061: v2(59.05,68.32) 58.7,68.38 v4(58.68,68.36) ; v4(88.58,59.15) 88.95,59.52 91.33,59.52 92.09,60.28 96.13,60.28 96.34,60.06 96.34,59.6 v4(96.53,59.41) ; v4(253.76,54.06) 254.05,53.76 256.83,53.76 v2(257.01,53.94)
  IN2 w0.061: v4(96.53,59.41) 96.92,59.02 97.66,59.02 98.11,59.47 101.8,59.47 102.1,59.17 102.84,59.17 103.14,59.47 105.63,59.47 105.81,59.29 109.99,59.29 110.37,58.91 110.37,57.83 107.33,54.79 106.6,54.79 106.3,54.49 106.3,52.79 107.8,51.29 108.29,51.29 v4(109.44,50.15) 109.61,49.97 113.8,49.97 115.93,47.84 119,47.84 119.35,47.49 119.35,44.59 120.92,43.02 121.91,43.02 130.26,34.67 133.19,34.67 142.96,24.9 145.36,24.9 149.62,20.63 155.47,20.63 155.73,20.38 176.11,20.38 189.51,33.78 189.51,34.06 190.15,34.71 190.5,34.71 192.73,34.71 193.13,34.31 193.13,33.89 193.31,33.71 194.25,33.71 197.67,37.13 204.82,37.13 205.13,36.82 205.13,36.64 205.45,36.31 206.31,36.31 207.94,37.94 213.52,37.94 213.84,38.26 216.52,38.26 222.33,44.07 227.05,44.07 231.67,48.68 245.92,48.68 v6(246.63,49.39) 246.63,49.86 250.6,53.83 253.53,53.83 v4(253.76,54.06)
  IN3 w0.061: v5(58.34,71.27) 58.64,70.97 59.98,70.97 60.31,71.3 62.3,71.3 63.71,72.71 68.97,72.71 74.29,67.39 76.47,67.39 78.55,65.31 79.86,65.31 86.49,58.68 88.11,58.68 v4(88.58,59.15) ; v5(109.7,49.75) 109.44,50.01 v4(109.44,50.15) ; v5(58.34,68.39) 58.37,68.36 v4(58.68,68.36)
  BOTTOM w0.102: v5(109.7,49.75) 109.7,49.76 UCPU1.CR10
  BOTTOM w0.127: v5(58.34,71.27) v5(58.34,68.39)
SYS_RESET#: length 115.6
  TOP w0.127: JAPS1.13 129.29,39.61 129.44,39.76 129.44,42.45 127.72,44.16 v1(124.66,44.16) 123.93,44.9 121.5,44.9 120.81,45.59 120.81,48.55 119.37,49.99 118.58,49.99 117.28,51.29 v6(116.72,51.29) ; RC89.2 52.23,67.05 52.32,66.96 52.32,66.4 v2(52.41,66.31)
  IN1 w0.061: v4(95.98,59.89) 95.9,59.98 92.2,59.98 91.36,59.13 v4(89.11,59.13) ; v2(52.41,66.31) 52.72,66.31 v4(52.74,66.34)
  IN2 w0.061: v6(116.72,51.29) 117.12,51.68 117.12,55.3 112.38,60.04 106.12,60.04 105.86,60.29 102.91,60.29 102.62,60.58 96.34,60.58 95.98,60.23 v4(95.98,59.89)
  IN3 w0.061: v4(52.74,66.34) 52.59,66.49 v5(52.59,66.72) ; v5(53.26,70.8) 53.39,70.67 60.27,70.67 60.61,71.01 62.15,71.01 62.42,71.01 63.84,72.42 68.85,72.42 74.17,67.1 76.35,67.1 78.43,65.02 79.74,65.02 86.37,58.39 88.37,58.39 v4(89.11,59.13)
  BOTTOM w0.127: v6(116.72,51.29) 114.32,51.29 113.89,50.86 RC88.2 113.69,51.12 113.47,51.34 111.47,51.34 110.02,49.89 110.02,49.57 109.89,49.44 108.62,49.44 UCPU1.CN10 ; v5(52.59,66.72) 53.26,67.39 v5(53.26,70.8)
SYSPWR_PRES: length 3.1
  TOP w0.127: 262.63,60.41 262.51,60.41 261.81,61.11 RE155.1 RE149.2
TACH_FAN1: length 80
  TOP w0.102: UE1.E3 264.22,58.02 v2(264.21,58.02)
  IN1 w0.061: v2(264.21,58.02) 264.14,58.02 v4(263.82,58.34)
  IN2 w0.061: v4(263.82,58.34) 263.52,58.64 261.97,58.64 259.75,56.42 251.1,56.42 244.69,50.01 225.7,50.01 218.97,43.27 215.35,43.27 213.73,41.66 207.75,41.66 206.27,40.18 206.27,39.01 205.16,37.89 v4(204.73,37.89)
  IN3 w0.061: v4(204.73,37.89) 204.49,37.65 v5(204.46,37.65)
  BOTTOM w0.127: DE6.2 202.16,29.48 202.87,30.19 R23.2 203.3,33.34 v1(203.72,33.76) 204.17,34.21 204.17,37.37 v5(204.46,37.65)
TACH_FAN1_D: length 6.1
  IN1 w0.061: v4(200.62,30.93) v2(199.09,29.4)
  IN3 w0.061: v5(200.19,30.64) 200.48,30.93 v4(200.62,30.93)
  BOTTOM w0.127: JFAN1.3 v5(200.19,30.64) 200.71,30.64 R229.2 202.12,30.46 DE6.1
TBT_A_AUX_N: length 27.3
  IN1 w0.074: v4(27.71,65.36) 27.69,65.38 27.69,65.58 v2(27.59,65.69)
  IN3 w0.074: v5(27.73,65.92) 27.71,65.91 v4(27.71,65.36) ; v5(30.41,49.81) 30.63,50.03 30.82,50.03 31.11,49.73 31.78,49.73 32,49.95 32.56,49.95 32.81,49.7 33.38,49.7 34,50.32 34,55.8 33.55,56.26 33.55,57.85 33.97,58.27 33.97,59.97 32.92,61.02 32.92,63.3 32.14,64.08 32.14,66 31.61,66.53 31.24,66.53 v5(31.14,66.63)
  BOTTOM w0.076: v5(27.73,65.92) 27.98,66.17 28.35,66.17 28.47,66.04
  BOTTOM w0.112: v5(31.14,66.63) 31.04,66.53 30.28,66.53 29.45,65.71 28.81,65.71 28.47,66.04
TBT_A_AUX_N_C: length 3.5
  IN3 w0.074: v5(26.83,50.97) 27.07,50.97 27.34,50.7 28.73,50.7 29.42,50.02 29.62,50.02 v5(29.83,49.81)
TBT_A_AUX_P: length 26
  IN1 w0.074: v4(28.23,65.37) 28.06,65.54 v2(28.06,65.69)
  IN3 w0.074: v4(28.23,65.37) v5(28.23,65.92) ; v5(30.41,50.37) 30.59,50.19 30.88,50.19 31.18,49.9 31.71,49.9 31.93,50.11 32.63,50.11 32.84,49.9 33.3,49.9 33.8,50.41 33.8,55.72 33.35,56.17 33.35,57.93 33.77,58.36 33.77,59.88 32.72,60.93 32.72,63.22 31.94,63.99 31.94,65.91 31.53,66.33 31.24,66.33 v5(31.14,66.23)
  BOTTOM w0.112: v5(28.23,65.92) 28.27,65.87 28.31,65.87 28.32,65.86 28.35,65.86 28.36,65.85 28.71,65.5 29.54,65.5 30.36,66.33 31.04,66.33 v5(31.14,66.23)
TBT_A_AUX_P_C: length 2.7
  IN3 w0.074: v5(27.48,50.97) 27.59,50.87 28.8,50.87 29.49,50.18 29.63,50.18 v5(29.83,50.37)
TBT_A_CC1: length 31.2
  TOP w0.102: v1(23.8,64.8) 24.2,65.2 v2(24.2,65.4)
  TOP w0.305: CT181.1 24.29,65.49 24.21,65.4 v2(24.2,65.4)
  GND1 w0.305: v8(23.58,66.03) 23.47,66.03 22.95,66.55 v8(17.54,66.55)
  IN1 w0.076: v2(24.2,65.4) 24.2,65.43 24.19,65.44
  IN1 w0.203: 7.09,55.35 6.88,54.86 6.72,54.7
  IN1 w0.254: v2(6.05,53.62) 5.91,53.62 v4(5.75,53.46)
  IN1 w0.305: v8(23.58,66.03) 23.96,66.03 v4(24.19,65.8) 24.19,65.44 ; v4(6.56,53.78) 6.56,54.54 6.72,54.7 ; 7.09,55.35 7.09,55.98 7.41,56.3 8.59,56.3 8.79,56.5 8.79,57.1 8.58,57.31 8.58,57.79 9.1,58.31 9.1,62.26 9.63,62.78 9.63,63.77 12.2,66.35 15.63,66.35 15.96,66.68 16.91,66.68 17.03,66.55 v8(17.54,66.55)
  IN3 w0.254: v5(24.22,65.42) 24.22,65.77 v4(24.19,65.8)
  BOTTOM w0.203: v5(24.22,65.42) UT1.L9
  vias: v5(5.95,53.19) v5(6.29,53.59)
TBT_A_CC2: length 28.2
  TOP w0.127: v2(10.83,55.82) 11.04,56.02 v1(11.04,56.14)
  TOP w0.229: 10.11,55.31 10.11,55.57 10.38,55.84 10.78,55.84 10.81,55.82 v2(10.83,55.82)
  TOP w0.254: 10.11,55.31 DT14.1
  TOP w0.305: CT180.1 23.72,65.89 v5(23.72,65.42) ; DT14.1 9.8,54.99 8.86,54.99 8.75,54.87 7.65,54.87 JUSBC1.A5
  GND1 w0.305: v8(17.56,65.93) 22.7,65.93 23.22,65.42 v5(23.72,65.42)
  IN1 w0.305: v8(17.56,65.93) 17.21,65.93 16.69,65.41 15.83,65.41 15.5,65.74 12.46,65.74 10.29,63.57 10.29,57.61 10.86,57.04 10.86,55.84 v2(10.83,55.82) ; v5(23.72,65.42) v4(23.72,65.09)
  IN3 w0.076: v5(23.72,65.42) v4(23.72,65.09)
TBT_A_DBG_CTL1: length 0.9
  IN1 w0.061: v4(26.87,68.29) 26.98,68.18 v2(26.98,67.91)
  IN3 w0.061: v5(26.72,67.92) 26.72,68.15 v4(26.87,68.29)
TBT_A_DBG_CTL2: length 0.7
  IN1 w0.061: v2(26.21,68.43) 26.38,68.59 26.48,68.63 v4(26.49,68.63)
  IN3 w0.061: v4(26.49,68.63) 26.27,68.41 v5(26.22,68.41)
TBT_A_DEBUG1: length 5.6
  TOP w0.127: v2(29.02,64.68) 29.1,64.76 29.96,64.76 30.42,65.22 RT53.2 30.42,65.45 30.64,65.68 31.46,65.68 31.62,65.51 RT109.2
  IN1 w0.061: v2(29.02,64.68) 28.85,64.5 v4(28.65,64.5)
  IN3 w0.061: v4(28.65,64.5) 28.83,64.5 28.92,64.6 28.92,64.8 28.83,64.89 27.75,64.89 v5(27.73,64.92)
TBT_A_DEBUG2: length 6.3
  TOP w0.127: RT111.2 RT54.2 30.26,66.64 v2(30.12,66.78)
  IN1 w0.061: v2(30.12,66.78) v4(30.12,67.22)
  IN3 w0.061: v5(27.27,65.87) 27.57,66.17 28.24,66.17 28.6,66.17 28.75,66.32 28.75,66.57 28.67,66.65 28.67,66.95 29,67.28 30.06,67.28 v4(30.12,67.22)
  BOTTOM w0.127: v5(27.27,65.87) 27.73,65.42 UT1.K2
TBT_A_DEBUG3: length 6
  TOP w0.127: v2(27.8,64.56) 27.95,64.71 v1(28.19,64.71) 28.33,64.71 28.69,64.36 29.29,64.36 29.43,64.51 30.32,64.51 RT262.2 30.42,64.71 30.64,64.94 31.33,64.94 31.62,64.65 RT118.2
  IN1 w0.061: v2(27.8,64.56) 27.8,64.54 27.86,64.48 v4(28.13,64.48)
  IN3 w0.061: v4(28.13,64.48) 27.98,64.64 27.45,64.64 27.44,64.64 v5(27.43,64.64)
  BOTTOM w0.127: UT1.L3 27.23,64.85 v5(27.43,64.64)
TBT_A_DEBUG4: length 1.6
  TOP w0.127: RT119.2 RT263.2
  IN1 w0.061: v2(26.58,64.98) 26.68,65.08 v4(27.16,65.08)
  IN3 w0.061: v4(27.16,65.08) 27.16,65.09 27.23,65.15 v5(27.23,65.42)
TBT_A_HPD: length 18.5
  TOP w0.127: RT104.2 22.59,68.92 22.37,68.7 22.37,66.74 21.77,66.13 21.77,64.58 21.37,64.18 20.74,64.18 20.41,63.85 v1(20.41,63.32) 20.41,62.58 v2(20.84,62.15)
  IN1 w0.061: v2(20.84,62.15) 20.84,60.47 21.54,59.77 22.53,59.77 22.88,60.13 23.66,60.13 24.01,59.78 v4(24.01,59.63)
  IN3 w0.076: v4(24.01,59.63) 24.05,59.59 v5(24.05,58.93) 23.8,58.68 23.8,56.75 23.58,56.54 v5(23.58,56.17)
  BOTTOM w0.127: RT36.1 23.43,59.31 23.81,58.93 v5(24.05,58.93)
TBT_A_I2C_B_N: length 27
  IN1 w0.074: v2(11.17,53.87) 11.16,53.87 11.16,54.01 11.23,54.08 11.49,54.08 11.83,54.42 11.83,57.2 11.07,57.96 11.07,62.71 12.21,63.85 15.65,63.85 16.23,64.43 17.59,64.43 17.96,64.79 20.25,64.79 20.66,65.21 21.86,65.21 22.56,64.51 22.86,64.51 23.04,64.33 23.65,64.33 23.83,64.51 24.88,64.51 24.98,64.41 24.98,64.32 v4(24.78,64.12)
  IN3 w0.074: v5(25.22,64.92) 25.22,65.04 25.1,65.16 24.99,65.16 24.91,65.08 24.91,64.85 25.06,64.7 25.06,64.59 24.97,64.5 24.97,64.31 v4(24.78,64.12)
TBT_A_I2C_B_N_R: length 3.3
  TOP w0.112: JUSBC1.A7 8.06,53.87 arc(8.14,53.88) 8.22,53.93 8.26,53.97 arc(8.31,54.01) 8.37,54.02 8.8,54.02 arc(8.95,53.99) 9.08,53.9 DT22.1 9.3,53.73 arc(9.38,53.93) 9.59,54.02 10.2,54.02 arc(10.4,53.98) LT9.2
TBT_A_I2C_B_P: length 27
  IN1 w0.074: v4(25.29,64.13) 25.18,64.25 25.18,64.49 24.96,64.71 23.74,64.71 23.57,64.53 23.13,64.53 22.95,64.71 22.64,64.71 21.95,65.41 20.58,65.41 20.16,64.99 17.88,64.99 17.51,64.63 16.15,64.63 15.57,64.05 12.12,64.05 10.87,62.8 10.87,57.88 11.63,57.12 11.63,54.5 11.41,54.28 11.25,54.28 v2(11.17,54.37)
  IN3 w0.074: v5(25.22,65.42) 25.47,65.03 25.47,64.71 25.17,64.41 25.17,64.26 v4(25.29,64.13)
TBT_A_I2C_B_P_R: length 3.3
  TOP w0.112: JUSBC1.A6 8.04,54.36 arc(8.11,54.35) 8.17,54.31 8.17,54.31 arc(8.26,54.24) 8.38,54.22 8.8,54.22 arc(8.95,54.25) 9.08,54.34 DT18.1 9.3,54.52 arc(9.38,54.31) 9.59,54.22 10.22,54.22 arc(10.41,54.26) LT9.3
TBT_A_I2C_INT#: length 21.2
  IN1 w0.076: v2(22.28,56.24) v5(22.28,56.17) v4(21.97,55.85)
  IN3 w0.061: v5(30.46,67.85) 30.46,67.02 30.01,66.56 30.01,65.74 29.39,65.12 29.39,63.58 28.55,62.74 28.16,62.74 27.87,62.45 27.47,62.45 26.99,62.93 25.72,62.93 25.22,62.44 25.22,62.32 24.3,61.4 24.3,60.65 24.26,60.61 24.26,60.32 23.7,59.76 23.7,59.16 21.91,57.37 21.91,56.83 22.32,56.42 22.32,56.26 22.29,56.24 22.29,56.23 22.28,56.22 v5(22.28,56.17)
  IN3 w0.076: v5(22.28,56.17) v4(21.97,55.85)
  BOTTOM w0.127: v5(30.46,67.85) 30.11,67.85 29.04,68.92 UT1.C1
TBT_A_LSRX: length 18.5
  TOP w0.127: RT117.1 RT119.1 26.58,64.31 v2(26.83,64.05)
  IN1 w0.061: v2(26.83,64.05) 26.83,63.62 26.15,62.93 26.15,62.45 25.61,61.92 25.14,61.92 23.6,60.37 22.78,60.37 22.43,60.02 21.78,60.02 21.63,60.17 21.63,60.65 v4(21.31,60.97)
  IN3 w0.061: v5(17.34,57.13) 17.34,57.3 17.9,57.85 19.68,57.85 20.21,58.38 21.01,58.38 21.24,58.61 21.24,59 20.95,59.29 20.95,60.62 v4(21.31,60.97)
  BOTTOM w0.076: v5(17.34,57.13) 17.75,56.73 17.75,56.52 18.32,55.95 UT2.A4
TBT_A_LSRX_R: length 2.2
  TOP w0.127: v2(26.26,65.81) 26.23,65.81 26.01,65.58 RT117.2
  IN1 w0.061: v2(26.26,65.81) 26.26,65.83 v4(26.48,66.06)
  IN3 w0.061: v5(26.24,65.81) 26.46,66.03 26.46,66.03 v4(26.48,66.06)
  BOTTOM w0.127: v5(26.24,65.81) 26.33,65.81 UT1.K4
TBT_A_LSTX: length 22.7
  TOP w0.127: v2(26.78,63.14) 27.29,63.65 v1(27.29,63.66) 30.35,63.66 30.68,63.99 RT116.1 30.9,64.24 31.94,64.24 32.21,64.51 RT118.1
  IN1 w0.061: v4(21.29,60.46) 21.29,60.19 21.59,59.9 22.48,59.9 22.83,60.25 23.65,60.25 25.2,61.8 25.68,61.8 26.34,62.46 26.34,62.69 v2(26.78,63.14)
  IN3 w0.061: v5(17.34,56.01) 17.61,56.28 17.61,57.34 17.99,57.71 19.74,57.71 20.26,58.24 21.07,58.24 21.55,58.73 21.55,59.11 21.29,59.36 v4(21.29,60.46)
  BOTTOM w0.076: v5(17.34,56.01) 17.83,56.01 18.35,55.49 UT2.A5
TBT_A_LSTX_R: length 3.8
  TOP w0.127: v2(27.98,64.08) 28.09,63.98 v1(29.25,63.98) 30.05,63.98 RT116.2
  IN1 w0.061: v4(27.65,64.15) 27.91,64.15 v2(27.98,64.08)
  IN3 w0.061: v4(27.65,64.15) 27.47,64.33 27.34,64.33 27.02,64.66 v5(26.94,64.66)
  BOTTOM w0.127: v5(26.94,64.66) 26.73,64.87 UT1.L4
TBT_A_MRESET: length 1
  IN1 w0.061: v4(23.64,68.34) 23.61,68.31 v2(23.25,68.31)
  IN3 w0.061: v4(23.64,68.34) 23.62,68.33 23.62,68.33 23.22,67.93 v5(23.22,67.92)
TBT_A_RESET_N: length 6.4
  IN3 w0.061: v5(23.94,62.29) 23.69,62.53 23.69,62.67 23.15,63.2 23.15,65.37 23.01,65.51 22.72,65.51 22.47,65.77 22.47,66.27 22.86,66.66 22.86,67.36 v5(22.87,67.37)
  BOTTOM w0.127: UT1.F11 v5(22.87,67.37)
TBT_A_SBU1: length 31.6
  IN1 w0.061: v2(6.05,55.11) v4(5.62,55.47)
  IN1 w0.076: v4(24.55,65.13) 24.55,66.09 23.92,66.72 23.37,66.72 22.83,67.27 21.65,67.27 21.42,67.5 20.28,67.5 19.89,67.89 17.18,67.89 16.84,67.55 15.13,67.55 14.78,67.9 13.25,67.9 12.85,67.51 12.66,67.51 9.12,63.97 9.12,62.98 8.61,62.46 8.61,58.45 7.88,57.72 7.22,57.72 6.75,57.25 6.75,55.31 v4(6.56,55.11)
  IN3 w0.061: v4(6.56,55.11) v5(6.33,54.88) ; v5(5.95,55.4) v4(5.62,55.47)
  IN3 w0.076: v5(24.72,65.42) 24.72,65.3 v4(24.55,65.13)
  BOTTOM w0.127: v5(24.72,65.42) UT1.K8 ; v5(5.95,55.4) v5(6.33,54.88)
TBT_A_SBU2: length 54.6
  TOP w0.102: JUSBC1.A8 9.68,53.36 DT26.1
  TOP w0.127: DT26.1 10.09,51.4 9.8,51.11 9.8,50.93 9.61,50.74 8.72,50.74 8.46,50.48 8.46,48.74 7.85,48.13 7.85,46.32 7.29,45.76 v2(7.29,42.56)
  IN1 w0.061: v2(7.29,42.56) 7.76,43.03 9.13,43.03 10.48,41.68 11.8,41.68 12.28,42.17 12.28,43.89 13.54,45.15 13.54,47.76 15.43,49.66 15.43,53.45 15.07,53.81 15.07,54.19 15.43,54.55 15.43,57.69 14.83,58.29 14.83,59.35 14.87,59.39 14.87,62.16 15.63,62.92 16.08,62.92 16.29,63.13 18.39,63.13 18.65,63.39 21.25,63.39 21.54,63.1 23.22,63.1 v4(23.52,63.4)
  IN3 w0.061: v5(23.49,64.55) 23.49,63.43 v4(23.52,63.4)
  BOTTOM w0.127: v5(23.49,64.55) 23.54,64.5 24.47,64.5 24.72,64.76 UT1.L8
TBT_A_TRX_DTX_N1: length 13.8
  TOP w0.112: JUSBC1.A10 8.08,52.36 arc(8.17,52.35) 8.25,52.29 arc(8.35,52.23) 8.47,52.2 8.47,52.2 9.02,52.2 arc(9.13,52.22) 9.22,52.29 DT30.1 9.45,52.22 arc(9.52,52.18) 9.6,52.16 9.64,52.16 arc(9.69,52.17) 9.72,52.19 v2(9.78,52.25)
  IN1 w0.074: v2(9.78,52.25) v4(10.11,52.31)
  IN3 w0.074: v5(18.52,48.13) 18.64,48.13 arc(18.72,48.17) 18.75,48.25 18.75,48.28 arc(18.71,48.36) 18.63,48.4 18.43,48.4 arc(18.35,48.38) 18.28,48.34 18.25,48.3 arc(18.2,48.27) 18.14,48.24 arc(18.12,48.24) 18.1,48.24 18.09,48.24 arc(17.99,48.2) 17.91,48.15 17.63,47.87 arc(17.43,47.73) 17.19,47.68 15.67,47.68 arc(15.2,47.77) 14.81,48.04 11.23,51.62 10.82,52.03 arc(10.68,52.13) 10.51,52.19 arc(10.31,52.25) v4(10.11,52.31)
TBT_A_TRX_DTX_N2: length 18
  IN1 w0.074: v2(6.05,56.11) v4(6.38,56.11)
  IN3 w0.074: v5(7.13,56.17) 7.15,56.19 arc(7.22,56.24) 7.3,56.25 8.34,56.25 arc(8.76,56.33) 9.12,56.57 9.9,57.36 arc(10.08,57.47) 10.28,57.51 10.85,57.51 arc(11.13,57.46) 11.37,57.3 11.9,56.77 arc(12.55,55.8) 12.77,54.66 12.77,54.64 arc(12.87,54.13) 13.16,53.7 15.39,51.47 arc(15.73,51.25) 16.12,51.17 17.2,51.17 arc(17.3,51.15) 17.38,51.1 17.41,51.06 arc(17.7,50.87) 18.04,50.81 18.17,50.81 arc(18.23,50.79) 18.28,50.76 18.29,50.75 arc(18.4,50.68) 18.53,50.65 18.59,50.65 arc(18.75,50.66) 18.91,50.7 arc(18.99,50.78) v5(18.98,50.89) ; v4(6.38,56.11) v5(6.05,56.17)
  BOTTOM w0.112: v5(7.13,56.17) 7.08,56.22 arc(7.03,56.25) 6.98,56.26 arc(6.86,56.24) 6.76,56.17 DT11.2 6.52,56.18 arc(6.43,56.24) 6.32,56.26 6.13,56.26 v5(6.05,56.17)
TBT_A_TRX_DTX_P1: length 13.8
  TOP w0.112: JUSBC1.A11 8.1,51.87 arc(8.22,51.89) 8.33,51.96 arc(8.37,51.99) 8.42,52 8.88,52 arc(9.04,51.97) 9.18,51.87 DT34.1 9.45,51.9 arc(9.52,51.94) 9.6,51.96 arc(9.68,51.94) 9.75,51.89 v2(9.78,51.87)
  IN1 w0.074: v2(9.78,51.87) v4(10.11,51.81)
  IN3 w0.074: v4(10.11,51.81) arc(10.26,51.97) 10.47,52 arc(10.58,51.96) 10.68,51.89 11.09,51.48 14.67,47.9 arc(15.13,47.59) 15.67,47.48 17.19,47.48 arc(17.51,47.54) 17.78,47.72 18.05,48 arc(18.09,48.03) 18.14,48.04 18.18,48.04 arc(18.24,48.03) 18.29,47.99 arc(18.4,47.92) 18.53,47.89 18.59,47.89 arc(18.82,47.96) v5(18.98,48.13)
TBT_A_TRX_DTX_P2: length 18
  IN1 w0.074: v2(6.05,56.62) v4(6.38,56.62)
  IN3 w0.074: v4(6.38,56.62) v5(6.05,56.56) ; v5(7.13,56.55) 7.18,56.5 arc(7.23,56.46) 7.29,56.45 8.34,56.45 arc(8.69,56.52) 8.98,56.71 9.76,57.5 arc(10,57.66) 10.28,57.71 10.85,57.71 arc(11.21,57.64) 11.51,57.44 12.04,56.91 arc(12.73,55.88) 12.97,54.66 12.97,54.64 12.97,54.64 arc(13.06,54.21) 13.3,53.85 15.53,51.62 arc(15.8,51.44) 16.12,51.37 17.2,51.37 arc(17.37,51.34) 17.52,51.24 17.56,51.21 arc(17.78,51.06) 18.04,51.01 18.16,51.01 arc(18.26,51.04) 18.35,51.1 arc(18.44,51.15) 18.54,51.16 arc(18.55,51.16) 18.56,51.16 18.62,51.16 arc(18.71,51.12) 18.75,51.03 18.75,51 arc(18.72,50.92) 18.64,50.89 v5(18.52,50.89)
  BOTTOM w0.112: v5(6.05,56.56) 6.14,56.46 6.32,56.46 arc(6.42,56.48) 6.5,56.54 DT7.2 6.77,56.55 arc(6.87,56.48) 6.98,56.46 arc(7.04,56.47) 7.09,56.51 v5(7.13,56.55)
