# Allegro board LAG441PR10-1221_GCR.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
RI59  0_0201_5%  [R0201_0OHM]  16.53 12.53 180 bottom
RI60  0_0201_5%  [R0201_0OHM]  16.53 11.89 180 bottom
RI61  0_0201_5%  [R0201_0OHM]  16.47 6.56 180 bottom
RI62  0_0201_5%  [R0201_0OHM]  16.47 5.92 180 bottom
RI64  10K_0201_5%  [R_0201]  18.39 16.53 270 top
RI67  22.1K_0201_1%  [R_0201]  21.94 13.73 0 top
RI68  0_0201_5%  [R0201_0OHM]  288.26 42.14 90 top
RI72  4.7K_0201_5%  [R_0201]  287.63 42.73 270 top
RI74  4.7K_0201_5%  [R_0201]  286.99 42.73 270 top
RI76  4.7K_0201_5%  [R_0201]  286.36 42.73 270 top
RI78  4.7K_0201_5%  [R_0201]  288.9 42.73 270 top
RI101  4.7K_0201_5%  [R_0201]  288.26 50.48 270 top
RI123  10K_0201_5%  [R_0201]  284.03 60.41 0 top
RI124  10K_0201_5%  [R_0201]  16.36 14.53 270 top
RI143  10K_0201_5%  [R_0201]  291.22 59.65 180 top
RI144  10K_0201_5%  [R_0201]  16.36 12.34 90 top
RK4  100K_0201_5%  [R_0201]  217.27 17.89 90 top
RK5  0_0603_5%  [R0603_0OHM]  241.4 10.94 180 top
RK6  100K_0201_5%  [R_0201]  242.54 12.3 90 top
RK7  240_0402_1%  [R_0402]  247.93 12.97 0 top
RK8  10K_0201_5%  [R_0201]  231.75 10.31 0 top
RK9  1K_0201_5%  [R_0201]  234.03 10.31 180 top
RK10  15_0201_1%  [R_0201]  227.47 13.85 0 top
RK11  240_0402_1%  [R_0402]  247.93 17.04 0 top
RK12  100K_0201_5%  [R_0201]  242.54 16.24 90 top
RM31  8.2_0201_1%  [R_0201]  16.62 32.56 180 top
RM32  150_0201_1%  [R_0201]  15.47 32.57 270 top
RM33  8.2_0201_1%  [R_0201]  16.62 32 180 top
RM34  8.2_0201_1%  [R_0201]  16.62 36.67 180 top
RM35  150_0201_1%  [R_0201]  15.47 36.7 270 top
RM36  8.2_0201_1%  [R_0201]  16.62 36.11 180 top
RM37  8.2_0201_1%  [R_0201]  16.65 29.51 180 top
RM38  150_0201_1%  [R_0201]  15.47 29.52 270 top
RM39  8.2_0201_1%  [R_0201]  16.65 28.95 180 top
RM40  8.2_0201_1%  [R_0201]  16.65 26.97 180 top
RM41  150_0201_1%  [R_0201]  15.47 26.98 270 top
RM42  8.2_0201_1%  [R_0201]  16.65 26.41 180 top
RM94  2.2K_0201_5%  [R_0201]  15.77 21.67 90 bottom
RM95  2.2K_0201_5%  [R_0201]  15.77 23.45 270 bottom
RM96  1M_0201_5%  [R_0201]  19.28 25.46 270 bottom
RM97  20K_0201_5%  [R_0201]  15.47 24.87 90 bottom
RM98  10K_0201_5%  [R_0201]  15.56 37.74 0 top
RM99  470_0201_1%  [R_0201]  17.19 32.57 90 top
RM100  470_0201_1%  [R_0201]  17.19 31.98 270 top
RM101  470_0201_1%  [R_0201]  17.19 36.68 90 top
RM102  470_0201_1%  [R_0201]  17.19 36.1 270 top
RM103  470_0201_1%  [R_0201]  17.22 29.52 90 top
RM104  470_0201_1%  [R_0201]  17.22 28.94 270 top
RM105  470_0201_1%  [R_0201]  17.22 26.98 90 top
RM106  470_0201_1%  [R_0201]  17.22 26.4 270 top
RM107  10K_0201_5%  [R_0201]  17.16 21.99 180 top
RN3  10K_0201_5%  [R_0201]  263.94 26.79 270 top
RN4  0_0402_5%  [R0402_0OHM]  251.61 29.74 0 top
RN7  10K_0201_5%  [R_0201]  259.5 33.78 270 top
RN9  0_0201_5%  [R0201_0OHM]  260.07 33.19 90 top
RN10  0_0201_5%  [R0201_0OHM]  273.72 31.35 90 top
RN12  0_0201_5%  [R0201_0OHM]  253.81 25.1 0 top
RN13  0_0201_5%  [R_0201]  274.29 30.66 270 top
RN14  0_0201_5%  [R0201_0OHM]  253.81 24.47 0 top
RN15  0_0201_5%  [R0201_0OHM]  253.81 27.2 0 top
RN16  0_0201_5%  [R0201_0OHM]  253.81 26.56 0 top
RN17  0_0201_5%  [R0201_0OHM]  271.25 27.04 270 top
RN18  0_0201_5%  [R0201_0OHM]  270.61 27.04 270 top
RN21  0_0201_5%  [R0201_0OHM]  205.54 51.08 180 top
RN22  0_0201_5%  [R0201_0OHM]  205.54 51.72 180 top
RN23  10K_0201_5%  [R_0201]  213.12 55.39 180 top
RN24  0_0201_5%  [R_0201]  213.12 51.39 180 top
RN25  10K_0201_5%  [R_0201]  213.12 51.96 180 top
RN26  0_0201_5%  [R0201_0OHM]  205.56 48.15 180 top
RN27  0_0201_5%  [R_0201]  212.53 47.9 0 top
RN28  1K_0201_1%  [R_0201]  205.56 47.58 180 top
RN31  0_0201_5%  [R0201_0OHM]  219.39 38.04 0 top
RN32  0_0201_5%  [R0201_0OHM]  219.98 36.98 180 top
RN43  0_0201_5%  [R0201_0OHM]  207.07 28.21 0 bottom
RN45  0_0201_5%  [R0201_0OHM]  207.07 28.85 0 bottom
RN46  22_0201_1%  [R_0201]  219.39 35.07 0 top
RN47  22_0201_1%  [R_0201]  220 31.93 270 top
RN48  0_0201_5%  [R_0201]  219.39 28.09 0 top
RN49  0_0201_5%  [R_0201]  272.01 31.35 90 top
RN50  0_0201_5%  [R_0201]  272.58 31.35 90 top
RN51  0_0201_5%  [R_0201]  273.15 31.35 90 top
RN52  0_0201_5%  [R_0201]  273.15 30.66 270 top
RN53  0_0201_5%  [R_0201]  272.58 30.66 270 top
RN54  0_0201_5%  [R_0201]  272.01 30.66 270 top
RN55  0_0201_5%  [R0201_0OHM]  219.39 23.89 0 top
RN57  0_0201_5%  [R0201_0OHM]  205.56 63.65 180 top
RN58  0_0201_5%  [R0201_0OHM]  205.56 63.07 180 top
RN59  0_0201_5%  [R0201_0OHM]  205.56 60.66 180 top
RN60  0_0201_5%  [R0201_0OHM]  205.56 60.09 180 top
RN61  0_0201_5%  [R0201_0OHM]  205.56 57.68 180 top
RN62  0_0201_5%  [R0201_0OHM]  205.56 57.11 180 top
RN63  0_0201_5%  [R0201_0OHM]  205.56 54.63 180 top
RN64  0_0201_5%  [R0201_0OHM]  205.56 54.06 180 top
RN67  0_0201_5%  [R0201_0OHM]  195.05 69.11 90 top
RN70  10K_0201_5%  [R_0201]  252.3 46.14 0 top
RN71  0_0201_1%  [R_0201]  254.93 45.15 180 top
RN72  100K_0201_5%  [R_0201]  254.74 42.67 270 top
RN73  0_0201_5%  [R0201_0OHM]  272.81 23.89 90 top
RN74  10K_0201_5%  [R_0201]  270.93 31.93 270 top
RN77  10K_0201_5%  [R_0201]  219.43 27.49 270 top
RN78  10K_0201_5%  [R_0201]  219.43 26.22 270 top
RN79  10K_0201_5%  [R_0201]  219.39 24.53 0 top
RN80  0_0201_5%  [R_0201]  258.61 43.03 90 top
RN81  0_0201_5%  [R_0201]  259.24 42.35 270 top
RN82  0_0201_5%  [R_0201]  258.61 42.35 270 top
RN83  0_0402_5%  [R_0402]  261.78 36.8 270 top
RN84  0_0402_5%  [R_0402]  261.02 36.8 270 top
RN85  10K_0201_5%  [R_0201]  262.13 37.61 0 top
RN86  0_0201_5%  [R_0201]  262.71 38.25 180 top
RN87  0_0201_5%  [R_0201]  259.5 36.89 270 top
RN88  100K_0201_5%  [R_0201]  258.86 36.3 90 top
RN89  100K_0201_5%  [R_0201]  261.02 41.76 90 top
RN90  0_0201_5%  [R_0201]  262.76 45.74 0 top
RN91  10K_0201_5%  [R_0201]  263.35 45.1 180 top
RN92  10K_0201_5%  [R_0201]  263.37 26.79 270 top
RN95  10K_0201_5%  [R_0201]  268.32 33.84 270 top
RN96  0_0201_5%  [R0201_0OHM]  268.32 34.52 90 top
RN97  10K_0201_5%  [R_0201]  262.13 38.88 0 top
RN98  0_0201_5%  [R0201_0OHM]  212.53 63.01 0 top
RN99  10K_0201_5%  [R_0201]  211.49 27.36 270 top
RN100  0_0201_5%  [R0201_0OHM]  211.49 26.16 270 top
RN101  0_0201_5%  [R0201_0OHM]  267.56 27.04 270 top
RN102  0_0201_5%  [R0201_0OHM]  268.2 27.04 270 top
RN103  0_0201_5%  [R0201_0OHM]  269.09 27.04 270 top
RN104  0_0201_5%  [R0201_0OHM]  269.72 27.04 270 top
RN105  10K_0201_5%  [R_0201]  272.81 25.69 270 top
RN106  100K_0201_5%  [R_0201]  254.86 46.31 270 top
RN107  0_0201_1%  [R_0201]  253.52 46.11 270 top
RN108  20K_0201_5%  [R_0201]  252.3 45.54 0 top
RN109  0_0201_1%  [R_0201]  251.05 46.12 270 top
RN110  75K_0201_5%  [R_0201]  250.42 46.12 270 top
RN111  75K_0201_5%  [R_0201]  251.66 45.54 90 top
RN112  0_0201_5%  [R_0201]  258.67 46.09 270 top
RN113  0_0201_5%  [R_0201]  258.74 38.35 270 top
RN114  0_0201_5%  [R_0201]  269.07 31.48 0 top
RN115  10K_0201_5%  [R_0201]  272.68 26.43 0 top
RN116  20K_0201_5%  [R_0201]  254.28 46.31 270 top
RN117  0_0201_5%  [R0201_0OHM]  197.95 74.45 270 top
RN118  0_0201_5%  [R0201_0OHM]  221.61 35.11 0 top
RN119  0_0201_5%  [R_0201]  221.61 35.72 0 top
RP3  0_0201_5%  [R0201_0OHM]  193.59 21.1 270 bottom
RP4  0_0201_5%  [R0201_0OHM]  192.44 21.1 270 bottom
RP5  0_0201_5%  [R0201_0OHM]  193.01 21.1 270 bottom
RP6  2.2K_0201_5%  [R_0201]  192.44 19.89 180 bottom
RP7  2.2K_0201_5%  [R_0201]  193.08 19.89 0 bottom
RP8  100K_0201_5%  [R_0201]  194.16 21.1 270 bottom
RP9  100K_0201_5%  [R_0201]  197.4 21.16 90 bottom
RP12  0_0201_5%  [R_0201]  194.54 22.5 0 bottom
RP13  0_0201_5%  [R_0201]  195.43 19.89 180 bottom
RP14  0_0201_5%  [R0201_0OHM]  191.87 21.1 270 bottom
RP15  100K_0201_5%  [R_0201]  198.03 20.53 0 bottom
RP16  0_0201_5%  [R_0201]  195.73 22.5 0 bottom
RR1  0.01_0603_1%  [R_0603]  285.25 39.12 180 top
RR2  0_0201_5%  [R0201_0OHM]  294.49 32.02 270 top
RR3  0_0201_5%  [R0201_0OHM]  295.12 32.02 270 top
RR4  0_0201_5%  [R0201_0OHM]  296.99 33.29 0 top
RR5  0_0201_5%  [R0201_0OHM]  296.99 34.56 0 top
RR6  0_0201_5%  [R0201_0OHM]  296.99 35.2 0 top
RR7  0_0201_5%  [R0201_0OHM]  296.99 35.83 0 top
RR8  0_0201_5%  [R0201_0OHM]  292.26 39.55 270 top
RR9  10K_0201_5%  [R_0201]  291.69 39.55 270 top
RR10  6.2K_0402_1%  [R_0402]  289.66 32.02 0 top
RR11  10K_0201_5%  [R_0201]  293.03 38.97 90 top
RR12  0_0201_5%  [R0201_0OHM]  299.22 29.61 180 top
RR13  10K_0201_5%  [R_0201]  291.11 38.94 180 top
RR14  100K_0201_5%  [R_0201]  291.11 39.58 180 top
RR16  0_0603_5%  [R0603_0OHM]  285.25 37.24 180 top
RR17  0_0201_5%  [R0201_0OHM]  288.96 35.46 0 top
RR18  0_0201_5%  [R0201_0OHM]  288.96 34.83 0 top
RR19  9.53K_0402_1%  [R_0402]  289.62 41.4 270 top
RR20  100_0201_1%  [R_0201]  285.44 38.22 180 top
RS1  15K_0201_5%  [R_0201]  290.42 32.24 90 bottom
RS2  51_0201_5%  [R_0201]  292.45 29.99 0 bottom
RS3  0_0201_5%  [R0201_0OHM]  202.89 68.6 180 bottom
RS5  2.2K_0201_5%  [R_0201]  198.69 68.98 0 bottom
RS6  2.2K_0201_5%  [R_0201]  201.62 66.4 90 bottom
RS7  2.2K_0201_5%  [R_0201]  199.91 66.4 90 bottom
RS8  0_0201_5%  [R_0201]  202.89 69.87 180 bottom
RS9  0_0201_5%  [R0201_0OHM]  202.89 69.23 180 bottom
RS10  0_0201_5%  [R0201_0OHM]  199.27 68.34 180 bottom
RS11  0_0201_5%  [R_0201]  201.05 66.99 270 bottom
RS12  0_0201_5%  [R_0201]  200.48 66.99 270 bottom
RS14  0_0201_5%  [R0201_0OHM]  201.22 69.06 0 top
RS15  0_0201_5%  [R0201_0OHM]  198.41 68.46 0 top
RT3  10K_0201_5%  [R_0201]  27.11 62.31 270 bottom
RT4  10K_0201_5%  [R_0201]  24.55 61.14 270 bottom
RT5  10K_0201_5%  [R_0201]  25.1 59.97 270 bottom
RT6  10K_0201_5%  [R_0201]  30.41 57.95 180 bottom
RT7  3.01K_0201_1%  [R_0201]  24.22 50.27 270 top
RT8  0_0201_5%  [R0201_0OHM]  22.31 59.39 90 bottom
RT9  14K_0201_1%  [R_0201]  24.23 54.88 90 top
RT10  10K_0201_5%  [R_0201]  29.82 57.39 0 bottom
RT11  2.2K_0201_5%  [R_0201]  29.78 60.53 90 bottom
RT13  2.2K_0201_5%  [R_0201]  28.5 59.38 0 bottom
RT14  10K_0201_5%  [R_0201]  25.1 61.73 90 bottom
RT15  0_0201_5%  [R_0201]  23.43 61.73 90 bottom
RT17  0_0201_5%  [R_0201]  23.99 61.73 90 bottom
RT18  100_0201_5%  [R_0201]  22.87 61.73 90 bottom
RT19  10K_0201_5%  [R_0201]  21.75 60.56 90 bottom
RT21  100_0201_5%  [R_0201]  30.39 55.41 90 bottom
RT23  14K_0201_1%  [R_0201]  31.5 47.21 0 bottom
RT24  0_0201_5%  [R0201_0OHM]  18.84 45.45 90 bottom
RT25  2.2K_0201_5%  [R_0201]  25.1 60.56 90 bottom
RT26  2.2K_0201_5%  [R_0201]  25.99 60.56 90 bottom
RT27  10K_0201_5%  [R_0201]  27.8 61.73 90 bottom
RT28  4.75K_0402_0.5%  [R_0402]  21.37 55.52 0 top
RT29  10K_0201_5%  [R_0201]  27.8 59.39 90 bottom
RT30  10K_0201_5%  [R_0201]  21.75 59.39 90 bottom
RT31  10K_0201_5%  [R_0201]  22.28 56.24 90 top
RT32  100K_0201_5%  [R_0201]  26.55 59.39 90 bottom
RT33  10K_0201_5%  [R_0201]  21.63 56.24 90 top
RT34  10K_0201_5%  [R_0201]  22.31 60.56 90 bottom
RT35  10K_0201_5%  [R_0201]  19.72 56.1 270 top
RT36  100K_0201_5%  [R_0201]  23.43 59.39 90 bottom
RT37  1M_0201_5%  [R_0201]  17.34 56.01 180 bottom
RT38  1M_0201_5%  [R_0201]  17.34 57.13 180 bottom
RT39  100K_0201_5%  [R_0201]  23.43 60.56 90 bottom
RT40  1M_0201_5%  [R_0201]  17.34 57.69 180 bottom
RT41  1M_0201_5%  [R_0201]  17.34 56.57 180 bottom
RT42  499_0201_1%  [R_0201]  21.63 48.5 270 top
RT43  499_0201_1%  [R_0201]  20.98 48.5 270 top
RT44  3.3K_0201_5%  [R_0201]  32.9 41.55 180 top
RT45  2.2K_0201_5%  [R_0201]  33.84 50.56 0 top
RT46  2.2K_0201_5%  [R_0201]  33.16 50.56 180 top
RT47  3.3K_0201_5%  [R_0201]  31.3 50.56 0 top
RT49  0_0603_5%  [R0603_0OHM]  23.66 58.2 180 top
RT50  0_0603_5%  [R0603_0OHM]  21.17 59.19 90 top
RT51  0_0402_5%  [R_0402]  24.03 68.73 0 top
RT52  0_0402_5%  [R_0402]  24.03 67.96 0 top
RT53  100K_0201_5%  [R_0201]  31 65.3 180 top
RT54  100K_0201_5%  [R_0201]  31.33 66.64 180 top
RT55  0_0201_5%  [R0201_0OHM]  27.51 67.39 180 top
RT56  0_0201_5%  [R0201_0OHM]  24 67.27 0 top
RT57  0_0402_5%  [R_0402]  24.03 75.9 0 top
RT58  0_0402_5%  [R_0402]  24.03 75.14 0 top
RT59  100K_0201_5%  [R_0201]  27.72 72.19 270 top
RT60  100K_0201_5%  [R_0201]  27.15 71.61 90 top
RT61  0_0201_5%  [R_0201]  27.51 74.57 180 top
RT62  0_0201_5%  [R0201_0OHM]  24 74.44 0 top
RT69  0_0201_5%  [R0201_0OHM]  24.55 61.73 90 bottom
RT71  0_0201_5%  [R0201_0OHM]  30.41 56.83 180 bottom
RT72  0_0201_5%  [R0201_0OHM]  18.28 46.03 270 bottom
RT80  100K_0201_5%  [R_0201]  31.5 57.52 0 bottom
RT81  100K_0201_5%  [R_0201]  23.99 59.39 90 bottom
RT82  100K_0201_5%  [R_0201]  31.5 56.96 0 bottom
RT83  100K_0201_5%  [R_0201]  24.28 56.15 180 top
RT88  0_0402_5%  [R_0402]  20.05 57.12 180 top
RT91  0_0201_5%  [R0201_0OHM]  32.09 58.08 180 bottom
RT92  0_0201_5%  [R0201_0OHM]  24.55 59.97 270 bottom
RT93  0_0201_5%  [R_0201]  31.5 56.41 0 bottom
RT94  0_0201_5%  [R_0201]  24.89 57.12 0 top
RT97  1M_0201_5%  [R_0201]  29.83 59.36 90 bottom
RT98  100K_0201_5%  [R_0201]  22.87 59.39 90 bottom
RT99  4.7K_0201_5%  [R_0201]  24.1 62.12 90 top
RT100  4.7K_0201_5%  [R_0201]  24.1 61.49 270 top
RT101  4.7K_0201_5%  [R_0201]  24.1 60.22 270 top
RT102  4.7K_0201_5%  [R_0201]  32.74 61.36 270 top
RT103  0_0201_5%  [R0201_0OHM]  27.98 68.94 90 top
RT104  0_0201_5%  [R0201_0OHM]  23.32 68.92 180 top
RT105  0_0201_5%  [R_0201]  24.84 69.55 180 top
RT106  10K_0201_5%  [R_0201]  27.51 67.96 180 top
RT107  0_0201_5%  [R0201_0OHM]  25.44 66.48 270 top
RT108  10K_0201_5%  [R_0201]  26.26 69.02 270 top
RT109  0_0201_5%  [R0201_0OHM]  32.21 65.3 180 top
RT111  0_0201_5%  [R0201_0OHM]  31.33 66.08 180 top
RT112  100K_0201_5%  [R_0201]  23.32 68.34 180 top
RT113  15K_0201_1%  [R_0201]  27.51 66.82 180 top
RT114  100K_0201_5%  [R_0201]  26.92 65.68 0 top
RT115  100K_0201_5%  [R_0201]  28.1 66.29 270 top
RT116  0_0201_5%  [R0201_0OHM]  30.68 64.03 180 top
RT117  0_0201_5%  [R0201_0OHM]  26.01 64.43 90 top
RT118  0_0201_5%  [R_0201]  32.21 64.6 180 top
RT119  0_0201_5%  [R_0201]  26.58 64.43 90 top
RT120  0_0201_5%  [R0201_0OHM]  27.98 76.12 90 top
RT121  0_0201_5%  [R0201_0OHM]  23.13 75.9 180 top
RT122  0_0201_5%  [R_0201]  24.88 77.17 0 top
RT123  10K_0201_5%  [R_0201]  27.51 75.14 180 top
RT124  0_0201_5%  [R0201_0OHM]  25.44 73.72 270 top
RT125  10K_0201_5%  [R_0201]  26.26 76.19 270 top
RT126  0_0201_5%  [R0201_0OHM]  30.68 71.33 180 top
RT128  0_0201_5%  [R0201_0OHM]  30.68 71.9 180 top
RT129  100K_0201_5%  [R_0201]  23.13 75.33 180 top
RT138  100K_0201_5%  [R_0201]  26.94 72.85 0 top
RT139  15K_0201_1%  [R_0201]  27.52 74 180 top
RT140  100K_0201_5%  [R_0201]  28.26 73.44 270 top
RT141  0_0201_5%  [R0201_0OHM]  24.83 71.33 0 top
RT142  0_0201_5%  [R0201_0OHM]  26.01 71.61 90 top
RT143  0_0201_5%  [R_0201]  28.29 72.19 270 top
RT144  0_0201_5%  [R_0201]  26.58 71.61 90 top
RT145  0_0402_5%  [R_0402]  30.15 70.63 180 top
RT146  0_0402_5%  [R0402_0OHM]  30.15 77.81 180 top
RT147  100K_0201_1%  [R_0201]  25.44 72.51 270 top
RT148  100K_0201_5%  [R_0201]  25.69 75.61 90 top
RT149  0_0402_5%  [R0402_0OHM]  30.15 69.81 180 top
RT151  1M_0201_5%  [R_0201]  31.33 67.21 180 top
RT152  1M_0201_5%  [R_0201]  24.04 70.15 90 top
RT153  1M_0201_5%  [R_0201]  31.33 67.79 180 top
RT155  10K_0201_1%  [R_0201]  24.87 64.69 90 top
RT159  100K_0201_1%  [R_0201]  25.44 65.27 270 top
RT160  100K_0201_5%  [R_0201]  25.69 68.43 90 top
RT161  0_0402_5%  [R_0402]  30.15 76.98 180 top
RT163  1M_0201_5%  [R_0201]  24.29 77.32 90 top
RT165  10K_0201_1%  [R_0201]  24.87 71.93 90 top
RT169  0_0201_5%  [R0201_0OHM]  26.83 68.94 90 top
RT170  0_0201_5%  [R0201_0OHM]  26.26 70.73 270 top
RT171  0_0201_5%  [R0201_0OHM]  26.83 70.73 270 top
RT172  0_0201_5%  [R0201_0OHM]  27.41 70.73 270 top
RT177  100K_0201_5%  [R_0201]  26.83 77.91 270 top
RT178  100K_0201_5%  [R_0201]  27.41 77.91 270 top
RT179  100K_0201_5%  [R_0201]  26.83 76.12 90 top
RT180  100K_0201_5%  [R_0201]  26.26 77.91 270 top
RT183  0_0201_5%  [R_0201]  34.16 56.76 180 top
RT185  10K_0201_5%  [R_0201]  27.11 60.56 90 bottom
RT186  0_0201_5%  [R_0201]  27.8 60.56 90 bottom
RT187  0_0201_5%  [R_0201]  28.36 60.56 90 bottom
RT188  0_0201_5%  [R_0201]  26.55 60.56 90 bottom
RT189  10K_0201_5%  [R_0201]  22.87 60.56 90 bottom
RT190  0_0201_5%  [R_0201]  32.79 58.29 0 top
RT260  0_0402_5%  [R_0402]  34.39 40.58 90 top
RT261  0_0402_5%  [R0402_0OHM]  33.63 40.58 90 top
RT262  100K_0201_5%  [R_0201]  31 64.6 180 top
RT263  100K_0201_5%  [R_0201]  27.15 64.43 90 top
RT265  100K_0201_5%  [R_0201]  29.48 71.33 180 top
RT266  100K_0201_5%  [R_0201]  29.48 71.9 180 top
RT267  10K_0201_5%  [R_0201]  22.93 49.08 180 top
RT268  0_0201_5%  [R_0201]  23.34 67.2 180 top
RT269  0_0201_5%  [R_0201]  23.32 67.77 180 top
RT271  0_0201_5%  [R_0201]  28.55 70.15 90 top
RT272  0_0201_5%  [R_0201]  28.55 77.32 90 top
RT274  0_0201_5%  [R_0201]  23.13 74.76 180 top
RT275  0_0201_5%  [R_0201]  23.13 73.93 180 top
RT284  0_0201_5%  [R_0201]  33.58 56.2 0 top
RT285  0_0201_5%  [R_0201]  32.97 56.77 270 top
RT287  0_0201_5%  [R_0201]  32.36 51.38 90 top
RT288  100K_0201_5%  [R_0201]  33.01 51.95 270 top
RT289  0_0201_5%  [R_0201]  32.21 56.77 270 top
RT290  0_0201_5%  [R_0201]  30.11 56.94 270 top
RT291  10K_0201_5%  [R_0201]  31.53 51.96 270 top
RT292  0_0201_5%  [R_0201]  29.63 51.96 270 top
RT293  1M_0201_5%  [R_0201]  30.2 51.96 270 top
RT294  0_0201_5%  [R_0201]  31.57 56.77 270 top
RT295  10K_0201_5%  [R_0201]  30.43 59.37 90 bottom
RT296  300K_0201_1%  [R_0201]  14.81 69.79 180 bottom
RT297  300K_0201_1%  [R_0201]  10.16 71.01 0 bottom
RT298  1M_0201_1%  [R_0201]  14.48 70.36 0 bottom
RT299  10K_0201_1%  [R_0201]  17.54 74.94 270 bottom
RT300  100K_0201_1%  [R_0201]  16.46 70.5 180 bottom
RT302  0_0201_5%  [R0201_0OHM]  16.25 74.95 0 bottom
RT303  0_0201_5%  [R0201_0OHM]  17.73 70.5 180 bottom
RT304  10K_0201_5%  [R_0201]  30.95 61.15 270 bottom
RT305  10K_0201_5%  [R_0201]  30.37 61.15 270 bottom
RTCD3  -  [RB520SM-30T2R_EMD2-2]  307.25 4.34 180 top
RV3  100K_0201_5%  [R_0201]  42.53 68.7 180 top
RV15  0_0201_5%  [R0201_0OHM]  111.28 29.69 270 top
RV16  2.2K_0201_5%  [R_0201]  35.69 75.27 0 top
RV17  0_0201_5%  [R0201_0OHM]  117.45 29.05 0 top
RV19  0_0201_5%  [R0201_0OHM]  39.34 74.92 270 top
RV20  0_0201_5%  [R0201_0OHM]  39.6 75.93 90 top
RV21  0_0201_5%  [R0201_0OHM]  40.8 75.93 90 top
RV23  0_0201_5%  [R0201_0OHM]  265.12 46.35 270 top
RV25  4.7K_0201_5%  [R_0201]  34.48 75.11 0 top
RV35  0.5A_65V_T0603FF0500TM  [F_T0603FF0500TM]  144.18 24.34 180 bottom
RV39  10K_0201_5%  [R_0201]  53.42 65.42 180 top
RV40  100K_0201_5%  [R_0201]  69.47 61.36 0 top
RV41  47K_0201_5%  [R_0201]  57.19 61.49 180 top
RV42  0_0201_5%  [R0201_0OHM]  70.66 61.36 0 top
RV43  200K_0201_5%  [R_0201]  51.62 63.52 0 top
RV44  1M_0201_5%  [R_0201]  70.05 61.93 180 top
RV45  0_0201_5%  [R0201_0OHM]  62.65 62.85 90 top
RV46  10K_0201_5%  [R_0201]  62.69 64.53 180 top
RV47  47K_0201_5%  [R_0201]  67.58 64.41 180 top
RV48  200K_0201_5%  [R_0201]  62.01 62.85 90 top
RV50  10K_0201_5%  [R_0201]  246.04 42.22 270 top
RV51  10K_0201_5%  [R_0201]  246.61 42.22 270 top
RV52  0_0201_5%  [R0201_0OHM]  245.46 42.22 270 top
RV53  0_0201_5%  [R0201_0OHM]  247.75 42.22 270 top
RV54  100K_0201_5%  [R_0201]  247.18 42.22 270 top
RV57  2.2K_0201_5%  [R_0201]  41.38 76.51 270 top
RV58  2.2K_0201_5%  [R_0201]  40.17 76.51 270 top
RV60  100K_0201_5%  [R_0201]  39.34 73.13 90 top
RV62  0_0201_5%  [R0201_0OHM]  119.04 20.99 180 bottom
RV63  0_0201_5%  [R0201_0OHM]  119.04 20.28 180 bottom
RV66  0_0201_5%  [R_0201]  139.61 20.31 270 bottom
RV67  0_0201_5%  [R_0201]  138.92 20.33 270 bottom
RV68  0_0603_5%  [R_0603]  141.48 25.51 270 bottom
RV69  0_0603_5%  [R_0603]  142.68 26.93 270 bottom
RV70  0_0201_5%  [R0201_0OHM]  35.47 76.31 90 top
RV71  0_0201_5%  [R0201_0OHM]  34.9 76.31 90 top
RV75  2A_65V_T0603FF2000TM  [F_T0603FF1000TM]  130.73 28.24 180 top
RV76  0.5A_65V_T0603FF0500TM  [F_T0603FF0500TM]  48.73 59.48 270 top
RV77  0.5A_65V_T0603FF0500TM  [F_T0603FF0500TM]  32.12 74.82 0 top
RV78  0_0603_5%  [R0603_0OHM]  38.42 73.17 90 top
RV80  100K_0201_5%  [R_0201]  35.03 69.46 270 top
RV81  1M_0201_5%  [R_0201]  35.03 71.82 0 top
RV83  0_0201_5%  [R0201_0OHM]  35.76 73.87 90 top
RV84  0_0201_5%  [R0201_0OHM]  35.06 74.54 180 top
RV85  10K_0201_5%  [R_0201]  264.51 45.76 90 top
RV86  0_0201_5%  [R0201_0OHM]  268.01 45.84 180 top
RV87  10K_0201_5%  [R_0201]  267.42 45.22 0 top
RV88  10K_0201_5%  [R_0201]  118.03 29.62 180 top
RV89  3.9K_0201_1%  [R_0201]  58.01 61.83 0 bottom
RV90  14K_0201_1%  [R_0201]  43.74 70.63 270 top
RV91  100_0201_1%  [R_0201]  38.1 71.82 90 top
RV92  10K_0201_5%  [R_0201]  43.7 68.7 180 top
RV93  1K_0603_5%  [R_0603]  33.13 73.52 0 top
RV94  0.5A_65V_T0603FF0500TM  [F_T0603FF0500TM]  135.57 24.24 90 bottom
RV95  0.5A_65V_T0603FF0500TM  [F_T0603FF0500TM]  50.51 74.22 90 top
RV96  499K_0201_1%  [R_0201]  84.12 57.44 0 bottom
RV97  499K_0201_1%  [R_0201]  83.53 57.43 180 bottom
RW19  100K_0201_5%  [R_0201]  222.26 38.44 180 top
RZ2  0_0201_5%  [R0201_0OHM]  101.04 15.32 180 bottom
RZ18  0_0402_5%  [R_0402]  45.36 28.59 0 top
RZ19  10K_0201_5%  [R_0201]  46.77 37.46 270 top
RZ21  10K_0201_5%  [R_0201]  41.57 31.16 90 top
RZ23  0_0201_5%  [R_0201]  41.57 32.37 90 top
RZ27  49.9_0201_1%  [R_0201]  41.95 37.46 270 top
RZ28  49.9_0201_1%  [R_0201]  46.3 39.13 180 top
RZ29  49.9_0201_1%  [R_0201]  46.2 37.46 270 top
RZ30  0_0201_5%  [R0201_0OHM]  45.06 37.46 270 top
RZ32  33_0201_5%  [R_0201]  45.63 37.46 270 top
RZ34  0_0402_5%  [R_0402]  41.62 28.66 0 top
RZ37  0_0201_5%  [R_0201]  45.53 29.36 0 top
RZ38  0_0402_5%  [R_0402]  48.36 39.39 180 top
RZ39  0_0402_5%  [R_0402]  47.71 37.06 90 top
RZ1412  150_0402_5%  [R_0402]  148.7 18.15 270 bottom
RZ1413  0_0402_5%  [R_0402]  49.18 42.4 270 top
SW2  SKRBACE010_4P  [SW_SKRBACE010_4P]  196.23 57.29 90 bottom
SW3  SSAL120100_3P  [SW_SSAL120100_3P]  22.94 5.36 0 top
T1  PAD~D  [TPC12]  81.63 52 0 top
T2  PAD~D  [TPC12]  80.24 52.15 0 top
T3  PAD~D  [TPC12]  76.25 30.24 180 bottom
T4  PAD~D  [TPC12]  75.54 39.83 0 top
T5  PAD~D  [TPC12]  76.94 39.83 0 top
T6  PAD~D  [TPC12]  78.84 30.24 180 bottom
T7  PAD~D  [TPC12]  99.43 28.39 0 top
T11  PAD~D  [TPC12]  99.4 30.13 0 top
T16  PAD~D  [TPC12]  73.38 30.24 0 bottom
T17  PAD~D  [TPC12]  74.78 30.24 0 bottom
T18  PAD~D  [TPC12]  114.96 36.05 0 bottom
T19  PAD~D  [TPC12]  114.34 37.23 180 bottom
T20  PAD~D  [TPC12]  93.32 30.24 0 bottom
T21  PAD~D  [TPC12]  98.65 46.04 180 top
T24  PAD~D  [TPC12]  98.22 28.82 180 top
T26  PAD~D  [TPC12]  98.11 30.09 180 top
T27  PAD~D  [TPC12]  61.57 32.02 0 bottom
T28  PAD~D  [TPC12]  60.3 32.02 0 bottom
T29  PAD~D  [TPC12]  90.88 50.84 180 top
T30  PAD~D  [TPC12]  90.87 41.2 180 top
T50  PAD~D  [TPC12]  75.64 55.35 0 top
T51  PAD~D  [TPC12]  74.14 57.32 180 bottom
T134  PAD~D  [TPC12]  88.39 49.71 180 top
T135  PAD~D  [TPC12]  89.13 41.45 180 top
T138  PAD~D  [TPC12]  115.77 37.34 180 bottom
T139  PAD~D  [TPC12]  115.62 38.66 180 bottom
T140  PAD~D  [TPC12]  113.3 58.46 180 bottom
T141  PAD~D  [TPC12]  113.28 59.81 180 bottom
T142  PAD~D  [TPC12]  59.03 32.02 180 bottom
T143  PAD~D  [TPC12]  59.63 33.57 180 bottom
T144  PAD~D  [TPC12]  58.97 54.25 180 bottom
T145  PAD~D  [TPC12]  60.96 54.2 180 bottom
T146  PAD~D  [TPC12]  242.16 69.18 180 bottom
T147  PAD~D  [TPC12]  243.43 69.18 180 bottom
T148  PAD~D  [TPC12]  244.7 69.18 180 bottom
T149  PAD~D  [TPC12]  245.97 69.18 180 bottom
T150  PAD~D  [TPC12]  247.24 69.18 180 bottom
T151  PAD~D  [TPC12]  113.5 36.15 0 bottom
TC1  PAD~D  [TPC12]  26.23 66.26 0 top
TC2  PAD~D  [TPC12]  26.03 67.53 0 top
TC6  PAD~D  [TPC12]  26.26 73.35 0 top
TC7  PAD~D  [TPC12]  25.89 74.77 0 top
TK1  PAD~D  [TPC12]  235.08 9.85 0 top
TV1  PAD~D  [TPC12]  40.14 77.7 0 top
TV2  PAD~D  [TPC12]  41.45 77.65 0 top
U4  AOZ1331DI_DFN_14  [EM5209VF_DFN14_3X2]  256.32 40.71 180 top
U5  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  85.79 64.84 270 bottom
U6  AOZ1331DI_DFN_14  [EM5209VF_DFN14_3X2]  196.79 33.29 270 top
U7  -  [74AUP1G07GW_TSSOP5]  65.58 65.74 90 top
U8  -  [AOZ1336DI_DFN8_2X2]  223.81 57.93 0 top
U10  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  70.52 65.35 90 top
U11  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  98.03 19.02 180 top
U12  AOZ1331DI_DFN_14  [EM5209VF_DFN14_3X2]  122.75 28.41 0 top
U15  -  [AOZ1336DI_DFN8_2X2]  186.01 14.02 180 bottom
U16  SX9324ICSTRT_WLCSP8  [SX9324ICSTRT_WLCSP_8P]  200.83 67.87 90 bottom
U17  -  [RT9078N-08GJ5_TSOT23-5]  228.13 44.18 0 top
U19  -  [AOZ1336DI_DFN8_2X2]  225.93 49.75 90 top
U27  -  [MX25L25645GM2I-10G_SO8]  112.95 12.08 90 top
U32  -  [74LV1T32GW_SOT353-1-5]  224.9 54.62 0 top
U33  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  285.33 71.45 0 bottom
UA1  -  [ALC3254-VA3-CG_MQFN48_6X6]  280.45 26.22 0 top
UA7  -  [AOZ1336DI_DFN8_2X2]  282 11.65 0 top
UA8  AOZ1331DI_DFN_14  [EM5209VF_DFN14_3X2]  267.43 40.71 180 top
UC2  -  [TC7SH08FU_SSOP5]  97.13 21.04 90 bottom
UC9  SN74AUP1G07DCKR_SC70  [74AUP1G07GW_TSSOP5]  59.37 30.66 270 bottom
UC10  -  [TC7SH08FU_SSOP5]  96.61 13.91 0 top
UC17  -  [AOZ1336DI_DFN8_2X2]  47.05 71.33 0 top
UC18  W25Q256JVEIQ_WSON8_8X6  [W25Q256JVEIQ_WSON8_8X6-S]  113.32 12.08 90 top
UC19  -  [TC7SH08FU_SSOP5]  126.99 31.69 180 bottom
UCPU1  WHL-U42_BGA1528  [WHL-U42_BGA_1528P-T]  65.06 55.38 270 bottom
UD1  H9CCNNN8JTMLAR-NTM_FBGA178~D  [H9CCNNN8JTMLAR-NTM_FBGA_178P]  94.12 17.43 90 bottom
UD2  H9CCNNN8JTMLAR-NTM_FBGA178~D  [H9CCNNN8JTMLAR-NTM_FBGA_178P]  60.22 17.43 90 top
UD3  H9CCNNN8JTMLAR-NTM_FBGA178~D  [H9CCNNN8JTMLAR-NTM_FBGA_178P]  83.72 17.43 90 top
UD4  H9CCNNN8JTMLAR-NTM_FBGA178~D  [H9CCNNN8JTMLAR-NTM_FBGA_178P]  70.62 17.43 90 bottom
UE1  MEC5105_WFBGA169_11X11  [MEC5105_WFBGA_169P]  262.63 61.21 0 top
UE4  -  [74AUP1G07GW_TSSOP5]  255.53 50.69 0 top
UI2  PS8713BTQFN24GTR2_TQFN24_4X4  [PS8713BTQFN24GTR2_TQFN24_4X4-S]  286.1 44.34 0 top
UI4  -  [SLGC55544CVTR_TQFN16_3X3]  286.21 62.55 270 top
UI5  -  [SLGC55544CVTR_TQFN16_3X3]  19.9 14.78 180 top
UK1  -  [ECE1117-Y3-1-TR_SQFN48_7X7]  236.45 18.64 270 top
ULID1  BU52072GWZ-E2_UCSP35L1-4  [BU52058GWZ-E2_UCSP35L1_4P]  18.17 20.39 180 bottom
UM3  -  [AP2330W-7_SC59-3]  20.04 32.73 180 top
UN1  -  [PI3PCIE3212ZBEX_TQFN20_2P5X4P5]  250.54 23.5 90 top
UN3  -  [BGSA14RN10_TSNP10]  197.33 73.17 0 top
UN4  -  [SN74LVC1G3157DCKR_SC70-6]  260.91 45.82 180 top
UN5  -  [74AUP1G97GW_SOT363-6]  261.01 39.78 180 top
UR1  -  [RTS5242-GR_QFN32_4X4]  291.04 36.72 0 top
UR2  -  [G517AH1TP1U_TSOT23-6]  286.59 37.86 0 top
UT1  TPS65982DCZQZR_BGA96  [TPS65982DCZQZR_BGA_96P]  28.23 69.92 180 bottom
UT2  AR-4C_BGA337  [AR-4C_BGA_337P-T]  18.52 57.33 90 bottom
UT3  -  [W25Q80DVZPIG_WSON8]  34.01 49.07 180 top
UT4  GD25Q80CWIGR_WSON8  [W25Q80DVZPIG_WSON8]  25.49 62.25 270 top
UT5  TPS65982DCZQZR_BGA96  [TPS65982DCZQZR_BGA_96P]  28.23 76.93 180 bottom
UT14  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  34.28 55.02 180 top
UT15  -  [TS5A3159ADCKR_SC70-6]  31.55 55.02 180 top
UT16  -  [RT9069-33GB_SOT23-5]  13.1 67.26 180 bottom
UV1  -  [G517AH1TP1U_TSOT23-6]  39.43 71.72 270 top
UV5  -  [LNG2DMTR_LGA12_2X2]  247.36 40.44 270 top
UV6  -  [TUSB211RWBR_X2QFN12_1P6X1P6]  55.82 59.64 0 bottom
UZ3  -  [TPS22961DNYR_WSON8]  99.01 64.26 0 bottom
UZ4  -  [TPS22961DNYR_WSON8]  80.64 62.78 0 bottom
UZ5  -  [TPS22961DNYR_WSON8]  99.2 17.36 270 bottom
UZ6  -  [ST33HTPH2E32AHB4_VQFN32_5X5]  43.57 30.59 90 top
YC1  24MHZ_12PF_7M24090001  [Y_X3G024000DC1H_4P]  106.78 62.37 0 bottom
YC2  32.768KHZ_9PF_9H03280012  [Y_9H03280012_2P]  99.67 24.4 180 bottom
YE1  32.768KHZ_9PF_9H03280012  [Y_9H03280012_2P]  261.36 64.92 0 top
YT1  25MHZ_20PF_X3S025000BK1H  [Y_7M25000016_4P]  17.44 43.81 0 bottom

## Library data of the parts
C14 C21 CN2-CN4 CN6-CN8 CN11 CN16-CN21 CN39 CN40 CS9 = C_0201: room: WWAN
C15 C26 C27 C29 C30 C37 C38 C41 C48 C50-C52 C56 C59 C60 C62 C70 C74 C78 C85 C86 C88 C92-C97 CA8 CA9 CA13 CA32 CA34 CA44 CA45 CA48 CA49 CA84-CA87 CA147 CA148 CA153-CA155 CB15-CB17 CB19-CB22 CC2 CC6-CC8 CC10 CC12 CC13 CC15 CC17 CC65-CC69 CC72 CC73 CC76 CC80 CC83 CC85-CC89 CC92 CC98 CC101 CC199 CC200 CC233 CC238 CC239 CC242-CC244 CC246-CC255 CC257-CC259 CC261 CC263 CD4 CD6 CD16 CD19-CD22 CD26-CD28 CD46 CD47 CD57 CD67 CD70-CD72 CD74 CD111 CE35 CE37 CE50 CE55 CE57 CE58 CE60 CE69 CE113 CE115 CI9-CI14 CI35 CI36 CK1 CK3 CK13 CM49-CM52 CN23-CN26 CN29 CN34 CN42 CN44 CN46 CN48 CN59 CN60 CP2 CR5 CR8 CR13 CR20 CS1-CS7 CS10-CS15 CT27-CT61 CT66-CT78 CT94-CT99 CT129-CT131 CT134-CT138 CT141-CT170 CT180 CT181 CT192 CT193 CT195-CT200 CT204 CT205 CV5-CV8 CV17 CV18 CV20 CV37 CV39 CV40 CV50-CV53 CV55 CV56 CZ1 CZ2 CZ5-CZ7 CZ22 CZ23 PC103 PC105 PC106 PC116 PC118 PC119 = C_0201
C18 = C_0201: room: KB
C22 = C_0402: room: TBT
C28 C39 C49 C53 C72 C75 CA141 CC9 CC11 CC47-CC50 CC53-CC56 CC201-CC203 CC240 CD5 CD7-CD11 CD13-CD15 CD18 CD23-CD25 CD29 CD30 CD33-CD39 CD51-CD56 CD58 CD60 CD61 CD63 CD65 CD66 CD68 CD75-CD79 CD82-CD85 CE3 CE25 CE26 CN41 CR18 CV27 CZ3 CZ15 CZ18-CZ20 CZ28 = C_0201: room: CPU
C31 C32 C57 C61 CV26 = C_0201: room: Other
C71 C73 = C_0201: room: MCP
CA1 CA4 CA6 CA12 CA14 CA21 CA23 CA24 CA27 CA28 CA30 CA31 CA35 CA36 CA46 CA47 CA150 CA151 = C_0201: room: AudioCodec
CA5 CC260 CD104 CD109 CD112 CD113 CE5 CE44 CE116 CI25 CI32 CK2 CK12 CS8 CT62-CT65 CT101 CT102 CT139 CT140 CT202 CT206 CV13 CV25 CV38 CZ21 PC130 PC131 PC137 PC140 PC212 PC213 PC226 PC227 PC238-PC240 PC243 PC305 PC310 PC313 PC400 PC405 PC413 PC418 PC424 PC700 PC904 PC907 PC909-PC912 PC1004 PC1005 PC1019 PC1020 PC1104 PC1105 PC1113 PC1114 PC1409 PC1419 PC1423-PC1426 PC1500-PC1505 PCB46 = C_0402
CA7 CA11 CA15 CA16 CA18-CA20 CA22 CA25 CA26 CA29 = C_0402: room: AudioCodec
CA10 CA42 CA43 CA152 CC70 CC100 CC102 CC262 CC265 CE7 CI24 CI28 CI29 CI31 CN1 CN5 CN22 CN47 CT79-CT81 CT100 CT103 CT132 CT133 CT201 PC203-PC210 PC214-PC217 PC221 PC222 PC225 PC230 PC303 PC304 PC306-PC308 PC311 PC312 PC403 PC404 PC406-PC410 PC416 PC417 PC419-PC423 PC426 PC501 PC502 PC600 PC601 PC610-PC613 PC615 PC616 PC619 PC620 PC802 PC805 PC807-PC810 PC1200-PC1206 PC1214-PC1224 PC1232-PC1236 PC1277-PC1285 PC1305-PC1316 PC1323-PC1348 PC1365-PC1376 PC1421 PC1422 = C_0603
CA144-CA146 CA149 = C_0201: room: AUDIO
CB18 = C_0201: room: RTC
CC4 = C_0201: room: SPI_ROM
CC31 CC33-CC42 CC45 CC46 CC51 CC52 CC232 CC234-CC237 CD1-CD3 CD12 CD17 CD31 CD32 CD40 CD41 CD48-CD50 CD59 CD62 CD64 CD73 CD80 CD81 = C_0402: room: CPU
CC32 CC241 CI21 CI22 = C_0603: room: CPU
CC245 CZ16 CZ17 = C_0402: room: TPM
CD100-CD103 CD105-CD108 = C_0201: room: PD_3
CE1 CE2 CE4 CE6 CE8-CE12 CE14 CE15 CE20 CE21 CE30-CE32 = C_0201: room: EC
CE18 CE19 CE22 CE23 CE112 = C_0402: room: EC
CE34 CE41 = C_0201: room: KBC
CI23 CI26 CI27 CI30 = C_0201: room: type-A
CK8-CK11 = C_0201: room: SENSOR-proximity
CLCMOS1 CLEC1 CLME1 = SHORTPADS: User Part Number: PART#
CLIP1-CLIP6 = EMIST_SUL-12A2M_1P
CM6 CM7 CM14-CM18 CM20 CM46 CM48 = C_0201: room: HDMI
CM47 = C_0402: room: HDMI
CN9 CN10 = C_NEC: room: WWAN
CN12 CN13 = C_0402: room: WWAN
CN14 CN15 = C_0201: signal model: C_0201_0.1U_0201_10V6K; room: WWAN
CN27 CN28 CN32 CN33 CV21 = C_0402: room: Card reader
CN30 CN31 CN35 CN36 = C_0201: room: WLAN
CN43 = MURAT_LQP03TN6N8J02D_2P
CN45 = MURAT_LQP03TN1N2B02D_2P
CN49-CN56 = C_0201: room: USB,PCIE
CN57 CN58 = C_0201: room: UZ3
CP1 = C_0201: room: TouchPAD
CR1 CR4 CR6 CR10 CR12 CR15-CR17 = C_0201: room: SOC
CR2 CR9 = C_0402: room: +VPP_2.5V
CR3 CR11 CR14 = C_0402: room: CARD READER
CR21 CR22 = C_0201: room: PCIE Re-driver
CT1-CT26 = C_0201: room: AR
CT104 CT105 CT108 CT109 = C_0201: room: TYPE_C_2
CT106 CT107 CT110 CT111 = C_0201: room: TYPE_C_1
CT171 CT172 CT174 CT179 CT183 = C_0402: room: PD_1
CT173 CT182 = C_0201: room: PD_1
CT175-CT178 = C_0603: room: PD_1
CT184 CT186 CT191 = C_0402: room: PD_2
CT185 CT194 = C_0201: room: PD_2
CT187-CT190 = C_0603: room: PD_2
CV1 CV4 CV19 CV22 CV44 CV45 = C_0201: room: eDP TS
CV2 CV3 CV16 = C_0402: room: eDP TS
CV23 = C_0201: room: EDP
CV24 = C_0603: room: Card reader
CV31 = C_0402: room: CAM
CV32 CV33 = C_0201: room: CAM
CV34 = C_0201: room: CAMERA
CV41 = C_0402: room: LCD
CV42 CV43 = C_0201: room: SENSOR
D3 DI9 DS1 = L05ESDL5V0NA-4_SLP2510P8-10-9
D9 DV12 = BAT54LPS-7_X2-DFN1006-2-2: room: TBT
D203 = RB751S40T1G_SOD523-2
D481 = RB751V40_SC76-2
DA1 = AZ5125-01HPR7G_SOD523-2: room: AudioCodec
DA4 DA5 DA8 DA9 DA25 DA26 = AZ5123-01FPR7G_DFN1006P2X2: room: AudioCodec
DA10-DA13 = ESD203-B1-02EL_TSLP-2-20-2: room: AMP
DA27 = RB751S-40_SOD523-2: room: AudioCodec
DB3 DB4 = BAT54HT1G_SOD323-2: room: MEC1641
DB5 DB9 DC5-DC8 DE7 DE8 = RB751S-40_SOD523-2
DC1 DC2 DT47-DT49 PD102 PD103 PD1500-PD1505 PDB4 PDB5 = RB520SM-30T2R_EMD2-2
DE4 DI7 DI8 DI13 DI14 DP1-DP4 DT12-DT27 DV4-DV7 DV10 DV11 = AZ5B25-01F_DFN0603P2Y2
DE6 = RB751V40_SC76-2: room: FAN1
DI15-DI18 DM1-DM8 DT4 DT6-DT11 DT28-DT35 DT42 = ESD101-B1-02ELS_TSSLP-2-4-2
DN7 = BAT54CW_SOT323-3
DS2 = PESD5V0U2BT_SOT23-3
DT43 = BZT52C15LP-7_DFN1006-2-2: room: PD_1
DT44 = PESD24VS2UT_SOT23-3: room: PD_1
DT45 = BZT52C15LP-7_DFN1006-2-2: room: PD_2
DT46 = PESD24VS2UT_SOT23-3: room: PD_2
DV1-DV3 = BAT54CW_SOT323-3: room: eDP TS
DV13 DV14 = RB751S-40_SOD523-2: room: GPU
FD1-FD4 = FIDUCIAL_C40M80
FK1 = F_0402L050SLKR: room: eDP TS
H1-H4 = H_3P8N
H5 H6 H9 H10 = H_4P2
H7 H8 = CLIP_C6-NPM
H30-H35 H38 H39 = H_2P3
H36 H37 = H_3P2
H63 H66 = H_1P1X1P5N
H64 H65 = H_1P1N
H72 = H_4P2N
H73 = H_1P8X2P2N
H75 = H_1P8N
H76 H78 = H_1P3N
H77 = H_1P3X1P8N
JANT1 JANT2 = BELLW_10093-1021_4P: room: WWAN
JAPS1 = ACES_50506-01841-P01_18P
JBATT1 = DEREN_40-42507-01001RHF_10P-T: room: BATT_CONNECTOR
JBL1 = ACES_51575-00401-001_4P
JCAM1 = I-PEX_20599-021E-01_21P-T
JCR1 = T-SOL_158-1160902600_23P-T: room: CARD READER
JDEG1 JSPI1 = ACES_50521-01041-P01_10P: room: EC5085
JEDP1 = I-PEX_20879-040E-01_40P-T
JESPI1 = ACES_50521-01041-P01_10P: room: TBT_CCG5
JFAN1 = ACES_50224-00401-001_4P: room: FAN1
JFP1 = FOX_QT510166-L010-7H_16P
JHDMI1 = LOTES_AHDM0056-P001A_19P: room: HDMI
JHP1 = SINGA_2SJ3095-052111F_6P-T: room: AudioCodec
JKB1 = JXT_FP257H-032S10M_32P
JLED1 JPTN1 = ELCO_46809604110846_4P-T: room: LED
JLTE1 JLTE2 = I-PEX_20854-005E-00_5P-T
JNGFF1 = LOTES_APCI0144-P007A_75P: room: WWAN
JNGFF2 = LOTES_APCI0146-P004A_75P
JNGFF3 = LOTES_APCI0147-P007A_75P
JRTC1 = ACES_50278-00201-001_2P
JSIM1 = JAE_SF51S006V4DR1000Q_8P: room: SIM
JSPK1 = ACES_50208-00601-P01_6P: room: AMP
JTP1 = STARC_106A08-001020-A2-R_8P-T
JUSB1 JUSB2 = SANTA_375230-1_9P
JUSBC1 = JAE_DX07SD24JJ2R1300_24P: room: TYPEC-P1
JUSBC2 = JAE_DX07SD24JJ2R1300_24P: room: TYPEC-P2
JUSH1 = CVILU_CF5026FD0RK-05-NH_26P-T
JXDP1 = JXT_FP270H-061G1AM_61P
L2 LB1 LI1 LI4 LN4 LV6 = MURAT_DLM0NSN900HY2D_4P: room: WWAN
L3 LN9-LN11 = MURAT_BLM15AG121SN1D_L0402_2P
LA1 = MURAT_BLM21PG600SN1D_2P: room: AudioCodec
LA2 = CHILI_PBY160808T-300Y-N_2P: room: AudioCodec
LA3-LA6 = MURAT_BLM15PX330SN1D_2P: room: AudioCodec
LA7-LA10 = MURAT_BLM15PX121SN1D_2P: room: AMP
LC1-LC3 = MURAT_BLM18EG221TN1D_2P
LED1 LED_PRI LED_RST LED_RUN = LED_HT-F196BP5_2P
LN6 = MURAT_DLM0NSN900HY2D_4P
LN12 LN13 = MURAT_LQP03TN1N8B00D_2P
LN14 = MURAT_LQP03TN3N3B00D_2P
LN15 R208 R223 R243 R246 R247 R249 R250 R258 R271 R273 R278 R279 R282 RC48 RC157 RC159 RC383 RC429 RC430 RC471 RC472 RC512 RC566 RC574-RC576 RC612 RC626 RC631 RE193 RE199 RE469 RE477 RE478 RE484 RE511-RE513 RE532 RE534 RI68 RN10 RN98 RN100-RN104 RN117 RN118 RS10 RS14 RS15 RT71 RT302 RT303 RV83 RV84 RV86 RZ2 RZ30 = R0201_0OHM
LS3-LS6 = MURAT_LQG15HSR15J02D_2P
LT1 = MAG_MND-04ABIR60M-XGL_2P
LT2 = CHILI_PBY160808T-300Y-N_2P
LT3 = R_0805: room: PD_1
LT4 = R_0805: room: PD_2
LT9-LT12 = MURAT_DLM0NSN900HY2D_4P: room: TBT
PC100-PC102 PC104 PC107 PC111-PC115 PC117 PC120 PC124 = C_0402: room: PWR_DCIN
PC108 PC121 = C_0603: room: PWR_DCIN
PC109 PC122 PC231 PC232 = C_0603: room: PWR_CHARGER
PC110 PC123 = C_0402: room: TYPE_C_1
PC132 = C_0402: room: BATT_CONNECTOR
PC133-PC135 = C_0201: room: BATT_CONNECTOR
PC136 PC142 = C_0402: room: CCG5_LPS_12
PC138 PC141 = C_0402: room: BATT CON
PC139 PC143 = C_0402: room: PDDR
PC200-PC202 PC211 PC224 PC228 PC229 PC233-PC237 PC241 PC244 PC245 = C_0402: room: PWR_CHARGER
PC218 PC219 PC300 PC1008 PC1010 PC1011 PC1117 PC1118 = C_B2
PC223 = C_0402: room: P_USBB
PC301 PC302 PC401 PC402 PC414 PC415 = C_0402: room: 3_5V
PC309 = C_0201: room: P_MLCC
PC314 PC412 PC425 PC512 = C_0402: room: 1.8VA
PC411 = C_0402: room: PWR_LCD
PC500 PC503 PC504 = C_0402: room: PWR_+3VALW
PC505 PC510 = C_0201: room: PWR_+3VALW
PC506-PC509 = C_0603: room: PWR_+3VALW
PC602-PC607 PC609 PC614 = C_0402: room: P_1.2V
PC608 = C_0603: room: P_1.2V
PC800 = C_0603: room: +1VA
PC801 PC804 PC806 PC811 PC813 = C_0402: room: +1VA
PC803 = C_0201: room: +1VA
PC900 PC902 PC903 PC905 PC906 PC908 PC914 PC1006 = C_0402: room: ISL95859
PC901 PC913 = C_0603: room: ISL95859
PC1000 PC1007 PC1015 PC1021 PC1022 PC1100 PC1106-PC1108 PC1116 PC1410 PC1420 = C_0402: room: VCC_GT_SA
PC1001 PC1016 PC1101 PC1109 = C_0402: room: IA
PC1002 PC1003 PC1017 PC1018 PC1102 PC1103 PC1110-PC1112 = C_0603: room: VCC_SA
PC1013 PC1119 = C_D2: room: IA
PC1115 = C_0603: room: VCC_GT_SA
PC1237-PC1241 = C_B2: room: CORE_CAP
PC1242-PC1276 = C_0201: room: CORE_CAP
PC1286-PC1304 = C_0201: room: IAGT_CAP
PC1349 PC1350 = C_B2: room: GT_CAP
PC1351-PC1364 = C_0201: room: GT_CAP
PC1377-PC1383 = C_0201: room: SA_CAP
PC1401-PC1405 PC1414-PC1418 = C_0603: room: PRIM
PC1406 PC1407 PC1412 PC1413 = C_0402: room: PRIM
PC1408 PC1411 = C_0402: room: VCCIO
PD104 PD105 = TVNST52302AB0_SOT523-3: room: BATT_CONNECTOR
PD200 = SMF4L22A_SOD123FL2
PD201 PD202 RTCD3 = RB520SM-30T2R_EMD2-2: room: P_CHRG
PJP300 PJP400 PJP401 = JUMP_43X118
PJP500 = JUMP_43X118: room: PWR_CHARGER
PJP600 = JUMP_43X118: room: P_1.2V
PJP601 = JUMP_43X39: room: PWR
PJP800 = JUMP_43X79: room: +1VA
PJP1400 = JUMP_43X79: room: VCCIO
PJP1401 = JUMP_43X79: room: PRIM
PL100-PL104 PL300 PL302 PL400 PL402 PL404 PL405 PL501 PL600 PL800 PL1001-PL1003 PL1005 PL1101 PL1103 PL1104 = TAI-T_HCB2012KF-121T50_2P
PL200 = MAG_MLV-FY12N1R0M-C1L_2P
PL201 = MAG_MMD-10BDE1R5M-R1L_2P
PL301 = MAG_MMD-06CZ-1R5M-V1_2P
PL401 PL403 = MAG_MMD-05AHN1R5M-M1L_2P
PL500 = CYNTE_PCMB042T-1R0MS_2P: room: PWR_+3VALW
PL601 = CHILI_MHCI05015B-1R0M-R8A_2P
PL801 = CYNTE_PCMB041B-1R0MS_2P: room: +1VA
PL1000 PL1004 PL1100 = CHILI_MHCB06024-R15M-C1R885_2P
PL1102 = CYNTE_CMME051B-R47MS_2P: room: VCC_SA
PL1400 PL1402 = CHILI_PBY160808T-300Y-N_2P: room: PRIM
PL1401 PL1403 = CHILI_HEI322512B-R68M-Q8_2P: room: PRIM
PQ100 PQ101 PQ115 PQ116 = AON7405_DFN8-5: room: PWR_DCIN
PQ102 PQ103 PQ117 PQ118 PQ1506 QT2 QT4 = SI1303DL-T1-E3_SOT323-3
PQ104-PQ106 PQ109 PQ112-PQ114 PQ119 PQ123 = DMN66D0LDW-7_SOT363-6
PQ107 PQ108 PQ110 PQ111 PQ120 PQ122 PQ124 PQ126 PQ129 PQ130 PQ205 PQ700 PQ1500-PQ1502 PQ1507 = L2N7002WT1G_SC70-3
PQ201 PQ203 = AON6962_DFN5X6D-8-7
PQ202 = AON7405_DFN8-5: room: P_Selector
PR100-PR102 PR107 PR110 PR113 PR116 PR119 PR121-PR124 PR128 PR132 PR136-PR139 PR144 PR146 PR149 PR151 PR153 PR155 PR158 PR160 PR161 PR163 PR169 PR172 PR189 PR191 R23 R24 R28 R145 R210 R217-R220 R222 R229 R238 R240-R242 R248 R266-R268 R272 R274 R276 R277 R280 R281 R283 RA110 RA118 RA126 RB21-RB23 RB25 RB34 RB35 RB40 RC1-RC8 RC10-RC13 RC17-RC20 RC23-RC27 RC29 RC38 RC40 RC41 RC45-RC47 RC49 RC50 RC53-RC55 RC57 RC59-RC61 RC66 RC68 RC71 RC73 RC74 RC76-RC82 RC85-RC90 RC92 RC106-RC109 RC116 RC118-RC120 RC124 RC125 RC150 RC151 RC154-RC156 RC158 RC160 RC161 RC163-RC166 RC217-RC221 RC225 RC230 RC239 RC240 RC242 RC244-RC248 RC250 RC252-RC258 RC366-RC369 RC371 RC381 RC387 RC388 RC395 RC397 RC402 RC405-RC419 RC433 RC436 RC439 RC443-RC446 RC451 RC452 RC454 RC458-RC460 RC463-RC470 RC473-RC477 RC481 RC485-RC491 RC499 RC500 RC503 RC511 RC516-RC519 RC521-RC529 RC531 RC538-RC540 RC546-RC551 RC555 RC556 RC560 RC564 RC565 RC568-RC573 RC577 RC580-RC585 RC594-RC597 RC599 RC606-RC609 RC611 RC613-RC625 RC630 RC632-RC634 RD1-RD82 RE1 RE187 RE190 RE192 RE197 RE198 RE241 RE472 RE473 RE521 RE522 RE524-RE527 RE529-RE531 RE535 RH51-RH60 RI29 RI30 RI38 RI40 RI42 RI44 RI55 RI67 RI72 RI74 RI76 RI78 RI101 RK4 RK6 RK8-RK10 RK12 RM94-RM107 RN3 RN7 RN25 RN28 RN71 RN77-RN82 RN85-RN92 RN97 RN99 RN105-RN116 RN119 RP6-RP9 RP15 RP16 RR13 RR14 RR20 RS1 RS2 RS11 RS12 RT3-RT7 RT9-RT11 RT13 RT14 RT18 RT19 RT21 RT23 RT25-RT27 RT29-RT41 RT44-RT47 RT80-RT83 RT97-RT102 RT106 RT108 RT112-RT115 RT123 RT125 RT129 RT138-RT140 RT147 RT148 RT151-RT153 RT155 RT159 RT160 RT163 RT165 RT177 RT185 RT189 RT267 RT284 RT285 RT287-RT300 RT304 RT305 RV39-RV41 RV43 RV44 RV46-RV48 RV50 RV51 RV57 RV58 RV60 RV80 RV81 RV85 RV87-RV92 RV96 RV97 RZ19 RZ21 RZ23 RZ27-RZ29 RZ32 RZ37 = R_0201
PR103 PR142 PR143 PR145 PR190 PR192-PR196 PR224 PR227 PR933 PR940 PR945 = R_0402: room: PWR_DCIN
PR104 PR105 PR112 PR115 PR147 PR148 PR150 PR152 PR178-PR184 PR187 PR202 PR203 PR207 PR226 PR231 PR236 PR302 PR304 PR307 PR308 PR310 PR403 PR411-PR414 PR502 PR504 PR510 PR701 PR705 PR803 PR905 PR917 PR918 PR920 PR921 PR924 PR932 PR936 PR938 PR939 PR941-PR944 PR1403 PR1404 PR1413 PR1416 PR1423 PR1431 PR1432 PR1500-PR1506 PR1512-PR1519 PRB36 PRB37 PRB40 PRB41 PRB45 R20 R101 R102 R139 R140 R151 R152 R209 R275 RA30 RA31 RC226 RE200 RE533 RK11 RR19 RT28 RZ18 RZ34 RZ38 RZ39 RZ1412 RZ1413 = R_0402
PR106 PR108 PR109 PR111 PR114 PR117 PR118 PR120 PR125-PR127 PR129-PR131 PR133-PR135 PR140 PR141 PR154 PR157 PR165-PR167 PR170 PR174 PR186 PR188 PR197 PR199 PR1204 = R0402_0OHM: room: PWR_DCIN
PR185 = R_0402: room: BATT_CONNECTOR
PR200 = R_1206_4P-D: room: CHARGER
PR201 PR204 PR217 PR219 PR230 PR808 PR902 = R_0402: room: PWR_CHARGER
PR205 PR210 = R_0603: room: PWR_CHARGER
PR206 PR208 PR215 PR216 = R_1206: room: PWR_CHARGER
PR209 = R_0201: room: PD-1
PR211 = R_1206_4P-D
PR212 PR228 PR229 = R0201_0OHM: room: PD-1
PR213 PR214 PR220 PR233 PR234 = R0402_0OHM: room: CPU_CORE
PR218 PR223 = R0402_0OHM: room: PWR_CHARGER
PR221 PR222 = R_0402: signal model: R_0402_1_0402_1%
PR225 = R_0402: room: PWR_Charger
PR232 = R_0201: room: Card reader
PR300 = R_0603: room: 3V5V
PR306 PR404 PR1507-PR1511 PRB39 PRB42 PRB46 PRB47 RC627 RC628 RE536 = R0402_0OHM
PR309 PR402 PR410 PR800 PR1003 PR1012 PR1103 PR1106 = R_0805: room: 3V_5VP
PR400 PR408 = R_0402: room: CPU_CORE
PR401 PR409 RV93 = R_0603
PR501 = R_0402: room: PWR_+3VALW
PR503 = R_0201: room: PWR_+3VALW
PR506 = R_0603: room: 3V_5VP
PR507 = R_0402: room: 3V5V
PR600 PR605 PR606 = R_0402: room: P_1.2V
PR602 PR603 = R_0603: room: P_1.2V
PR604 PR607 = R_0402: room: P_3VALW
PR702-PR704 PR706 = R_0402: room: PWR_BATT_SHIP
PR801 PR806 PR807 = R_0402: room: +1VA
PR900 PR908-PR910 PR912-PR915 PR923 PR928 PR929 PR931 PR937 = R_0402: room: ISL95859
PR901 PR903 PR904 PR906 PR907 PR911 PR916 PR919 PR922 PR925-PR927 PR930 PR934 PR935 PR1408 = R0402_0OHM: room: ISL95859
PR1000-PR1002 PR1009-PR1011 PR1100-PR1102 PR1104 PR1105 PR1107 = R0402_0OHM: room: VCC_GT_SA
PR1400-PR1402 PR1409 PR1414 PR1419-PR1421 PR1425-PR1427 = R_0402: room: PRIM
PR1405 PR1406 PR1410 PR1411 = R_0402: room: VCCIO
PR1407 PR1417 = R_0603: room: VCCIO
PR1412 PR1415 PR1418 PR1424 PR1428-PR1430 = R0402_0OHM: room: PRIM
PR1567 PR1568 = SOLDER_PREFORMS_0603
PT100-PT105 PT200 = TPC12: room: VCC_GT
PTB2 T138-T151 TK1 = TPC12
PU101 PU102 PU1500 PU1501 = AZV3001FZ47_X2DFN1410-6_1P4X1
PU200 = ISL9538BHRTZ-T_TQFN32_4X4
PU300 = MP8733AGLE-Z_QFN21_3X4
PU400 PU401 = NB679AGD-Z_QFN12_2X3
PU500 = NB591GG-Z_QFN11_2X2
PU600 = SY8210AQVC_QFN19_4X3: room: 1.2V
PU700 = SN74LVC1G123DCUR_VSSOP8: room: PWR_BATT_SHIP
PU800 = SY8286RAC_QFN20_3X3: room: +1VA
PU900 = MP2979AGQKT-0030-Z_TQFN48_6X6
PU1000 PU1001 PU1100 = MP86901-CGLT-Z_TQFN21_3X4
PU1101 = MP86901-AGQT-Z_TQFN13_3X3
PU1400 PU1401 = NB692GD-Z_QFN13_2X3
PUB2 = MC74VHC1G08DFT2G_SC70-5
Q3 Q13-Q15 QB6 QM1 QN4 QN5 QN7-QN9 QN12 = DMN2400UV-7_SOT-563-6
Q12 = DMN2400UV-7_SOT-563-6: room: WWAN
QB5 QK2 QK5 QV12 = DMG2301U-7_SOT23-3
QC1 = DMN2400UV-7_SOT-563-6: room: CPU
QC2 QE4 QE26 QK3 QK4 QM2 QM3 QN3 QN6 QN11 = L2N7002WT1G_SC-70-3
QC3 QV1 = DMG2301U-7_SOT23-3: room: CMAERA
QE1 QE10 QE11 = L2N7002WT1G_SC-70-3: room: EC
QE5 QV5 QV7 QZ21 = LMBT3904WT1G_SC70-3
QE8 QE12 QE14 QE17 QE23 = PMZ370UNE_DFN1006-3
QK1 QN10 = DMG6968U-7_SOT23-3
QN2 = L2N7002WT1G_SC-70-3: room: KB
QR1 = L2N7002WT1G_SC-70-3: room: CARD READER
QT1 = DMN65D8LW-7_SOT323-3
QT3 QV11 = L2N7002DW1T1G_SC88-6
QV4 QV6 = MMBT3906H_SOT23-3
QV10 = SI3457BDV-T1-E3_TSOP6
QZ20 = LMUN5111T1G_SC70-3
R26 RV76 RV77 RV94 RV95 = F_T0603FF0500TM
R27 R31 R33 R43 R44 R46 R47 R58 R59 R205 R284 RB36-RB39 RK5 RR16 RV78 = R0603_0OHM
R103 R206 R207 RT49 RT50 = R0603_0OHM: room: Other
R221 RE91-RE96 RE98 RE104-RE106 RE108-RE113 RE115 RE116 RE118-RE122 RE124 RE126 RE129 RE131 RE135 RE136 RE138 RE141 RE142 RE147-RE149 RE151 RE153-RE155 RE161-RE164 RE166 RE172 RE177 RE180 RE186 RE209-RE213 RE486-RE490 RE495-RE497 RE499-RE506 RE515 RE516 RE518 RE519 RN95 = R_0201: room: EC
R256 = R_0402: room: PD-1
RA1 RA5 RA6 RA9 RA13 RA14 = R0402_0OHM: room: AudioCodec
RA2 RA4 RA7 RA8 RA12 RA16 RA22 RA33 RA34 RA117 RA120 RA121 RA123 RA124 = R_0201: room: AudioCodec
RA10 RA125 = R0201_0OHM: room: AudioCodec
RA11 RA15 RA21 RA23 RA29 = R_0402: room: AudioCodec
RA109 = R0201_0OHM: room: AMP
RA112 RA115 RA116 = R0603_0OHM: room: AUDIO
RA122 = R0201_0OHM: room: CPU-CLK-PM-RTC
RB24 = R0201_0OHM: room: TBT
RC58 RC62 RC63 RC65 RC67 RC530 = R_0201: room: CPU-CLK-PM-RTC
RC111-RC113 RC482-RC484 RC559 RE509 RR9 RR11 RV54 RW19 = R_0201: room: SOC
RC153 = R0603_0OHM: room: CPU
RC173 = R_0603: room: Other
RC175 = R_0402: room: Other
RC222 RI48-RI51 RI59-RI62 RN21 RN22 RN26 RN43 RN45 RN57-RN64 RV62 RV63 = R0201_0OHM: room: CPU
RC223 RC227-RC229 RC231-RC238 RC241 RC243 RC370 RC420 RC434 RC435 RN24 RN27 RV66 RV67 = R_0201: room: CPU
RC249 = R_0402: room: SOC
RC251 = R_0402: room: CPU_XDP
RC375 RC376 RC403 RC404 = R_0201: signal model: R_0201_0_0201_5%
RC394 RC424 RC604 RN48 = R_0201: room: MCP
RC425 RC426 RT8 RT24 RT69 RT72 RT91 RT92 = R0201_0OHM: room: AR
RC431 RC432 = R0201_0OHM: signal model: R_0201_0_0201_5%
RC501 RC502 = SHORTPADS: User Part Number: PART#; room: CPU
RC534 = R0402_0OHM: room: Other
RC541 = R_0402: room: MCP
RC542 = R0402_0OHM: room: MCP
RC545 = R_0201: room: I2C-UART-ISH
RE90 RE97 RE99 RE144 RE158 RE165 RE167 RE179 RE182 RE480 RE482 RE485 RE507 = R0201_0OHM: room: EC
RE103 = R0402_0OHM: room: EC
RE114 RE123 RE125 = R_0402: room: EC
RE183 RE184 = R0603_0OHM: room: EC
RE188 = R0402_0OHM: room: SIO
RE189 = R_0402: room: SIO
RE457 RE467 RE468 RE508 RP3-RP5 RP14 RR2-RR8 RR12 = R0201_0OHM: room: SOC
RE474 = R_0402: room: KBC
RI53 RI64 RI123 RI124 RI143 RI144 = R_0201: room: USBB
RK7 = R_0402: room: KB
RM31-RM42 RN74 = R_0201: room: HDMI
RN4 = R0402_0OHM: room: WWAN
RN9 RN12 RN14-RN18 RN73 RN96 RR17 RR18 RS3 RS9 = R0201_0OHM: room: WWAN
RN13 RN49-RN54 RS5-RS8 = R_0201: room: WWAN
RN23 = R_0201: room: NGFF SSD
RN31 RN32 RN55 RV42 RV45 RV52 RV53 = R0201_0OHM: room: MCP
RN46 RN47 = R_0201: room: CSI,CNVI
RN67 = R0201_0OHM: room: CAM-PMIC
RN70 = R_0201: room: WLAN
RN72 = R_0201: room: Other
RN83 RN84 = R_0402: room: WWAN
RP12 RP13 RV3 RV16 RV25 = R_0201: room: eDP TS
RR1 = R_0603: room: CAMERA_CR_DC_DC
RR10 = R_0402: room: CARD READER
RT15 RT17 RT42 RT43 RT93 RT94 RT183 RT186-RT188 RT190 = R_0201: room: AR
RT51 RT52 RT58 = R_0402: room: PD_1
RT53 RT54 RT59 RT60 RT105 RT118 RT119 RT122 RT262 RT263 RT265 RT266 RT268 RT269 RT271 RT272 RT274 RT275 = R_0201: room: PD_1
RT55 RT56 RT62 RT103 RT104 RT107 RT109 RT111 RT116 RT117 RT120 RT121 RT124 RT126 RT128 RT141 RT142 RT169-RT172 = R0201_0OHM: room: PD_1
RT57 = R_0402: room: PD_2
RT61 RT143 RT144 RT178-RT180 = R_0201: room: PD_2
RT88 RT145 RT161 RT260 = R_0402: room: AUDIO_CODEC
RT146 RT149 RT261 = R0402_0OHM: room: AUDIO_CODEC
RV15 RV17 RV19-RV21 RV23 RV70 RV71 = R0201_0OHM: room: eDP TS
RV35 = F_T0603FF0500TM: room: PD-1
RV68 RV69 = R_0603: room: PD-1
RV75 = F_T0603FF1000TM
SW2 = SW_SKRBACE010_4P
SW3 = SW_SSAL120100_3P
T1-T7 T11 T16-T21 T24 T26-T30 T50 T51 T134 T135 = TPC12: room: CPU
TC1 TC2 = TPC12: room: PD_1
TC6 TC7 = TPC12: room: PD_2
TV1 TV2 = TPC12: room: CSI,CNVI
U4 U6 U12 = EM5209VF_DFN14_3X2
U5 = TC7SH08FU_SSOP5: room: +1.0V_VCCSTG
U7 = 74AUP1G07GW_TSSOP5
U8 U15 U19 UC17 = AOZ1336DI_DFN8_2X2
U10 U11 UC2 UC10 = TC7SH08FU_SSOP5: room: CPU
U16 = SX9324ICSTRT_WLCSP_8P
U17 = RT9078N-08GJ5_TSOT23-5
U27 = MX25L25645GM2I-10G_SO8
U32 = 74LV1T32GW_SOT353-1-5
U33 UC19 UT14 = TC7SH08FU_SSOP5
UA1 = ALC3254-VA3-CG_MQFN48_6X6
UA7 = AOZ1336DI_DFN8_2X2: room: eDP TS
UA8 = EM5209VF_DFN14_3X2: room: AUDIO
UC9 = 74AUP1G07GW_TSSOP5: room: CPU
UC18 = W25Q256JVEIQ_WSON8_8X6-S
UCPU1 = WHL-U42_BGA_1528P-T
UD1 = H9CCNNN8JTMLAR-NTM_FBGA_178P: room: CHB-Dram1
UD2 = H9CCNNN8JTMLAR-NTM_FBGA_178P: room: CHA-Dram1
UD3 = H9CCNNN8JTMLAR-NTM_FBGA_178P: room: CHB-Dram0
UD4 = H9CCNNN8JTMLAR-NTM_FBGA_178P: room: CHA-DRAM0
UE1 = MEC5105_WFBGA_169P: room: EC
UE4 = 74AUP1G07GW_TSSOP5: room: EC
UI2 = PS8713BTQFN24GTR2_TQFN24_4X4-S
UI4 UI5 = SLGC55544CVTR_TQFN16_3X3
UK1 = ECE1117-Y3-1-TR_SQFN48_7X7
ULID1 = BU52058GWZ-E2_UCSP35L1_4P
UM3 = AP2330W-7_SC59-3: room: HDMI
UN1 = PI3PCIE3212ZBEX_TQFN20_2P5X4P5: room: WWAN
UN3 = BGSA14RN10_TSNP10
UN4 = SN74LVC1G3157DCKR_SC70-6
UN5 = 74AUP1G97GW_SOT363-6
UR1 = RTS5242-GR_QFN32_4X4: room: CARD READER
UR2 UV1 = G517AH1TP1U_TSOT23-6: room: eDP TS
UT1 UT5 = TPS65982DCZQZR_BGA_96P
UT2 = AR-4C_BGA_337P-T
UT3 = W25Q80DVZPIG_WSON8
UT4 = W25Q80DVZPIG_WSON8: room: PD_1
UT15 = TS5A3159ADCKR_SC70-6
UT16 = RT9069-33GB_SOT23-5
UV5 = LNG2DMTR_LGA12_2X2: room: SENSOR
UV6 = TUSB211RWBR_X2QFN12_1P6X1P6
UZ3 = TPS22961DNYR_WSON8: room: +1.0V_VCCST
UZ4 = TPS22961DNYR_WSON8: room: +1.0V_VCCSTG
UZ5 = TPS22961DNYR_WSON8: room: +VCCPLL_OC
UZ6 = ST33HTPH2E32AHB4_VQFN32_5X5
YC1 = Y_X3G024000DC1H_4P: room: CPU
YC2 = Y_9H03280012_2P: room: CPU
YE1 = Y_9H03280012_2P: room: EC
YT1 = Y_7M25000016_4P

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
74AUP1G07GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
74AUP1G97GW_SOT363-6
  rect 0.508x0.508 smd: 1(0,0) 3(1.5,0) 4(1.5,1.8) 6(0,1.8)
  rect 0.406x0.61 smd: 2(0.75,0) 5(0.75,1.8)
74LV1T32GW_SOT353-1-5
  rect 0.508x0.508 smd: 1(0,0) 3(1.5,0) 4(1.5,1.8) 5(0,1.8)
  oval 0.406x0.61 smd: 2(0.75,0)
ACES_50208-00601-P01_6P
  oval 0.508x0.991 smd: 1(0,0) 2(-0.8,0) 3(-1.6,0) 4(-2.4,0) 5(-3.2,0) 6(-4,0)
  rect 1.194x1.702 smd: 7(-5.3,-1.95) 8(1.3,-1.95)
ACES_50224-00401-001_4P
  oval 0.61x1.549 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0)
  rect 1.194x1.803 smd: 5(4.3,-3.875) 6(-1.3,-3.875)
ACES_50278-00201-001_2P
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0)
  rect 1.295x3.353 smd: 3(-2.85,-4.925) 4(4.1,-4.925)
