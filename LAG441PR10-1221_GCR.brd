# Allegro board LAG441PR10-1221_GCR.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3VS_WLAN_R: length 1.7
  TOP w0.102: 253.97,37.1 R33.1 252.98,37.1 v1(252.45,37.64)
+3VS_WWAN_R: length 1
  TOP w0.127: v1(257.58,38.17) 257.47,38.06 256.65,38.06
+3VS_WWAN_RF: length 3.9
  TOP w0.203: UN3.4 197.05,71.97 v2(197.04,71.98)
  IN1 w0.381: v2(197.04,71.98) 196.14,71.98 195.05,70.88 v2(195.05,69.69)
+3VS_WWAN_UN1: length 18.5
  TOP w0.254: RN4.1 CN12.1 250.54,29.53 UN1.10 ; CN13.1 250.4,22.21 250.4,22.79 250.54,22.93 UN1.1 ; UN1.6 253.62,26.05 CN11.1
  TOP w0.381: CN11.1 253.59,25.65 253.41,25.65 253.26,25.49 v6(252.96,25.49)
  TOP w0.508: v6(251.05,28.89) 251.61,29.45 RN4.1 ; v6(251.81,22.8) v1(251.81,22.18) 251.5,21.86 CN13.1
  BOTTOM w0.508: v6(251.81,22.8) 252.44,22.8 253.11,23.48 253.11,25.34 v6(252.96,25.49) 252.96,25.83 251.83,26.95 251.83,28.11 v6(251.05,28.89)
+5V_USB_L:
  vias: v3(20.76,10.05) v5(14.57,13.76) v5(14.57,13.51) v5(14.82,13.76) v5(14.82,13.51) v6(17.37,15.2) v6(17.36,14.61) v6(17.63,15.77) v6(17.92,14.6) v6(17.94,15.2) v6(20.29,10.5) v6(20.42,11.7) v6(20.36,11.07) v6(20.87,10.69) v6(20.93,11.26)
+5V_USB_R: length 5.2
  IN3 w0.508: JUSB1.1 302.65,48.61 299.98,45.93
  vias: v3(290.97,62.91) v4(292.96,47.64) v4(293.47,47.64) v4(293.84,47.11) v4(293.98,47.64) v4(294.49,47.64) v5(292.96,47.26) v5(292.96,47.01) v5(293.22,47.14) v5(293.31,48) v5(293.47,47.26) v5(293.47,47.01) v5(294.23,47.26) v5(294.23,47.01) v5(294.49,47.14) v5(294.74,47.26) v5(294.74,47.01) v6(291.2,61.82) v6(291.65,61.44) v6(292.01,60.98) v6(292.26,61.49) v6(292.44,60.57)
+5VALW: length 287.5
  TOP w0.203: U12.4 v2(123.95,27.82)
  TOP w0.508: CI32.1 19.11,16.21 18.79,16.53 RI64.1 17.93,16.99 16.62,16.99 ; 16.62,16.99 15.59,15.96 15.59,12.72 15.98,12.34 RI144.1 ; 16.62,16.99 16.62,18.63 v3(16.93,18.94) 18.16,20.17 18.16,21.25 19.76,22.86 19.76,25.31 22.87,28.41 22.87,29.38 22.16,30.08 21.5,30.08 v3(20.96,30.63) 20.04,31.54 UM3.1 ; 49.01,71.5 49.09,71.59 49.09,73.41 49.5,73.82 49.5,75.05 49.15,75.4 49.15,77.15 49.17,77.16 ; v2(64.45,74.82) 62.86,73.23 55.71,73.23 52.12,76.81 50.23,76.81 49.88,77.16 49.17,77.16 ; CT199.1 23.04,77.32 v6(22.6,76.89) ; v6(82.09,68.86) 82.09,69.56 83.18,70.65 87.02,70.65 v2(87.59,71.22) ; v2(124.72,27.4) v3(123.23,25.91) 121.92,24.6 121.92,22.24 121.92,22.24 v2(121.92,22.16) 121.92,21.33 119.53,18.95 v2(119.53,17.96) ; v2(42.2,77.92) 47.71,77.92 48.47,77.16 49.17,77.16
  IN1 w0.381: v4(29.76,77.73) 30.35,78.32 41.87,78.32 42.2,78 v2(42.2,77.92)
  IN1 w0.508: v2(87.59,71.22) 87.59,75.27 v4(87.35,75.52) ; v4(56.72,12.27) 57.89,12.27 58.1,12.06 94.14,12.06 95.78,13.69 95.78,14.85 96.63,15.7 96.63,16.25 97.65,17.28 98.18,17.28 98.37,17.47 99.07,17.47 v4(99.59,16.95) 99.64,16.9 104.66,16.9 106.56,14.99 112.04,14.99 115.01,17.96 v2(119.53,17.96) ; v2(124.72,27.4) 124.3,27.82 v2(123.95,27.82) ; v2(64.45,74.82) 64.24,75.04 64.24,75.34 v4(63.99,75.58) ; v6(131.12,16.44) 128.94,18.62 125.46,18.62 v2(121.92,22.16)
  IN2 w0.508: v4(63.99,75.58) 64.96,76.55 76.69,76.55 77.08,76.17 87.07,76.17 87.35,75.89 v4(87.35,75.52)
  IN3 w0.254: v5(23.72,73.43) 23.71,73.43 23.28,73 v4(23.14,73) ; v5(83.09,64.78) 84.14,63.72 v5(84.82,63.72)
  IN3 w0.508: v5(29.17,78.03) 29.45,78.03 v4(29.76,77.73) ; v6(20.7,14.49) 20.7,12.38 23.33,9.75 26.78,9.75 29.41,12.38 36.31,12.38 38.39,10.29 48.7,10.29 50.68,12.27 v4(56.72,12.27) ; v5(99.2,16.06) 99.59,16.45 v4(99.59,16.95) ; v6(82.09,68.86) 81.75,68.52 81.75,67.13 83.03,65.84 83.73,65.84 84.82,64.75 v5(84.82,63.72) ; v5(23.72,66.42) v4(23.28,66.42)
  BOTTOM w0.254: v5(84.82,63.72) 84.82,63.16 85.46,62.52 88.84,62.52 89.05,62.73 97.09,62.73 97.84,63.48 97.84,64.29 98.31,64.76 100.03,64.76 100.31,64.49 UZ3.3
  BOTTOM w0.305: UZ4.3 81.94,63.16 81.48,63.62 81.48,64.52 81.74,64.78 83.08,64.78 v5(83.09,64.78)
  BOTTOM w0.508: v6(131.12,16.44) 132.33,16.44 132.4,16.51 ; v5(29.17,78.03) 28.87,78.33 23.97,78.33 22.7,77.06 22.7,76.99 v6(22.6,76.89)
  vias: v2(20.75,33.52) v2(20.76,33.24) v2(20.75,32.95) v2(20.93,32.57) v2(22.83,70.09) v4(19.29,76.85) v4(19.8,76.66) v4(19.8,76.22) v4(20.24,76.66) v4(20.24,76.22) v4(20.28,68.37) v4(20.36,68.8) v4(20.69,76.66) v4(20.69,76.22) v4(20.7,68.46) v4(20.71,68.04) v4(20.93,68.81) v4(21.11,33.32) v4(21.12,32.87) v4(21.16,68.46) v4(21.17,68.04) v5(18.91,76.5) v5(18.91,76.22) v5(19.16,76.5) v5(19.16,76.22) v5(19.42,76.5) v5(19.42,76.22) v5(20.14,69.58) v5(20.14,69.28) v5(20.42,69.58) v5(20.42,69.28) v5(20.7,69.58) v5(20.7,69.28) v5(21.28,76.54) v5(21.28,76.22) v5(21.57,68.63) v5(21.57,68.24) v6(20.37,15.58) v6(20.38,15) v6(20.95,15.3) v6(21.25,14.74) v6(27.85,41.99) v6(28.09,41.48) v6(28.14,40.93) v6(28.41,43.14) v6(28.39,42.58) v6(28.41,41.99) v6(28.62,41.22) v6(28.9,42.88) v6(28.89,42.31) v6(28.9,41.72)
+5VALWB: length 218.5
  TOP w0.254: U19.4 226.12,51.25 226.49,51.62 v6(226.49,51.76) ; v6(225.77,57.33) 225.53,57.33 225.31,57.54 U8.4
  TOP w0.356: RI53.1 283.48,61.04 v6(283.47,61.05)
  TOP w0.381: RI143.1 v6(291.22,58.94)
  TOP w0.508: 192.44,25.8 191.58,24.94 v6(191.58,21.9)
  IN1 w0.508: v6(284.35,11.97) 283.93,11.55 279.98,11.55 276.74,14.79 272.21,14.79 271.48,15.52 270.76,15.52 270.15,14.92 v2(269.79,14.92) 269.79,16 267.58,18.2 254.58,18.2 v4(254.29,18.5) 252.89,17.1 240.64,17.1 239.56,18.18 223.34,18.18 v6(222.2,19.32) ; v6(225.77,57.33) 225.77,59.51 222.78,62.5 210.34,62.5 207.8,65.04 203.75,65.04 v6(201.41,62.71) ; v4(265.98,41.01) 265.98,41.05 v2(266.19,41.27) ; v2(255.12,41.32) v4(255.54,41.32)
  IN2 w0.508: v6(253.21,31.36) 253.21,26.43 253.8,25.85 253.8,18.99 v4(254.29,18.5)
  IN3 w0.508: v4(255.46,33.75) 253.21,31.5 v6(253.21,31.36) ; v6(222.2,19.32) 215.9,19.32 214.81,18.23 212.02,18.23 208.97,15.17 201.19,15.17 199.94,13.92 184.61,13.92 v5(184.51,14.02)
  BOTTOM w0.305: JPTN1.1 v6(294.36,73.79)
  BOTTOM w0.508: 183.43,14.9 183.43,17.17 188.16,21.9 v6(191.58,21.9) ; R102.1 v6(201.41,62.71) ; v6(225.77,57.33) 225.77,52.48 v6(226.49,51.76) 225.77,51.04 225.77,39.84 227.65,37.97 227.65,24.34 222.63,19.32 v6(222.2,19.32)
  vias: v2(267.25,42.08) v2(267.25,41.67) v2(267.25,41.29) v2(267.56,41.67) v2(267.56,41.29) v2(267.69,42.06) v2(267.88,41.74) v3(193.56,28.56) v4(267.94,41.36) v4(268.07,42.06) v4(268.32,41.67) v4(268.45,41.23) v4(268.58,42.12) v4(268.83,41.67) v6(192.19,27.26) v6(192.44,26.75) v6(192.76,27.26) v6(193.01,26.75) v6(193.33,27.26) v6(193.65,26.75) v6(283.82,64.41) v6(283.82,63.77) v6(283.82,63.2) v6(284.39,64.41) v6(285.03,64.41) v6(291.44,70) v6(291.76,70.49) v6(292.07,70) v6(292.41,70.51) v6(292.71,70) v6(293.08,70.52) v6(293.34,70) v6(293.68,70.53) v6(293.97,70.04)
+5VALWB_USH: length 1.6
  TOP w0.127: v1(270.17,18.58) 269.86,18.26 v6(269.86,18.05)
  TOP w0.508: v6(269.86,18.05) 269.86,17.26 RB37.2
+5VALWBP: length 6.9
  TOP w0.102: v6(292.81,67.04) v1(292.07,67.04)
  BOTTOM w0.254: 294.54,59.45 294.88,59.8 PU401.5
  BOTTOM w0.508: PC419.1 291.98,62.92 293.12,61.78 293.12,59.96 293.62,59.45 294.54,59.45
+5VALWP: length 5.1
  IN3 w0.254: v5(37.93,42.33) 38.08,42.33 41.47,38.94 v5(41.47,38.81)
+5VS: length 149.2
  TOP w0.508: v2(263.4,29.78) 265.89,27.29 265.89,21.91 v3(265.85,21.86) 265.52,21.53 263.84,21.53 263.48,21.17 263.48,20.45 264.45,19.48 v2(264.45,15.74) ; FK1.1 211.26,17.43 211.25,17.43 CK1.1 211.05,15.39 211.58,14.85 v2(212.27,14.85)
  IN1 w0.508: v2(254.45,51.9) v4(256.14,51.9) ; v4(263.93,29.7) 263.85,29.78 v2(263.4,29.78) ; v2(212.27,14.85) 215.82,14.85 217.08,16.11 v6(218.71,16.11) 223.54,16.11 224.32,15.33 224.32,13.91 227.11,11.12 233.83,11.12 234.06,11.35 238.45,11.35 238.69,11.11 249.96,11.11 254.59,15.74 v2(264.45,15.74) 267.69,15.74 v2(268.52,14.92)
  IN2 w0.508: 210.34,31.17 210.51,31.35 215.31,31.35 v6(217.24,33.28)
  IN3 w0.508: v4(263.93,29.7) 263.93,30.4 264.15,30.61 264.5,30.61 266.34,32.45 266.34,35.95 266.98,36.58 266.98,44.28 264.79,46.46 264.79,47.24 263.88,48.15 263.88,49.31 262.98,50.21 260.31,50.21 258.62,51.9 v4(256.14,51.9)
  BOTTOM w0.508: v6(218.71,16.11) 220.79,18.19 220.79,20.31 223.01,22.53 223.01,31.49 220.83,33.67 217.63,33.67 v6(217.24,33.28)
  vias: v6(201.4,31.31) v6(201.95,31.31) v6(202.54,31.32)
+5VS_AUDIO: length 1
  TOP w0.102: 267.11,35.31 v3(267.11,34.3)
  vias: v2(267.14,35.81) v2(267.3,35.55) v2(267.44,35.81) v2(267.6,35.55) v2(267.73,35.81) v2(268.08,35.6) v2(293.38,29.43) v2(293.74,29.43) v4(267.25,35.2) v4(267.75,35.2) v4(268.26,35.2) v4(268.46,35.65) v4(268.71,35.26) v4(268.97,35.68) v4(285.22,32.21) v4(285.53,31.9) v4(285.98,32.09) v4(286.23,33.22) v4(286.36,32.47) v4(286.55,32.9) v4(292.85,29.28) v4(292.85,28.8) v5(285.42,32.95) v5(285.58,32.63) v5(285.8,32.81) v5(285.79,32.44) v5(285.99,32.62) v6(286.3,31.45) v6(286.74,31.9) v6(293.55,28.97)
+5VS_AUDIO_R: length 0.8
  TOP w0.102: 267.78,38.75 v1(268.55,38.75)
+5VS_KBL: length 6.8
  TOP w0.127: v6(214.15,19.2) 214.07,19.2 v3(213.41,19.86)
  TOP w0.508: v6(214.15,19.2) 214.1,19.14 CK3.1 213.63,18.47 213.54,18.38 CK2.1 211.98,18.38 FK1.2
  BOTTOM w0.508: v6(214.15,19.2) 215.34,19.2 215.96,18.58 JBL1.2
+5VS_R: length 1.9
  TOP w0.102: 198.78,30.65 197.6,29.47 v1(197.33,29.47)
+5VS_USH: length 1.5
  TOP w0.127: v6(268.77,17.93) v1(268.77,18.55)
  TOP w0.508: v6(268.77,17.93) 268.52,17.68 RB39.2
+AVDD1: length 7.1
  TOP w0.203: CA14.1 286.9,28.85 285.56,28.85 285.37,28.66 285.13,28.66 284.5,28.03 UA1.40
  TOP w0.381: CA16.1 287.65,29 CA14.1
  TOP w0.508: LA1.1 289.33,28.83 CA5.1 CA16.1
+DVDD: length 192.4
  TOP w0.508: v6(229.21,25.71) 229.21,27.13 228.31,28.03 228.31,31.07 234.92,37.69 v1(234.92,41.64) 234.92,48.41 v2(235.18,48.66)
  IN1 w0.508: v2(235.18,48.66) 225.66,48.66 223.45,46.45 212.99,46.45 212.15,47.29 205.7,47.29 203.69,45.28 203.69,42.41 194.81,33.52 194.3,33.52 193.61,32.84 191.53,32.84 191.01,33.36 v6(191.01,33.89) ; v2(279.02,29.61) 279.02,28.95 v2(278.46,28.39) 278.21,28.14 v2(278.21,26.12) ; v4(276.48,24.13) v2(276.87,24.52)
  IN2 w0.508: v4(276.48,24.13) 275.63,23.27 275.63,20.97 274.23,19.58 267.63,19.58 265.87,17.82 251.28,17.82 249.05,20.06 243.66,20.06 238.01,25.71 v6(229.21,25.71)
  BOTTOM w0.508: RV35.1 146.86,24.34 147.3,24.06 150.83,22.42 150.85,22.41 153.83,21.43 156.35,20.86 159.04,20.45 159.18,20.4 162.29,19.96 164.73,19.77 174.1,19.77 185.29,30.96 187.95,30.96 190.4,33.42 190.64,33.42 191.01,33.79 v6(191.01,33.89)
+DVDDIO: length 5.1
  TOP w0.203: RA15.2 RA14.2 280.86,18.45 CA26.1 281.81,18.6 CA27.1 282.42,19.26 283.3,20.14 UA1.18
+PVDD: length 0.9
  TOP w0.102: v3(283.18,30.49) 283.6,30.07 v6(283.96,30.07)
  vias: v2(280.25,29.2) v2(280.55,28.97) v2(281.15,29) v6(284.22,28.72) v6(284.47,30.42) v6(284.49,29.81) v6(284.59,29.22) v6(285.03,29.61)
+VBATT: length 14.9
  TOP w0.508: PR236.2 33.88,13.69 PC234.1 33.93,13.7 33.93,13.24 34.18,12.99 v1(36.89,12.99) 37.55,12.99 37.86,13.3 37.86,15.13 v2(37.45,15.54)
  IN1 w0.508: v4(43.43,16.13) 43.15,16.42 40.35,16.42 40.23,16.3 38.21,16.3 v2(37.45,15.54)
  IN3 w0.508: v5(43.93,16.26) 43.56,16.26 v4(43.43,16.13)
+VBUS1_20V: length 1
  BOTTOM w0.508: DT47.2 18.14,64.95
  vias: v1(15.63,52.81) v2(9.09,50.04) v2(9.09,49.3) v2(9.35,50.04) v2(9.35,49.3) v2(19.2,67.31) v2(19.23,67.57) v2(19.5,67.59) v2(19.5,67.33) v4(9,49.71) v4(8.99,48.96) v4(9.94,49.04) v4(10.29,49.35) v4(10.75,49.5) v4(10.8,48.82) v4(11.18,49.63) v4(18.24,66.18) v4(18.24,65.39) v4(18.24,64.41) v4(18.39,67.11) v4(18.89,67.11) v4(19.03,66.18) v4(19.03,65.39) v4(19.03,64.41) v4(19.82,66.18) v4(19.82,65.39) v4(19.81,64.41) v4(19.88,67.15) v5(9.09,50.04) v5(9.09,49.3) v5(9.35,50.04) v5(9.35,49.3) v5(10.84,49.16) v5(10.83,48.49) v5(10.84,48.23) v5(11.04,49.32) v5(11.48,49.77) v5(11.5,49.52) v5(18.17,64.93) v5(18.24,66.51) v5(18.24,65.78) v5(18.75,66.01) v5(18.75,65.22) v5(19.28,65.93) v5(19.31,65.56) v5(19.4,67.04) v5(19.42,64.63) v5(19.95,66.48) v5(19.95,65.71) v5(19.95,65.08) v5(20.31,67.25)
+VBUS2_20V: length 12.3
  TOP w0.254: PQ102.3 14.77,66 15.2,66.43 PR100.1
  TOP w0.508: 10.67,65.74 10.67,64.98 11.06,64.58 13.05,64.58 13.5,65.03 13.5,65.04 14.29,65.82 PQ102.3 14.29,67.08 PR104.1 14.27,67.88 PC110.1
  BOTTOM w0.102: 18.67,73.87 18.67,74.06 18.31,74.42 18.31,75.19 v1(17.79,75.71)
  BOTTOM w0.508: PC107.1 13.77,64.2 DT48.2
  vias: v2(10.54,66.17) v2(10.81,66.17) v2(18.62,74.03) v2(18.62,73.41) v2(18.66,72.56) v2(19.01,72.72) v4(8.67,64.31) v4(8.7,63.8) v4(8.74,64.92) v4(9.05,65.23) v4(9.05,64.66) v4(9.44,64.98) v4(9.59,61.92) v4(9.59,61.38) v4(9.74,60.72) v4(9.74,60.09) v4(9.77,59.53) v4(10.33,74.54) v4(10.76,74.62) v4(10.84,66.5) v4(11.17,74.41) v4(17.45,73.11) v4(17.45,72.32) v4(18.24,73.9) v4(18.24,73.11) v4(18.24,72.32) v4(18.24,71.54) v4(19.07,73.59) v4(19.03,73.11) v4(19.03,72.32) v4(19.82,73.9) v4(19.82,73.11) v4(19.82,72.32) v4(19.82,71.54) v5(9.13,64.26) v5(9.13,63.85) v5(9.38,60.34) v5(9.38,59.45) v5(9.56,64.26) v5(9.56,63.87) v5(10.02,62.99) v5(10.02,62.48) v5(9.99,61.74) v5(10.02,61.23) v5(10.24,74.14) v5(10.5,74.14) v5(10.77,74.14) v5(11.17,74.07) v5(18.24,73.44) v5(18.24,72.72) v5(18.24,71.94) v5(18.75,72.94) v5(18.75,72.15) v5(19.07,73.97) v5(19.19,72.7) v5(19.42,71.54) v5(19.52,73.45) v5(19.81,72.71) v5(19.95,73.42) v5(19.95,72.01) v5(20.18,74.12) v5(20.21,71.54)
+VCC0V9_CIO: length 2.6
  IN1 w0.229: v4(24.65,52.69) v5(24.88,52.92) ; v4(24.65,52.04) v5(24.88,52.27) ; v4(24.65,53.81) v5(24.88,53.57) ; v4(24.65,54.46) v5(24.88,54.22)
  IN3 w0.229: v5(24.88,52.92) v4(24.65,52.69) ; v5(24.88,52.27) v4(24.65,52.04) ; v5(24.88,53.57) v4(24.65,53.81) ; v5(24.88,54.22) v4(24.65,54.46)
+VCC0V9_DP: length 6.1
  TOP w0.127: 26.18,52.93 v5(26.18,52.92) 26.16,52.92 ; v5(26.18,52.27) 26.16,52.27 ; CT54.1 26.76,51.7 v3(27.29,51.17)
  IN1 w0.229: v4(22.7,52.04) v5(22.93,52.27) ; v4(23.35,55.11) v5(23.58,54.87) ; v4(23.35,54.46) v5(23.58,54.22) ; v4(22.7,55.11) v5(22.93,54.87) ; v4(22.7,52.69) v5(22.93,52.92)
  IN1 w0.254: v4(25.3,52.69) v5(25.53,52.92)
  IN3 w0.229: v5(22.93,52.92) v4(22.7,52.69)
  IN3 w0.254: v5(25.53,52.92) v4(25.3,52.69) ; v5(23.58,54.22) v4(23.35,54.46) ; v5(22.93,52.27) v4(22.7,52.04) ; v5(23.58,54.87) v4(23.35,55.11) ; v5(26.18,52.92) 25.95,52.69 v4(25.92,52.69) ; v5(22.93,54.87) v4(22.7,55.11) ; v5(22.93,54.22) v4(22.7,54.46)
  vias: v2(26.1,52.98) v2(26.13,52.32) v2(26.14,51.77) v4(25.3,52.04) v4(25.79,52.04) v5(25.53,52.27) v5(26.18,51.62)
+VCC0V9_PCIE: length 4.7
  IN1 w0.203: v4(24,48.79) v2(24.23,48.53) ; v4(24,49.44) v2(24.23,49.15) ; v4(22.7,48.79) v2(22.93,48.5)
  IN1 w0.229: v4(23.35,50.09) v5(23.58,50.32) ; v4(23.35,50.74) v5(23.58,50.97) ; v4(23.35,51.39) v5(23.58,51.62)
  IN3 w0.229: v5(23.58,49.67) v4(23.35,49.44) ; v5(23.58,51.62) v4(23.35,51.39) ; v5(22.93,49.67) v4(22.7,49.44) ; v5(24.23,49.67) v4(24,49.44) ; v5(23.58,50.97) v4(23.35,50.74) ; v5(23.58,50.32) v4(23.35,50.09) ; v5(24.23,49.02) v4(24,48.79) ; v5(22.93,49.02) v4(22.7,48.79)
+VCC0V9_USB: length 1.3
  IN1 w0.254: v4(24.65,50.74) v2(24.88,50.5) ; 24.65,50.09 v2(24.88,49.85)
  IN3 w0.203: v5(24.88,50.32) 24.65,50.09 ; v5(24.88,50.97) v4(24.65,50.74)
+VCC_CORE: length 109.6
  TOP w0.127: PC1293.1 85.2,53.28 ; PC1298.1 85.48,40.39 ; PC1288.1 87.4,52.66 ; PC1299.1 87.95,40.39
  IN1 w0.203: v2(86.52,50.57) 86.32,50.57 v4(86.15,50.4) ; v4(75.39,54.79) 75.47,54.7 v2(75.73,54.7)
  IN1 w0.254: v2(91.3,42.06) v4(90.97,42.06) ; v2(91.3,47.12) v4(90.97,47.12) ; v2(91.3,44.32) v4(90.97,44.32) ; v2(78.29,54.04) v4(78.12,54.34) ; v2(91.3,42.63) v4(90.97,42.63) ; v2(91.3,46) v4(90.97,46) ; v2(91.87,54.55) v4(92.18,54.7) ; v2(85.81,46.54) v4(85.48,46.54) ; v2(91.3,47.68) v4(90.97,47.68) ; v2(91.3,43.76) v4(90.97,43.76) ; v2(81.81,50.3) v4(82.14,50.3) ; v2(91.3,45.44) v4(90.97,45.44) ; v2(91.3,44.88) v4(90.97,44.88) ; v2(85.52,50.5) v4(85.52,50.17) ; v2(90.05,44.66) v4(90.38,44.66) ; v2(91.3,48.24) v4(90.97,48.24) ; v2(90.03,46.51) v4(90.36,46.51) ; v2(91.3,46.56) v4(90.97,46.56) ; v2(91.3,48.8) v4(90.97,48.8) ; v2(82.75,50.3) v4(82.75,49.97) ; v2(91.3,43.21) v4(90.97,43.21)
  IN3 w0.061: v5(84.14,50.29) v4(84.48,50.32)
  IN3 w0.203: v5(75.17,55.05) 75.38,54.79 v4(75.39,54.79)
  IN3 w0.254: v5(87.37,52.68) v4(87.61,52.91) ; v4(89.46,50.96) v5(89.22,50.73) ; v5(91.48,39.46) v4(91.48,39.13) ; v5(85.53,52.68) v4(85.76,52.91) ; v4(76.63,49.63) 76.45,49.81 v5(76.29,49.81) ; v4(92.17,39.23) v5(91.93,38.99) ; v4(80.22,55.38) 80.22,55.22 v5(80.05,55.05) ; v4(76.62,50.91) 76.44,50.73 v5(76.29,50.73) ; v5(84.6,49.81) v4(84.84,50.05) ; v5(91.48,40.38) v4(91.71,40.62) ; v5(90.15,52.68) v4(90.38,52.91) ; v4(86.68,50.96) 86.68,50.95 86.46,50.73 v5(86.45,50.73) ; v5(87.83,39.46) v4(88.06,39.22) ; v4(88.53,50.96) v5(88.3,50.73) ; v5(91.07,52.68) 90.85,52.9 v4(90.81,52.9) ; v5(79.06,50.73) 78.86,50.53 v4(78.79,50.53) ; v5(88.3,51.38) v4(88.53,51.61) ; v5(83.68,50.73) 83.92,50.97 v4(84.04,50.97) ; v5(85.53,51.38) v4(85.76,51.61) ; v5(89.2,39.92) v4(89.11,39.58) ; v5(77.61,55.05) 78.12,54.55 v4(78.12,54.34) ; v5(90.15,52.03) v4(90.38,52.26) ; v5(85.53,52.03) v4(85.76,52.26) ; v5(88.74,40.38) v4(88.98,40.62) ; v5(89.2,38.99) v4(89.43,39.23) ; v5(91.53,50.27) v4(91.15,50.26) ; v5(90.15,49.81) v4(90.15,49.48) ; v5(79.98,50.73) v4(80.22,50.5) ; v5(90.15,51.38) v4(90.38,51.61) ; v5(92.39,40.38) v4(92.58,40.65) ; v5(90.56,39.46) v4(90.9,39.46) ; v5(86.01,39.46) v4(86.24,39.69) ; v5(85.1,39.46) v4(85.33,39.69) ; v5(84.18,40.38) v4(84.44,40.64) ; v5(79.06,49.81) v4(79.29,49.58) ; v5(83.22,50.27) v4(83.22,49.94) ; v5(87.83,40.38) v4(88.06,40.66) ; v4(85.76,50.96) v5(85.53,50.73) ; v4(92.52,38.86) v5(92.84,38.99) ; v5(79.52,50.27) v4(79.76,50.04) ; v5(85.1,40.38) v4(85.33,40.62) ; v5(88.3,49.81) 88.3,49.57 v4(88.18,49.46) ; v5(86.45,52.68) v4(86.68,52.91) ; v5(86.01,40.38) v4(86.24,40.62) ; v4(82.07,50.96) v5(81.83,50.73) ; v5(81.83,49.81) v4(82.07,49.58) ; v5(89.22,52.68) v4(89.46,52.91) ; v5(88.3,52.68) v4(88.53,52.91) ; v5(87.84,50.27) v4(87.84,49.94) ; v5(86.45,52.03) v4(86.68,52.26) ; v4(78.37,50.96) v5(78.14,50.73) ; v4(81.14,50.5) v5(80.91,50.73) ; v4(77.45,50.96) v5(77.21,50.73) ; v5(86.46,38.99) v4(86.7,38.76) ; v5(87.37,51.38) v4(87.61,51.61) ; v5(89.22,51.38) v4(89.46,51.61) ; v5(86.45,51.38) v4(86.68,51.61) ; v5(88.3,52.03) v4(88.53,52.26) ; v5(86.92,40.38) v4(87.1,40.67) ; v5(90.11,38.99) v4(90.44,38.99) ; v5(87.37,49.81) v4(87.37,49.48) ; v5(88.29,39.92) v4(88.52,39.69) ; v4(91.3,50.96) v5(91.07,50.73) ; v5(92.46,50.27) v4(92.69,50.04)
  BOTTOM w0.102: v5(83.22,50.27) 83.21,50.27 82.76,49.82 UCPU1.AL10 ; v5(83.22,50.27) 83.43,50.48 83.43,50.48 v5(83.68,50.73) ; v5(83.22,50.27) 83.42,50.07 ; v5(83.22,50.27) 82.76,50.73 UCPU1.AL8 ; UCPU1.AF10 79.79,49.62 ; UCPU1.AF10 79.76,50.04 79.53,50.27 v5(79.52,50.27) ; UCPU1.AF10 80.16,49.99 80.26,50.08 UCPU1.AG9 ; UCPU1.AF10 80.21,49.59 ; v5(88.3,50.73) 88.5,50.93 ; v5(88.3,50.73) 88.29,50.73 87.84,50.28 v5(87.84,50.27) ; v5(88.3,50.73) 88.51,50.52 ; v5(88.3,50.73) 88.06,50.97 ; UCPU1.AK9 82.49,50.07 82.57,50 UCPU1.AL10 ; UCPU1.AK9 81.84,49.81 v5(81.83,49.81) ; UCPU1.AK9 82.11,50.45 82.03,50.53 v5(81.83,50.73) ; UCPU1.AK9 82.48,50.46 82.56,50.54 UCPU1.AL8 ; v5(90.15,49.81) 90.36,49.6 ; v5(90.15,49.81) 89.89,49.56 ; v5(90.15,49.81) 90.15,49.82 90.6,50.27 UCPU1.BC9 ; v5(90.15,49.81) 89.94,50.02 ; v5(81.83,49.81) 81.62,49.6 ; v5(81.83,49.81) 81.37,50.27 UCPU1.AH9 ; v5(81.83,49.81) 82.07,49.58 ; v5(79.98,50.73) 79.77,50.94 ; v5(79.98,50.73) 79.97,50.73 79.52,50.28 v5(79.52,50.27) ; v5(79.98,50.73) 80.18,50.92 ; v5(79.98,50.73) 79.99,50.73 UCPU1.AG9 ; UCPU1.AG9 80.65,50.07 ; UCPU1.AG9 80.45,50.27 80.91,50.73 v5(80.91,50.73) ; 84.33,50.46 UCPU1.AN9 ; UCPU1.AN9 83.96,50.1 ; UCPU1.AN9 84.15,50.27 v5(84.6,49.81) ; UCPU1.AN9 84.14,50.27 v5(83.68,50.73) ; v5(85.1,39.46) 85.1,39.46 85.55,39.92 ; v5(85.1,39.46) 85.3,39.25 ; v5(85.1,39.46) 84.91,39.64 ; v5(85.1,39.46) 84.9,39.26 ; UCPU1.AP9 85.06,50.27 84.61,49.81 v5(84.6,49.81) ; UCPU1.AP9 85.07,50.27 85.52,50.73 v5(85.53,50.73) ; UCPU1.AP9 84.86,50.48 ; UCPU1.AP9 85.26,50.08 ; v5(83.68,50.73) 83.89,50.94 ; v5(83.68,50.73) 83.48,50.93 ; v5(81.83,50.73) 81.63,50.53 81.54,50.45 UCPU1.AH9 ; v5(81.83,50.73) 81.63,50.94 ; v5(81.83,50.73) 82.05,50.94 ; UCPU1.AR25 85.37,40.1 85.28,40.2 v5(85.1,40.38) ; UCPU1.AR25 85.55,39.92 ; UCPU1.AR25 85.73,40.1 85.81,40.19 v5(86.01,40.38) ; UCPU1.AB9 77.22,50.73 v5(77.21,50.73) ; UCPU1.AB9 77.87,50.46 77.96,50.56 v5(78.14,50.73) ; UCPU1.AB9 77.49,50.08 77.4,50 UCPU1.AB10 ; UCPU1.AB9 77.87,50.07 ; UCPU1.AY26 88.56,39.27 ; UCPU1.AY26 88.74,39.47 88.29,39.92 v5(88.29,39.92) ; UCPU1.AY26 88.75,39.46 89.2,39.9 v5(89.2,39.92) ; UCPU1.AY26 88.94,39.26 ; UCPU1.AU26 86.72,39.26 ; UCPU1.AU26 86.73,39.64 86.65,39.73 UCPU1.AU25 ; UCPU1.AU26 87.13,39.24 ; UCPU1.AU26 87.11,39.65 ; UCPU1.AL10 82.99,49.58 ; UCPU1.AL10 82.55,49.61 ; 88.11,50 v5(88.3,49.81) ; v5(88.3,49.81) 88.5,50.01 ; v5(88.3,49.81) 88.51,49.6 ; v5(88.3,49.81) 88.08,49.59 ; v5(89.22,50.73) 89.43,50.52 ; v5(89.22,50.73) 89.02,50.53 ; v5(89.22,50.73) 89.42,50.93 ; v5(89.22,50.73) 89.01,50.94 ; UCPU1.AH9 80.91,50.73 v5(80.91,50.73) ; UCPU1.AH9 81.15,50.05 ; UCPU1.AR10 85.71,50 85.8,50.08 UCPU1.AT9 ; UCPU1.AR10 85.74,49.6 ; UCPU1.AR10 85.33,49.62 ; UCPU1.AR10 85.34,50 ; 85.75,50.51 85.53,50.73 v5(85.53,50.73) ; v5(87.83,40.38) 87.61,40.61 ; v5(87.83,40.38) 87.83,40.36 88.27,39.92 v5(88.29,39.92) ; v5(87.83,40.38) 88.05,40.6 ; v5(87.83,40.38) 87.62,40.18 ; UCPU1.AA9 76.93,50.09 ; UCPU1.AA9 76.58,50.1 76.5,50.03 v5(76.29,49.81) 76.45,49.81 76.51,49.75 76.51,49.59 ; UCPU1.AA9 76.75,50.27 76.29,50.73 v5(76.29,50.73) 76.52,50.96 ; UCPU1.AA9 76.75,50.28 77.2,50.73 v5(77.21,50.73) ; v5(88.29,39.92) 88.29,39.92 87.83,39.46 v5(87.83,39.46) ; v5(88.29,39.92) 88.29,39.93 88.74,40.38 v5(88.74,40.38) ; 92.24,50.06 v5(92.46,50.27) 92.24,50.49 ; v5(78.14,50.73) 78.32,50.55 78.4,50.47 UCPU1.AD9 ; v5(78.14,50.73) 78.35,50.94 ; v5(78.14,50.73) 77.94,50.92 ; v5(79.06,50.73) 79.27,50.94 ; v5(79.06,50.73) 79.07,50.73 v5(79.52,50.27) ; v5(79.06,50.73) 79.06,50.73 UCPU1.AD9 ; v5(79.06,50.73) 78.87,50.92 ; UCPU1.AL8 82.94,50.91 ; UCPU1.AL8 82.57,50.92 ; v5(85.53,50.73) 85.33,50.93 ; v5(85.53,50.73) 85.72,50.92 ; v5(91.53,50.27) 91.3,50.5 91.3,50.5 v5(91.07,50.73) ; v5(91.53,50.27) 91.74,50.48 ; v5(91.53,50.27) 91.53,50.27 UCPU1.BD10 ; v5(91.53,50.27) 91.74,50.07 ; v5(91.48,40.38) 91.65,40.2 91.75,40.1 UCPU1.BE25 ; v5(91.48,40.38) 91.71,40.61 ; v5(91.48,40.38) 91.25,40.61 ; v5(91.48,40.38) 91.3,40.21 91.22,40.12 UCPU1.BD25 ; UCPU1.BD25 90.56,39.46 v5(90.56,39.46) ; UCPU1.BD25 91.02,39.91 91.47,39.46 v5(91.48,39.46) ; UCPU1.BD25 90.82,40.13 ; v5(87.84,50.27) 88.01,50.1 ; v5(87.84,50.27) 87.83,50.27 87.37,49.82 v5(87.37,49.81) ; v5(87.84,50.27) 87.64,50.47 ; UCPU1.BF26 92.21,39.63 92.11,39.74 UCPU1.BE25 ; UCPU1.BF26 92.57,39.64 ; UCPU1.BF26 92.61,39.24 ; UCPU1.BF26 92.19,39.26 ; v5(86.91,50.27) 87.11,50.47 ; v5(86.91,50.27) 86.91,50.28 86.46,50.73 v5(86.45,50.73) ; v5(86.91,50.27) 87.14,50.04 87.15,50.04 v5(87.37,49.81) ; v5(86.91,50.27) 86.7,50.06 ; v5(80.91,50.73) 81.1,50.93 ; v5(80.91,50.73) 80.68,50.96 ; v5(77.21,50.73) 77.43,50.95 ; v5(77.21,50.73) 76.99,50.95 ; UCPU1.AB10 77.01,50.02 ; UCPU1.AB10 77.42,49.6 ; UCPU1.AB10 77.01,49.61 ; UCPU1.BD10 90.88,50.01 90.8,50.08 UCPU1.BC9 ; UCPU1.BD10 90.88,49.62 ; UCPU1.BD10 91.29,49.59 ; UCPU1.AD9 78.41,50.08 ; UCPU1.AD9 78.6,50.27 v5(79.06,49.81) ; v5(89.2,39.92) 89.47,39.65 89.47,39.64 UCPU1.BB26 ; v5(89.2,39.92) 89.19,39.92 88.74,40.37 v5(88.74,40.38) ; v5(79.52,50.27) 79.51,50.27 79.06,49.82 v5(79.06,49.81) ; UCPU1.BE25 91.93,39.91 91.48,39.46 v5(91.48,39.46) ; UCPU1.BE25 92.11,40.1 92.21,40.21 v5(92.39,40.38) ; 84.43,40.63 v5(84.18,40.38) 84.39,40.18 ; 85.79,50.48 85.99,50.27 UCPU1.AT9 ; v5(91.07,50.73) 90.86,50.94 ; v5(91.07,50.73) 91.06,50.73 90.61,50.28 UCPU1.BC9 ; v5(91.07,50.73) 91.27,50.93 ; v5(87.37,49.81) 87.59,49.6 ; v5(87.37,49.81) 87.18,49.62 ; v5(90.56,39.46) 90.77,39.26 ; v5(90.56,39.46) 90.34,39.24 ; v5(90.56,39.46) 90.38,39.64 ; 89.87,39.24 UCPU1.BB26 ; UCPU1.BB26 89.43,39.24 ; UCPU1.BB26 89.85,39.65 ; v5(88.74,40.38) 88.52,40.61 ; v5(88.74,40.38) 88.96,40.6 ; v5(86.45,50.73) 86.65,50.93 ; v5(86.45,50.73) 86.25,50.93 ; v5(86.45,50.73) 86.45,50.73 85.99,50.27 UCPU1.AT9 ; v5(87.83,39.46) 88.05,39.24 ; v5(87.83,39.46) 87.64,39.65 ; v5(87.83,39.46) 87.64,39.27 ; v5(91.48,39.46) 91.68,39.25 ; v5(91.48,39.46) 91.28,39.26 ; v5(92.39,40.38) 92.61,40.61 ; v5(92.39,40.38) 92.16,40.61 ; v5(92.39,40.38) 92.6,40.18 ; UCPU1.AU25 86.22,39.68 86.22,39.67 v5(86.01,39.46) ; UCPU1.AU25 86.64,40.1 86.73,40.19 v5(86.92,40.38) ; UCPU1.AU25 86.28,40.1 86.22,40.18 v5(86.01,40.38) ; UCPU1.AT9 86.18,50.08 ; v5(86.01,40.38) 86.26,40.63 ; v5(86.01,40.38) 85.76,40.63 ; 84.42,39.23 UCPU1.AN26 84.42,39.69 ; v5(84.6,49.81) 84.81,49.61 ; v5(84.6,49.81) 84.4,49.61 ; v5(79.06,49.81) 79.29,49.58 ; v5(79.06,49.81) 78.85,49.6 ; v5(85.1,40.38) 84.9,40.19 ; v5(85.1,40.38) 84.85,40.63 ; v5(85.1,40.38) 85.35,40.63 ; UCPU1.BC9 90.41,50.47 ; 85.55,39.92 86.01,39.46 v5(86.01,39.46) ; v5(86.92,40.38) 86.68,40.63 ; v5(86.92,40.38) 87.11,40.19 ; v5(86.92,40.38) 87.16,40.62 ; v5(86.01,39.46) 85.79,39.24 ; v5(86.01,39.46) 86.22,39.25
  BOTTOM w0.254: v5(84.18,40.38) 84.21,40.38
  vias: v2(76.4,50.64) v2(76.99,50.67) v2(77.56,47.96) v2(77.56,46.76) v2(77.56,45.55) v2(77.56,44.33) v2(77.81,47.96) v2(77.81,46.77) v2(77.81,45.55) v2(77.81,44.33) v2(79.04,50.3) v2(80.29,49.97) v2(81.04,48.01) v2(81.04,46.81) v2(81.03,45.57) v2(81.06,44.32) v2(81.29,48.01) v2(81.29,46.81) v2(81.29,45.57) v2(81.31,44.32) v2(83.76,50.3) v2(84.42,48.47) v2(84.42,47.26) v2(84.42,46.05) v2(84.42,44.85) v2(84.42,43.64) v2(84.42,42.43) v2(84.64,51.47) v2(84.67,48.47) v2(84.67,47.26) v2(84.67,46.06) v2(84.67,44.85) v2(84.67,43.64) v2(84.67,42.44) v2(84.81,70.05) v2(84.82,68.92) v2(84.93,68.29) v2(85.13,69.5) v2(85.16,53.31) v2(85.26,67.53) v2(85.27,52.61) v2(85.45,70.05) v2(85.45,68.95) v2(85.52,68.3) v2(85.45,67.93) v2(85.51,67.29) v2(85.58,67.64) v2(85.53,40.34) v2(85.81,44.68) v2(85.86,45.41) v2(85.86,40.19) v2(85.98,48.5) v2(86.02,42.28) v2(86.12,45.41) v2(86.16,70.05) v2(86.16,68.95) v2(86.16,68.3) v2(86.16,67.66) v2(86.16,66.56) v2(86.18,40.19) v2(86.23,48.51) v2(86.27,42.28) v2(86.48,69.5) v2(86.48,67.11) v2(86.79,70.05) v2(86.79,68.95) v2(86.79,68.3) v2(86.79,67.66) v2(86.79,66.56) v2(87.2,48.5) v2(87.21,42.31) v2(87.3,70.05) v2(87.4,53.31) v2(87.39,52.65) v2(87.5,68.95) v2(87.43,68.3) v2(87.43,67.66) v2(87.43,66.56) v2(87.45,48.51) v2(87.46,42.31) v2(87.82,69.5) v2(87.75,67.11) v2(87.9,40.34) v2(87.95,70.07) v2(87.98,51.35) v2(87.98,39.82) v2(88.07,68.3) v2(88.07,67.66) v2(88.07,66.56) v2(88.14,68.95) v2(88.16,50.96) v2(88.4,42.32) v2(88.45,48.5) v2(88.7,68.3) v2(88.7,67.66) v2(88.7,66.56) v2(88.71,48.51) v2(88.66,42.33) v2(88.83,40.32) v2(88.85,39.82) v2(89.02,67.11) v2(89.11,50.86) v2(89.15,51.43) v2(89.34,68.3) v2(89.34,67.66) v2(89.34,66.56) v2(89.58,53.23) v2(89.62,52.59) v2(89.6,48.52) v2(89.67,42.32) v2(89.75,45.38) v2(89.85,48.52) v2(89.98,68.3) v2(89.98,67.66) v2(89.98,66.56) v2(90,45.38) v2(89.93,42.33) v2(90.29,67.11) v2(90.61,68.3) v2(90.61,67.66) v2(90.61,66.56) v2(90.63,39.82) v2(90.75,51.73) v2(91.22,40.37) v2(91.25,68.3) v2(91.25,67.66) v2(91.25,66.56) v2(91.31,49.93) v2(91.24,39.82) v2(91.7,67.15) v2(91.89,68.3) v2(91.88,67.66) v2(91.88,66.56) v2(92.52,68.3) v2(92.52,67.66) v2(92.52,66.56) v2(92.84,67.11) v2(93.16,68.3) v2(93.16,67.66) v2(93.16,66.56) v2(93.79,68.3) v2(93.79,67.66) v2(93.79,66.56) v2(94.11,67.11) v2(94.43,68.3) v2(94.48,67.66) v2(94.45,66.55) v2(95.07,68.3) v2(95.07,67.66) v2(95.07,66.56) v2(95.38,67.11) v2(95.7,68.3) v2(95.7,67.66) v2(95.7,66.56) v2(96.34,68.3) v2(96.34,67.66) v2(96.34,66.56) v2(96.66,67.11) v2(96.98,68.3) v2(96.97,67.66) v2(96.97,66.56) v2(97.61,68.3) v2(97.66,67.68) v2(97.67,66.58) v2(97.93,67.11) v2(98.23,70.05) v2(98.23,68.95) v2(98.25,68.3) v2(98.24,67.66) v2(98.24,66.56) v2(98.54,69.5) v2(98.86,70.05) v2(98.86,68.95) v2(98.88,68.3) v2(98.88,67.66) v2(98.84,67.1) v2(99.2,67.11) v2(99.5,70.05) v2(99.5,68.95) v2(99.52,68.3) v2(99.51,67.66) v2(99.82,69.5) v2(100.04,67.68) v2(100.13,70.05) v2(100.13,68.95) v2(100.15,68.3) v2(100.19,67.13) v2(100.47,67.13) v2(100.72,67.68) v2(100.72,67.38) v2(100.72,67.1) v3(91.08,63.56) v4(77.68,48.27) v4(77.68,47.07) v4(77.68,45.85) v4(77.68,44.63) v4(81.16,48.32) v4(81.16,47.11) v4(81.16,45.87) v4(81.18,44.63) v4(82.89,50.97) v4(84.54,48.77) v4(84.54,47.57) v4(84.54,46.36) v4(84.54,45.15) v4(84.54,43.95) v4(84.54,42.74) v4(85.04,67.85) v4(85.13,69.96) v4(85.13,69.04) v4(85.48,44.68) v4(85.84,69.5) v4(85.84,68.21) v4(85.84,67.11) v4(85.99,45.71) v4(86.1,48.81) v4(86.14,42.59) v4(86.48,69.96) v4(86.48,69.04) v4(86.48,67.57) v4(86.48,66.65) v4(87.11,68.21) v4(87.11,67.11) v4(87.19,69.5) v4(87.32,48.81) v4(87.34,42.61) v4(87.62,69.96) v4(87.82,69.04) v4(87.75,67.57) v4(87.75,66.65) v4(88.38,68.21) v4(88.38,67.11) v4(88.58,48.81) v4(88.53,42.63) v4(89.02,67.57) v4(89.02,66.65) v4(89.66,68.21) v4(89.66,67.11) v4(89.72,48.83) v4(89.8,42.63) v4(89.88,45.69) v4(90.29,67.57) v4(90.29,66.65) v4(90.93,68.21) v4(90.93,67.11) v4(91.57,67.57) v4(91.57,66.65) v4(92.2,68.21) v4(92.2,67.11) v4(92.84,67.57) v4(92.84,66.65) v4(93.48,68.21) v4(93.48,67.11) v4(94.11,67.57) v4(94.11,66.65) v4(94.75,68.21) v4(94.75,67.11) v4(95.38,67.57) v4(95.38,66.65) v4(96.02,68.21) v4(96.02,67.11) v4(96.66,67.57) v4(96.66,66.65) v4(97.29,68.21) v4(97.29,67.11) v4(97.91,69.5) v4(97.9,68.01) v4(97.93,67.46) v4(98.36,67.18) v4(98.54,69.96) v4(98.54,69.04) v4(98.56,68.21) v4(99.18,69.5) v4(99.2,68.01) v4(99.2,67.57) v4(99.82,69.96) v4(99.82,69.04) v4(99.83,68.21) v4(99.83,67.11) v4(100.39,67.68) v4(100.45,69.5) v4(100.49,68.22) v5(84.81,70.05) v5(84.82,68.92) v5(84.93,68.29) v5(85.13,69.5) v5(85.23,68.3) v5(85.26,67.53) v5(85.45,70.05) v5(85.45,68.95) v5(85.51,68.5) v5(85.44,68.06) v5(85.47,67.73) v5(85.51,67.29) v5(86.11,69.16) v5(86.16,70.05) v5(86.16,68.3) v5(86.16,67.66) v5(86.16,66.56) v5(86.48,69.5) v5(86.48,67.11) v5(86.79,70.05) v5(86.79,68.3) v5(86.79,67.66) v5(86.79,66.56) v5(86.83,69.12) v5(87.3,70.05) v5(87.5,68.95) v5(87.43,68.3) v5(87.43,67.66) v5(87.43,66.56) v5(87.82,69.5) v5(87.75,67.11) v5(87.95,70.07) v5(88.07,68.3) v5(88.07,67.66) v5(88.07,66.56) v5(88.14,68.95) v5(88.7,68.3) v5(88.7,67.66) v5(88.7,66.56) v5(89.02,67.11) v5(89.34,68.3) v5(89.34,67.66) v5(89.34,66.56) v5(89.98,68.3) v5(89.98,67.66) v5(89.98,66.56) v5(90.29,67.11) v5(90.61,68.3) v5(90.61,67.66) v5(90.61,66.56) v5(91.25,68.3) v5(91.25,67.66) v5(91.25,66.57) v5(91.7,67.15) v5(91.89,68.3) v5(91.88,67.66) v5(91.88,66.56) v5(92.52,68.3) v5(92.52,67.66) v5(92.52,66.56) v5(92.84,67.11) v5(93.16,68.3) v5(93.16,67.66) v5(93.16,66.56) v5(93.79,68.3) v5(93.79,67.66) v5(93.79,66.56) v5(94.11,67.11) v5(94.43,68.3) v5(94.48,67.66) v5(94.45,66.55) v5(95.07,68.3) v5(95.07,67.66) v5(95.07,66.56) v5(95.38,67.11) v5(95.7,68.3) v5(95.7,67.66) v5(95.7,66.56) v5(96.34,68.3) v5(96.34,67.66) v5(96.34,66.56) v5(96.66,67.11) v5(96.98,68.3) v5(96.97,67.66) v5(96.97,66.56) v5(97.61,68.3) v5(97.66,67.67) v5(97.67,66.58) v5(97.93,67.11) v5(98.23,70.05) v5(98.23,68.95) v5(98.25,68.3) v5(98.24,67.66) v5(98.25,66.56) v5(98.54,69.5) v5(98.86,70.05) v5(98.86,68.95) v5(98.88,68.3) v5(98.88,67.66) v5(98.84,67.1) v5(99.2,67.11) v5(99.5,70.05) v5(99.5,68.95) v5(99.52,68.3) v5(99.51,67.66) v5(99.45,67.13) v5(99.7,67.46) v5(99.81,69.5) v5(100.04,67.68) v5(100.13,70.05) v5(100.13,68.95) v5(100.15,68.3) v5(100.21,67.25) v6(77.01,49.24) v6(77.68,49.41) v6(78.28,49.02) v6(79.22,49.02) v6(80.01,49.33) v6(80.79,49.03) v6(81.67,49.03) v6(82.55,49.3) v6(83.39,49.41) v6(84.9,40.94) v6(84.99,49.36) v6(85.82,49.37) v6(85.77,40.92) v6(86.49,49.35) v6(86.66,40.98) v6(87.57,40.94) v6(88.54,40.93) v6(89.04,68.66) v6(89.36,41.01) v6(89.62,49.39) v6(90.33,68.66) v6(90.33,40.9) v6(90.72,49.4) v6(91.3,40.96) v6(91.36,49.37) v6(91.59,68.67) v6(92.85,68.67) v6(94.11,68.66) v6(95.38,68.66) v6(96.66,68.66) v6(97.65,68.82)
+VCC_CORE_G0: length 2.5
  TOP w0.127: v2(89.7,49.94) 90.12,49.94 90.88,50.7 T29.1
  IN1 w0.061: v2(89.7,49.94) v4(89.3,50.25)
  IN3 w0.061: v5(89.68,50.27) v4(89.3,50.25)
+VCC_CORE_G1: length 1.6
  TOP w0.127: T30.1 90.87,40.75 v2(90.59,40.47)
  IN1 w0.254: v4(90.83,40.7) 90.82,40.7 v2(90.59,40.47)
  IN3 w0.254: v5(90.56,40.38) 90.83,40.65 v4(90.83,40.7)
+VCC_CORE_G2: length 1.4
  TOP w0.127: v2(88.76,49.82) 88.66,49.71 T134.1
  IN1 w0.061: v4(88.42,50.27) 88.76,49.92 v2(88.76,49.82)
  IN3 w0.076: v5(88.76,50.27) 88.42,50.27 v4(88.42,50.27)
+VCC_CORE_G3: length 2.3
  TOP w0.127: v2(90.08,40.47) 89.91,40.63 89.91,41.04 89.51,41.45 T135.1
  IN1 w0.254: v2(90.08,40.47) v4(89.8,40.7)
  IN3 w0.254: v4(89.8,40.7) 89.74,40.58 v5(89.65,40.38)
+VCCDPHY_1P24: length 1.1
  TOP w0.102: v2(109.83,40.28) v1(109.83,39.19)
  vias: v4(109.83,39.92) v5(109.27,40.28)
+VCCGT: length 76.6
  TOP w0.127: PC1361.1 68.88,45.69 ; PC1351.1 73.38,50.29 ; 69.47,45.7 PC1360.1 69.48,45.71
  IN3 w0.076: v5(75.83,50.27) v4(75.5,50.27)
  IN3 w0.203: v5(65.06,46.56) v4(64.83,46.79) ; v5(65.72,50.97) v4(65.48,51.2) ; v4(73.21,49.94) 73.21,50.12 v5(73.06,50.27) ; v5(65.71,52.28) v4(65.48,52.51) ; v4(75.6,50.96) v5(75.37,50.73) ; v4(66.44,51.87) 66.44,51.87 ; v5(66.03,51.63) v4(65.8,51.86) ; v4(70.06,50.96) v5(69.82,50.73) ; v5(73.98,50.27) v4(74.21,50.04) ; v5(65.06,48.44) v4(64.83,48.68) ; v5(66.36,52.28) v4(66.13,52.51)
  IN3 w0.254: v5(68.96,47.5) v4(68.73,47.73) ; v5(65.08,53.16) v4(64.85,53.39) ; v5(66.36,44.67) v4(66.13,44.91) ; v5(71.21,50.27) 71.37,50.11 v4(71.37,49.96) ; v4(69.84,45.87) 69.84,45.85 v5(69.61,45.62) ; v4(74.68,50.96) v5(74.44,50.73) ; v5(68.96,44.67) v4(68.73,44.91) ; v5(67.66,43.73) v4(67.43,43.97) ; v5(72.13,50.27) v4(72.13,49.94) ; v5(66.32,54.12) v4(66.55,54.35) ; v5(68.31,47.5) v4(68.08,47.73) ; v5(67.01,47.5) v4(66.78,47.73) ; v5(68.31,44.67) v4(68.08,44.91) ; v5(66.36,43.73) v4(66.13,43.97) ; v5(68.96,46.56) v4(68.73,46.79) ; v5(66.77,53.66) v4(67,53.89) ; v5(68.31,43.73) v4(68.08,43.97) ; v4(68.21,50.96) v5(67.98,50.73) ; v4(73.75,50.96) v5(73.52,50.73) ; v4(72.83,50.96) v5(72.59,50.73) ; v5(65.06,52.29) v4(64.83,52.53) ; v5(67.98,52.68) v4(68.21,52.91) ; v5(68.96,49.38) v4(68.73,49.62) ; v5(66.36,45.62) v4(66.13,45.85) ; v5(67.01,43.73) v4(66.78,43.97) ; v4(71.9,50.96) v5(71.67,50.73) ; v5(68.31,49.38) v4(68.08,49.62) ; v5(67.01,46.56) v4(66.78,46.79) ; v5(68.9,52.03) v4(69.13,52.26) ; v5(65.06,43.73) v4(64.83,43.97) ; v4(69.11,51.65) 68.9,51.44 v5(68.9,51.38) ; v4(69.19,45.91) 69.13,45.85 69.13,45.78 v5(68.96,45.62) ; v4(70.98,50.96) v5(70.75,50.73) ; v5(66.36,49.38) v4(66.12,49.62) ; v5(65.71,43.73) v4(65.48,43.97) ; v5(67.01,49.38) v4(66.78,49.62) ; v5(67.38,53.43) v4(67.61,53.19) ; v5(68.96,43.73) v4(68.73,43.97) ; v5(65.06,44.67) v4(64.83,44.91) ; v5(65.06,47.5) v4(64.83,47.73) ; v5(65.06,50.98) v4(64.83,51.21) ; v5(68.31,45.62) v4(68.08,45.85) ; v5(66.36,47.5) v4(66.13,47.73) ; v5(68.31,48.44) v4(68.08,48.68) ; v5(71.67,51.38) v4(71.9,51.61) ; v4(69.8,44.06) 69.8,43.92 v5(69.61,43.73) ; v5(67.66,49.38) v4(67.43,49.62) ; v4(66.02,54.45) 66.02,54.64 v5(66.16,54.78) ; v5(65.71,47.5) v4(65.48,47.73) ; v5(67.98,52.03) v4(68.21,52.26) ; v5(69.61,49.38) v4(69.38,49.62) ; v5(65.71,49.38) v4(65.48,49.62) ; v5(67.01,48.44) v4(66.78,48.68) ; v5(65.06,45.62) v4(64.83,45.85) ; v5(65.71,45.62) v4(65.48,45.85) ; v5(67.66,45.62) v4(67.43,45.85) ; v5(67.66,47.5) v4(67.43,47.73) ; v5(69.82,51.38) v4(70.06,51.61) ; v5(67.01,44.67) v4(66.78,44.91) ; v5(67.01,45.62) v4(66.78,45.85) ; v5(69.61,47.5) v4(69.38,47.73) ; v5(66.36,48.44) v4(66.13,48.68) ; v5(68.9,52.68) v4(69.13,52.91) ; v5(65.67,53.58) v4(65.9,53.81) ; v5(67.98,51.38) v4(68.21,51.61) ; v4(69.19,51.02) v5(68.9,50.73) ; v5(68.96,48.44) v4(68.73,48.68) ; v5(65.06,49.38) v4(64.83,49.62) ; v5(66.36,46.56) v4(66.13,46.79) ; v5(70.75,51.38) v4(70.98,51.61)
  BOTTOM w0.102: v5(68.96,46.56) 68.72,46.32 68.72,46.32 ; v5(68.96,46.56) v4(68.73,46.79) 68.72,46.79 ; v5(68.96,46.56) 69.23,46.29 69.23,46.28 ; v5(68.96,46.56) 69.19,46.79 69.21,46.79 ; v5(68.31,45.62) 68.57,45.36 68.57,45.36 ; v5(68.31,45.62) 68.06,45.86 ; v5(68.31,45.62) 68.55,45.86 68.56,45.86 ; v5(68.31,45.62) 68.04,45.35 ; v5(68.31,43.73) 68.05,43.47 ; v5(68.31,43.73) 68.57,43.47 68.57,43.47 ; v5(68.31,43.73) 68.56,43.98 ; v5(68.31,43.73) 68.07,43.97 ; 69.89,44.01 69.89,44.01 v5(69.61,43.73) ; 68.68,50.52 68.69,50.52 v5(68.9,50.73) ; v5(68.96,45.62) 69.21,45.86 69.21,45.86 ; v5(68.96,45.62) 68.71,45.36 68.71,45.36 ; v5(68.96,45.62) 69.22,45.36 69.23,45.36 ; v5(68.96,45.62) 68.72,45.86 68.71,45.86 ; 75.16,50.94 75.16,50.93 v5(75.37,50.73) ; v5(71.21,50.27) 71.21,50.27 70.75,49.81 UCPU1.L10 ; v5(71.21,50.27) 71.67,49.81 UCPU1.N10 ; v5(71.21,50.27) 70.98,50.5 70.97,50.5 70.75,50.72 v5(70.75,50.73) ; v5(73.52,50.73) 73.52,50.73 73.75,50.5 73.75,50.5 v5(73.98,50.27) ; v5(73.52,50.73) 73.52,50.73 73.06,50.27 v5(73.06,50.27) ; v5(73.52,50.73) 73.31,50.94 ; v5(73.52,50.73) 73.72,50.93 ; 69.87,47.24 69.87,47.24 v5(69.61,47.5) ; v5(72.13,50.27) 72.12,50.27 71.67,50.72 v5(71.67,50.73) ; v5(72.13,50.27) 71.89,50.03 71.88,50.03 71.67,49.82 UCPU1.N10 ; v5(72.13,50.27) 72.13,50.28 72.58,50.73 v5(72.59,50.73) ; v5(72.13,50.27) 72.33,50.08 ; 75.61,50.06 v5(75.83,50.27) 75.83,50.28 75.37,50.73 v5(75.37,50.73) ; v5(69.61,47.5) 69.38,47.73 69.38,47.73 ; v5(69.61,47.5) 69.37,47.26 69.37,47.25 ; v5(69.61,47.5) 69.84,47.73 69.86,47.73 ; 68.71,44.42 68.71,44.42 v5(68.96,44.67) ; v5(68.96,48.44) 68.72,48.2 68.72,48.2 ; v5(68.96,48.44) 69.2,48.69 69.2,48.7 ; v5(68.96,48.44) 68.71,48.69 68.71,48.69 ; v5(68.96,48.44) 69.22,48.18 69.23,48.18 ; v5(69.61,49.38) 69.85,49.62 69.85,49.62 ; v5(69.61,49.38) 69.37,49.14 ; v5(69.61,49.38) 69.37,49.62 69.37,49.62 ; v5(69.61,49.38) 69.87,49.13 69.87,49.12 ; UCPU1.V9 74.45,50.73 v5(74.44,50.73) ; UCPU1.V9 75.36,50.73 v5(75.37,50.73) ; UCPU1.V9 74.71,50.08 74.63,50.01 UCPU1.U10 ; UCPU1.V9 75.09,50.08 ; v5(68.31,44.67) 68.04,44.95 ; v5(68.31,44.67) 68.05,44.42 ; v5(68.31,44.67) 68.55,44.91 68.55,44.92 ; v5(68.31,44.67) 68.54,44.44 68.54,44.4 ; v5(68.31,47.5) 68.06,47.75 ; v5(68.31,47.5) 68.07,47.26 ; v5(68.31,47.5) 68.55,47.74 68.55,47.74 ; v5(68.31,47.5) 68.58,47.23 ; v5(73.98,50.27) 73.98,50.27 74.43,49.81 UCPU1.U10 ; v5(73.98,50.27) 73.98,50.28 74.43,50.73 v5(74.44,50.73) ; v5(73.98,50.27) 73.98,50.27 73.52,49.81 UCPU1.T10 ; UCPU1.G15 68.05,46.3 ; UCPU1.G15 68.57,46.3 68.57,46.3 ; UCPU1.G15 68.56,46.81 ; UCPU1.G15 68.04,46.83 ; v5(69.61,43.73) 69.35,44 69.34,44 ; v5(69.61,43.73) 69.89,43.45 69.91,43.45 ; v5(69.61,43.73) 69.34,43.46 69.34,43.45 ; 69.59,50.96 69.59,50.96 v5(69.82,50.73) ; v5(68.96,49.38) 69.2,49.62 69.2,49.62 ; v5(68.96,49.38) 69.21,49.13 69.21,49.13 ; v5(68.96,49.38) 68.72,49.14 ; v5(68.96,49.38) 68.72,49.62 68.72,49.62 ; 69.86,45.87 69.86,45.87 v5(69.61,45.62) ; v5(67.98,50.73) 67.76,50.51 67.76,50.51 ; v5(67.98,50.73) 68.18,50.52 ; v5(67.98,50.73) 68.18,50.94 68.18,50.95 ; v5(67.98,50.73) 67.76,50.94 67.74,50.94 ; UCPU1.N10 71.48,49.62 ; UCPU1.N10 71.89,49.6 ; v5(68.96,47.5) 68.72,47.74 ; v5(68.96,47.5) 69.21,47.75 ; v5(68.96,47.5) 69.23,47.23 ; v5(68.96,47.5) 68.71,47.25 68.71,47.25 ; 70.95,49.61 UCPU1.L10 ; UCPU1.L10 70.56,49.62 70.45,49.57 UCPU1.K11 ; UCPU1.L10 70.56,50.01 ; v5(75.37,50.73) 75.59,50.95 75.6,50.95 ; v5(69.61,45.62) 69.36,45.36 69.36,45.36 ; v5(69.61,45.62) 69.37,45.86 69.37,45.86 ; v5(69.61,45.62) 69.87,45.36 69.87,45.36 ; v5(68.9,50.73) 68.68,50.95 68.67,50.95 ; v5(68.9,50.73) 69.13,50.96 69.15,50.96 ; v5(68.9,50.73) 69.13,50.5 69.13,50.5 ; v5(72.59,50.73) 72.81,50.95 ; v5(72.59,50.73) 72.6,50.73 v5(73.06,50.27) ; 68.06,48.7 68.06,48.69 v5(68.31,48.44) ; 74.64,49.62 UCPU1.U10 ; UCPU1.U10 74.25,49.62 ; 68.71,43.98 68.71,43.98 v5(68.96,43.73) ; v5(73.06,50.27) 73.28,50.04 73.29,50.04 73.52,49.82 UCPU1.T10 ; v5(73.06,50.27) 72.84,50.06 ; v5(71.67,50.73) 71.46,50.94 71.46,50.94 ; v5(71.67,50.73) 71.87,50.93 71.88,50.93 ; v5(74.44,50.73) 74.23,50.94 74.2,50.94 ; v5(74.44,50.73) 74.68,50.97 74.69,50.97 ; 68.04,49.63 68.07,49.63 v5(68.31,49.38) ; v5(70.75,50.73) 70.54,50.93 ; v5(70.75,50.73) 70.55,50.53 ; v5(70.75,50.73) 70.96,50.94 ; UCPU1.T10 73.73,49.6 ; UCPU1.T10 73.33,49.62 ; 68.54,49.63 68.54,49.62 v5(68.31,49.38) ; v5(68.31,49.38) 68.05,49.13 ; v5(68.31,49.38) 68.56,49.13 ; v5(69.82,50.73) 70.05,50.96 70.05,50.98 ; v5(69.82,50.73) 70.04,50.51 70.05,50.51 ; v5(69.82,50.73) 69.6,50.51 69.59,50.51 ; UCPU1.K11 70.07,49.57 ; UCPU1.K11 70.48,49.17 ; UCPU1.K11 70.04,49.17 ; v5(68.96,43.73) 69.2,43.98 69.2,43.99 ; v5(68.96,43.73) 68.71,43.49 68.71,43.49 ; v5(68.96,43.73) 69.21,43.49 69.21,43.47 ; 69.21,44.42 69.21,44.42 v5(68.96,44.67) ; v5(68.31,48.44) 68.56,48.19 68.56,48.19 ; v5(68.31,48.44) 68.06,48.2 ; v5(68.31,48.44) 68.56,48.69 ; 69.2,44.91 69.19,44.91 v5(68.96,44.67) ; v5(68.96,44.67) 68.72,44.91
  vias: v2(64.18,48.13) v2(64.18,45.69) v2(64.18,43.43) v2(64.44,45.69) v2(64.77,48.13) v2(64.77,43.43) v2(65.38,43.55) v2(65.82,45.57) v2(66,50.91) v2(65.99,43.55) v2(66.08,51.64) v2(66.19,48.1) v2(66.41,45.55) v2(66.45,48.1) v2(66.65,43.6) v2(67.26,43.6) v2(67.56,52.85) v2(67.73,45.52) v2(67.94,48.13) v2(67.97,43.6) v2(68.07,52.6) v2(68.2,48.13) v2(68.26,45.52) v2(68.58,43.6) v2(68.91,49.19) v2(68.83,47.36) v2(68.88,45.68) v2(69.48,53.24) v2(69.48,52.89) v2(69.47,47.36) v2(69.51,45.65) v2(69.45,44.24) v2(69.53,50.76) v2(69.59,49.17) v2(70.99,50.26) v2(71.28,47.89) v2(71.26,46.7) v2(71.26,45.51) v2(71.26,44.31) v2(71.26,43.12) v2(71.26,41.86) v2(71.51,46.7) v2(71.51,45.51) v2(71.51,44.32) v2(71.51,43.12) v2(71.51,41.86) v2(71.57,50.32) v2(71.54,47.9) v2(72.47,50.26) v2(72.86,52.96) v2(73.11,52.96) v2(73.41,50.32) v2(73.75,47.89) v2(73.75,46.7) v2(73.75,45.51) v2(73.77,44.31) v2(73.77,43.12) v2(73.77,41.93) v2(74,47.9) v2(74,46.7) v2(74,45.51) v2(74.03,44.32) v2(74.03,43.12) v2(74.03,41.93) v2(74.24,50.57) v2(74.83,50.24) v3(51.31,46.32) v4(66.58,51.28) v4(68.06,46.77) v4(69.82,54.37) v4(71.41,48.2) v4(71.38,47.01) v4(71.38,45.81) v4(71.38,44.62) v4(71.38,43.43) v4(71.38,42.17) v4(72.26,54.08) v4(73.87,48.2) v4(73.87,47.01) v4(73.87,45.81) v4(73.9,44.62) v4(73.9,43.43) v4(73.9,42.23) v5(65.67,54.27) v5(66.34,51.05) v5(66.69,51.65) v5(68.33,46.54) v5(70.29,55.05) v5(72.73,55.05) v6(52.26,51.25) v6(52.37,52.59) v6(52.68,51.97) v6(52.66,50.52) v6(53.11,52.71) v6(53.1,51.25) v6(53.08,49.8) v6(53.52,51.97) v6(53.51,50.52) v6(53.92,41.08) v6(53.93,51.25) v6(53.93,49.8) v6(53.94,42.53) v6(54.35,50.52) v6(54.42,43.27) v6(54.34,41.81) v6(54.77,49.8) v6(54.78,42.53) v6(54.76,41.08) v6(54.92,47.63) v6(54.9,43.99) v6(55.32,43.27) v6(55.35,48.37) v6(55.34,46.91) v6(55.34,44.72) v6(55.76,47.63) v6(55.74,43.99) v6(56.19,48.37) v6(56.18,46.91) v6(56.18,44.72) v6(56.16,43.27) v6(56.6,47.63) v6(56.58,43.99) v6(57.02,46.91) v6(57.02,44.72) v6(57,43.27) v6(57.03,48.37) v6(57.42,43.99) v6(57.43,47.63) v6(57.87,48.37) v6(57.85,46.91) v6(57.85,44.72) v6(57.83,43.27) v6(58.27,47.63) v6(58.25,43.99) v6(58.7,48.37) v6(58.69,46.91) v6(58.69,44.72) v6(58.67,43.27) v6(59.11,47.63) v6(59.09,43.99) v6(59.51,43.27) v6(59.54,48.37) v6(59.53,46.91) v6(59.53,44.72) v6(59.95,47.63) v6(59.93,43.99) v6(60.38,48.37) v6(60.37,46.91) v6(60.37,44.72) v6(60.35,43.27) v6(60.79,47.63) v6(60.77,43.99) v6(61.22,48.37) v6(61.21,46.91) v6(61.21,44.72) v6(61.19,43.27) v6(61.61,43.99) v6(61.63,47.63) v6(62.06,48.37) v6(62.04,46.91) v6(62.04,44.72) v6(62.03,43.27) v6(62.46,47.63) v6(62.44,43.99) v6(62.9,48.37) v6(62.88,46.91) v6(62.88,44.72) v6(62.86,43.27) v6(63.31,47.65) v6(63.3,44.01) v6(70.65,48.79) v6(70.65,47.9) v6(70.65,47.01) v6(70.65,46.12) v6(70.65,45.1) v6(70.65,44.21) v6(70.7,43.4) v6(71.16,49.47) v6(71.92,49.27) v6(73.29,49.26) v6(74,49.32) v6(74.67,49.23)
+VCCLDOSRAM_1P24: length 1.3
  IN3 w0.076: v5(101.06,41.6) v4(101.29,41.83) ; v5(101.71,41.6) v4(101.94,41.83) ; v5(101.06,40.76) v4(101.29,40.99) ; v5(101.71,40.76) v4(101.94,40.99)
+VCCPDSW_1P05: length 0.9
  IN1 w0.254: v2(99.16,41.23) v4(98.79,41.09)
  IN3 w0.254: v5(98.46,40.76) v4(98.79,41.09)
+VCCPLL_OC: length 25.9
  TOP w0.127: v3(96.95,22.5) 97.27,22.17 v6(97.87,22.17)
  TOP w0.203: CC203.1 95.39,40.57 96.04,41.21 CC232.1
  TOP w0.254: CC233.1 CC203.1
  IN1 w0.254: v4(95.58,39.37) 95.56,39.38 v2(95.42,39.79)
  IN2 w0.508: 94.5,34.56 94.5,31.34 99.77,26.07 100.28,26.07 100.77,25.57 100.77,23.28 99.66,22.17 v6(97.87,22.17)
  IN3 w0.254: v5(95.58,38.99) v4(95.58,39.37) v5(96.03,39.46)
  BOTTOM w0.508: R103.2 98.02,19.07 CZ6.1 98.53,19.41 97.94,20 97.94,22.1 v6(97.87,22.17)
+VCCPLL_OC_R: length 1.6
  TOP w0.127: v1(95.67,18.52) 95.85,18.7 v2(95.85,19.04)
  IN1 w0.061: v2(95.85,19.04) v4(96.1,19.3)
  IN3 w0.061: v5(96.3,18.99) 96.1,19.2 v4(96.1,19.3)
  BOTTOM w0.127: R103.1 v5(96.3,18.99)
+VCCRTCEXT: length 0.7
  IN1 w0.061: v2(97.66,41.19) v4(97.39,40.99)
  IN3 w0.076: v5(97.16,40.76) v4(97.39,40.99)
+VCCSA: length 21.7
  TOP w0.381: PC1383.1 v2(94.18,39.83)
  IN1 w0.254: v4(95,39.92) 94.82,39.9 v2(94.18,39.83) ; v2(94.4,50.46) 94.48,50.46 v4(94.68,50.25)
  IN3 w0.076: v4(95.59,50.27) 95.69,50.37 v5(95.69,50.73) ; v5(96.49,39.92) v4(96.72,40.15) ; v5(93.38,50.27) v4(93.38,49.94) ; v4(95.2,50.65) 94.84,50.65 v5(94.77,50.73) ; v5(95.69,49.81) v4(95.92,49.58) ; v5(92.92,50.73) v4(93.15,50.96)
  IN3 w0.254: v4(94.9,38.76) 94.89,38.76 94.89,38.77 v5(94.67,38.99) ; v4(94.68,50.25) 94.67,50.27 v5(94.3,50.27) ; v5(93.84,49.81) 94.21,49.81 v4(94.22,49.81) ; v5(94.67,39.92) v4(95,39.92)
  BOTTOM w0.102: UCPU1.BL24 94.93,40.57 ; UCPU1.BL24 95.32,40.58 ; UCPU1.BL24 95.12,40.38 94.67,39.92 v5(94.67,39.92) 94.89,39.69 95.12,39.46 v5(95.12,39.46) ; UCPU1.BL24 95.33,40.18 ; v5(95.69,49.81) 95.47,49.6 ; v5(95.69,49.81) 95.68,49.81 95.23,50.27 v5(95.23,50.27) ; v5(95.69,49.81) 95.87,50 ; v5(95.69,49.81) 95.9,49.6 ; v5(95.69,50.73) 95.9,50.52 ; v5(95.69,50.73) 95.68,50.73 95.23,50.28 v5(95.23,50.27) ; v5(95.69,50.73) 95.91,50.95 ; v5(95.69,50.73) 95.5,50.92 ; v5(94.77,50.73) 94.58,50.92 ; v5(94.77,50.73) 94.53,50.49 94.53,50.49 v5(94.3,50.27) ; v5(94.77,50.73) 94.77,50.73 95.22,50.27 v5(95.23,50.27) ; v5(94.77,50.73) 94.96,50.92 ; v5(95.12,39.46) 94.93,39.26 ; v5(95.12,39.46) 95.31,39.64 ; v5(95.12,39.46) 95.32,39.26 ; UCPU1.BJ8 93.6,50.49 93.6,50.49 v5(93.38,50.27) ; UCPU1.BJ8 94.03,50.92 ; UCPU1.BJ8 93.85,50.73 94.3,50.28 v5(94.3,50.27) ; UCPU1.BJ8 93.66,50.91 ; v5(96.03,40.38) 96.23,40.58 ; v5(96.03,40.38) 95.82,40.6 ; v5(96.03,40.38) 96.03,40.38 96.49,39.93 v5(96.49,39.92) ; v5(96.03,40.38) 95.83,40.18 ; v5(93.84,49.81) 93.84,49.82 94.07,50.04 94.08,50.04 v5(94.3,50.27) ; v5(93.84,49.81) 93.84,49.81 93.38,50.27 v5(93.38,50.27) ; v5(93.84,49.81) 93.64,49.61 ; v5(93.84,49.81) 94.04,49.61 ; v5(94.3,50.27) 94.49,50.08 ; v5(93.38,50.27) 93.38,50.27 92.92,50.73 v5(92.92,50.73) 93.16,50.97 ; v5(93.38,50.27) 93.14,50.03 93.13,50.03 92.92,49.82 UCPU1.BG10 93.13,49.6 ; v5(96.49,39.92) 96.3,39.73 ; v5(96.49,39.92) 96.71,40.14 ; v5(96.49,39.92) 96.72,39.69
  vias: v2(94.22,48.71) v2(94.22,48.23) v2(94.22,46.3) v2(94.22,45.81) v2(94.22,43.94) v2(94.25,47.52) v2(94.25,47.03) v2(94.25,45.08) v2(94.25,44.6) v2(94.25,43.4) v2(94.25,42.69) v2(94.25,42.23) v2(94.97,48.58) v2(94.97,48.01) v2(94.97,47.44) v3(103.73,61.88) v4(93.81,48.46) v4(93.84,47.26) v4(93.84,46.07) v4(93.86,44.82) v4(93.86,43.63) v4(93.84,42.44) v4(94.05,50.97) v4(94.6,48.46) v4(94.6,47.29) v4(94.6,43.68) v4(94.63,46.07) v4(94.63,44.85) v4(94.65,42.46) v4(96.05,42.06) v4(96.05,41.55) v4(96.05,41.04) v4(96.27,40.62) v4(126.91,55.52) v4(127.42,55.52) v4(127.93,55.52) v4(128.43,55.52) v5(93.83,50.71) v5(94.66,39.53) v5(95.12,40.37) v5(95.69,40.29) v5(95.97,39.91) v5(96.36,40.26) v5(126.78,55.92) v5(127.09,55.93) v5(127.39,55.92) v5(127.98,55.92) v5(128.29,55.92) v5(128.6,55.93) v6(93.31,49.41) v6(93.89,49.27) v6(94.58,49.27) v6(126.55,57.13) v6(126.6,56.42) v6(127.09,56.97) v6(127.29,56.41) v6(127.85,56.64) v6(128.38,56.43)
+VSS_PLL: length 3.5
  TOP w0.33: CE7.2 259.66,56.69 CE8.2 262.36,56.69 UE1.G1
AGND: length 42.9
  TOP w0.102: v3(285.99,29.46) 286.41,29.46 v6(286.53,29.58) ; v3(295.06,19.01) 295.06,19.42 294.5,19.98 293.36,19.98 v9(293,20.34) ; v2(288.77,29.75) v3(288.77,30.89)
  TOP w0.203: UA1.22 284.9,20.27 v6(285,20.17) ; v6(286.68,27.17) 286.35,27.5 285.8,27.5 285.7,27.4 UA1.37
  TOP w0.356: RA12.1 290.76,27.01 v6(290.97,27.22)
  TOP w0.381: v6(288.29,18.91) 288.69,18.91 CA8.2 ; CA13.2 v6(288.14,26.78) ; v6(302.29,24.62) 302.29,25.11 302.6,25.42 RA125.1 ; CA14.2 v6(286.53,29.58)
  TOP w0.508: v6(288.29,18.91) 288.29,18.54 288.52,18.31 RA5.2 ; RA1.2 v6(289.79,19.03) ; v6(287.4,30.35) 287.82,29.93 CA16.2 v2(288.77,29.75) ; v6(290.97,27.22) 290.5,27.69 CA15.1
  GND1 w0.203: 303.25,11.87 JHP1.5 ; JHP1.5 304.31,12.52 ; JHP1.5 302.2,12.52 ; JHP1.5 304.31,11.87 ; JHP1.5 302.2,11.87
  IN1 w0.508: v2(288.77,29.75) 289.23,29.75 v4(289.35,29.63)
  GND2 w0.203: JHP1.5 304.31,11.87 ; JHP1.5 302.2,12.52 ; JHP1.5 302.2,11.87 ; JHP1.5 303.25,11.87 ; JHP1.5 304.31,12.52
  VCC w0.203: 303.25,11.87 JHP1.5 ; JHP1.5 302.2,11.87 ; JHP1.5 302.2,12.52 ; JHP1.5 304.31,12.52 ; JHP1.5 304.31,11.87
  GND3 w0.203: 302.2,12.52 JHP1.5 ; JHP1.5 304.31,12.52 ; JHP1.5 303.25,11.87 ; JHP1.5 304.31,11.87 ; JHP1.5 302.2,11.87
  GND4 w0.203: 303.25,11.87 JHP1.5 ; JHP1.5 304.31,12.52 ; JHP1.5 302.2,11.87 ; JHP1.5 304.31,11.87 ; JHP1.5 302.2,12.52
  BOTTOM w0.508: v6(287.4,30.35) 288.01,30.95 RA6.2
  vias: v2(285.29,18.43) v2(286.16,18.13) v9(285.29,19.2) v9(289.48,20.34) v9(290.45,23.77) v9(291.87,24.53) v9(291.95,22.29) v9(291.95,21.02) v9(292.07,19.2) v9(299.19,16.53)
DV12S: length 8.9
  TOP w0.127: CR14.1 v2(293.09,31.82)
  IN1 w0.508: v2(291.93,32.69) 291.93,33.41 291.22,34.12 v4(291.22,34.53) ; v2(293.09,31.82) v4(293.09,31.46)
  IN2 w0.508: v4(293.09,31.46) 293.09,33.98 292.28,34.79 291.48,34.79 v4(291.22,34.53)
  IN3 w0.508: v4(291.22,34.53) 291.22,34.25 v5(291.41,34.07)
  BOTTOM w0.127: CR15.1 v1(291.44,34.99)
DV33_18:
  vias: v1(296.2,33.78)
GND: length 3350.5
  TOP w0.102: v6(195.81,39.39) v3(194.87,39.39) ; v6(289.79,66.82) v3(289.06,66.82)
  TOP w0.127: v9(281.45,37.36) 281.93,37.36 v2(281.99,37.29) 282.18,37.29 283.09,36.39 v9(286.36,36.39) 286.46,36.29 287.31,36.29 287.82,36.8 288.53,36.8 288.81,37.08 290.36,37.08 v9(290.45,36.99) ; v9(281.45,37.36) 281.45,36.5 v2(281.81,36.14) 282.49,35.46 v9(282.62,35.46) 287.71,35.46 288.11,35.86 v9(288.68,35.86) ; v9(281.45,37.36) 281.45,39.19 280.87,39.77 v2(280.54,39.77) 280.21,39.44 v2(280.21,38.77) 280.21,36.58 ; 280.21,36.58 280.19,36.61 279.59,36.61 279.42,36.44 279.42,35.64 279.6,35.46 279.97,35.46 v2(280.02,35.52) 280.43,35.11 280.43,34.96 v9(281.7,33.69) 281.83,33.56 288.1,33.56 288.4,33.25 290.26,33.25 v6(290.42,33.42) ; 280.21,36.58 v9(280.66,36.13) v9(282.33,34.46) 282.39,34.41 v9(288.47,34.41) ; v6(251.27,14) 251.57,14.31 v3(251.57,14.88) ; v6(208.76,40.3) v3(208.76,41.27) ; v6(224,55.52) v3(222.74,55.52) ; v9(300.06,54.39) 299.95,54.5 v9(298.8,54.5) 296.04,54.5 v2(295.88,54.65) ; v2(72.87,56.36) v3(72.41,56.82) ; v6(223.66,13) v3(222.73,13) ; v9(222.52,47.64) v3(222.52,46.44) ; v6(284.49,46.64) 283.18,46.64 v2(283.13,46.59) 282.7,46.59 v9(282.33,46.23) ; v9(290.22,45.22) 290.93,45.22 292.94,47.22 v9(292.94,50.72) v2(294.59,52.37) ; v9(282.33,46.23) 281.82,46.74 281.82,48 282.1,48.27 284.96,48.27 v2(285.2,48.03) ; v9(282.33,46.23) 282.33,45.79 v2(283.15,44.98) ; v2(295.79,55.9) 295.91,56.02 v9(296.19,56.02) 299.09,56.02 v2(299.24,55.86) ; v9(288.99,48.03) 289.53,48.03 v9(289.91,48.41) 290.28,48.77 v9(290.28,49.87) v9(290.28,51.24) 290.88,51.83 291.28,52.1 291.49,52.27 291.98,52.76 292.05,52.86 292.43,53.43 292.47,53.53 292.66,53.85 v9(293.01,54.49) ; 293.63,53.38 291.7,51.45 v9(291.7,51.38) 291.7,48.02 v9(291.47,47.78) 290.33,46.64 v6(290.19,46.64) ; 293.63,53.38 v9(293.66,53.38) ; 293.63,53.38 293.74,53.49 294.22,53.49 294.87,52.83 v9(295.03,52.83) 300.07,52.83 v6(300.12,52.88) ; v3(249.35,31.07) 249.83,30.59 CN12.2 ; v9(267.25,42.67) 268.06,42.67 v3(268.4,43.01) ; v6(284.03,59.89) 283.05,59.89 v3(282.84,59.68) ; v6(73.1,28.43) v3(74.01,28.43) ; v9(26.29,28.7) v3(27.71,28.7) ; v3(80.35,23.11) CD8.2 ; v6(296.39,63.39) v3(295.25,63.39) ; v6(57.52,17.65) v3(56.5,17.65)
  TOP w0.203: UA8.11 266.23,38.16 v9(266.22,38.15) ; UN3.7 v9(198.44,72.37) ; U12.11 v9(123.95,31.09) ; v9(199.34,32.1) 199.33,32.09 U6.11
  TOP w0.254: v6(226.48,53.75) 226.4,53.83 U32.3 ; v2(69.49,46.34) 69.47,46.32 PC1360.2 ; v9(48.65,31.3) 48.28,31.3 48.2,31.39 UZ6.9 ; v6(249.66,22.78) 249.71,22.78 250.04,23.11 UN1.20 ; v2(51.45,24.77) 51.16,24.77 50.85,25.09 PC614.2 ; UZ6.16 47.88,34.89 48.31,35.32 v6(48.31,35.63) ; v2(81.51,21.35) 81.51,21.36 CD7.2 ; v2(23.87,45.09) 23.75,44.98 PU102.2 ; CT131.2 v2(25.49,51.06) ; v2(48,75.88) 48.09,75.79 C30.2 ; v2(69.34,50.27) 69.59,50.01 PC1357.2 ; v2(24.97,67.24) 24.95,67.27 RT56.2 ; v5(69.97,18.23) v2(69.97,19.03) ; UE1.H4 265.04,55.61 v2(265.04,55.62) ; RC572.1 v2(102.2,29.32) ; CD30.2 57.56,15.86 ; v6(21.79,13.17) 21.6,12.98 UI5.14 ; v2(81.32,40.43) 81.43,40.57 CC236.2 ; v6(252.37,25.52) 252.34,25.55 UN1.5 ; UI4.14 288,63.36 v6(288,64.14) ; UD2.D12 v5(62.17,25.87) ; UE1.A13 272.24,61.2 v2(272.25,61.2) ; v9(85.79,73.13) 85.56,73.36 PU1500.2 ; CC67.2 97.52,44.42 CC68.2 ; v6(284.49,46.64) UI2.21 ; PC1356.2 68.91,49.8 v2(68.43,50.28) ; v2(13.68,68.81) 13.53,68.96 PQ111.3 ; U8.5 v6(225.31,60.86) ; U27.4 113.01,15.89 ; 113.01,15.89 UC18.4 ; 113.01,15.89 v9(113,15.89) ; 73.03,51.75 PC1336.2 72.68,51.75 ; CC56.2 81.85,39.88 v2(81.85,39.89) ; v5(93.47,25.87) UD3.T12 ; v2(41.55,22.24) 41.52,22.22 PD104.1 ; PC1334.2 68.27,42.86 v2(68.33,42.92) ; v5(92.17,25.87) UD3.P12 ; v6(252.47,24.25) 252.27,24.05 UN1.2 ; v2(16.48,63.56) 16.19,63.27 PQ109.4 ; UM3.2 v2(20.99,35.89) ; v2(67.58,29.1) CD9.2 ; v6(309.21,67.8) 309.21,67.43 309.09,67.31 D3.3 ; v6(249.83,29.08) 250.04,28.87 UN1.11 ; v2(24.96,74.61) 24.79,74.44 RT62.2 ; CA155.2 284.02,14.71 283.5,14.19 UA7.5 ; UT3.4 v9(30.2,49.11) ; UD2.B12 v5(60.87,25.87) ; PC1329.2 68.08,46.96 ; UK1.48 237.25,19.4 v6(237.53,19.68) ; PC1327.2 64.38,49.68 ; CA154.2 v9(278.95,19.54) ; UE1.C4 v2(265.02,59.61) ; U19.5 v9(222.99,51.25) ; v6(290.19,46.64) UI2.10 ; PC138.2 v9(21.96,43.55) ; UE1.E6 v2(266.62,58.01)
  TOP w0.305: CD5.2 88.51,28.69 88.59,28.61 88.59,26.57 v5(88.92,26.23) ; v5(63.47,26.23) 62.76,26.94 CD3.2 ; CD55.2 82.29,19.78 v2(82.6,20.09) ; v5(66.72,23.03) v5(66.72,23.83) 66.72,23.98 v5(66.07,24.63) ; CD15.2 85.28,28.82 85.67,28.43 v5(85.67,26.23) ; UD3.F12 86.97,28.5 86.71,28.77 v2(86.71,29.03) ; CD29.2 92.17,28.85 UD3.P12 ; CD18.2 61.29,29.03 61.29,26.66 UD2.B12 ; CD6.2 90.87,28.45 v5(90.87,26.23) ; CD37.2 68.52,26.39 v5(68.67,26.23) ; v6(294.77,39.69) 294.3,39.69 CR4.2 ; CD9.2 67.58,26.44 v9(67.37,26.23) ; UD3.T12 93.01,26.69 93.01,28.27 93.51,28.77 CD13.2 ; CD32.2 69.87,27.88 69.48,27.49 69.48,26.72 v5(69.97,26.23) ; CT197.2 23.47,71.07 v2(23.38,71.16) ; v5(85.67,23.03) 85.25,22.61 83.55,22.61 83.05,23.11 CD8.2 ; v5(87.62,23.83) 87.62,23.98 v5(88.27,24.63)
  TOP w0.356: v6(57.07,20.97) 57.17,20.86 CD50.2 ; R267.2 226.48,53.74 v6(226.48,53.75) ; CA47.2 v6(294.93,26.96) ; v6(57.06,21.6) 57.24,21.6 57.59,21.25 CD54.2 ; CA27.2 281.94,17.53 CA26.2 ; RD1.2 v2(59.48,14.84) ; v6(211.78,64.6) 212.24,64.15 CN25.2 ; v6(211.74,60.98) CN24.2 CN23.2 ; C56.2 v6(221.84,60.98) ; 57.56,15.86 CD28.2 CD26.2 57.56,17.61 v6(57.52,17.65) ; CN30.2 CN29.2 214.66,38.63 v6(214.6,38.68) ; v6(297.26,32.04) 297.14,32.16 297.13,32.16 296.99,32.31 CR8.2 ; CA6.2 293,25.77 CA4.2 293.43,26.31 v6(293.59,26.47) ; v6(57.03,18.94) RD4.2 ; v6(293.51,27.11) 293.28,26.88 RA4.2 ; v6(285.77,17.21) 286.03,16.96 286.03,15.86 v3(285.25,15.08) CA155.2 ; C57.2 v6(224,55.52) ; RA8.2 v6(294.3,26.96) ; RD13.2 v2(83.68,14.85) ; CN31.2 215.02,39.9 v6(214.63,40.28) ; v6(57.06,23.01) CD16.2 ; CB17.2 v6(310.62,2.83) ; RB25.2 v6(313.41,3.96) ; CB16.2 309,4.83 v6(309.08,4.91) ; v6(279.55,19.68) 280.14,19.68 CA28.2 ; RI123.1 v6(284.03,59.89) ; CA141.2 v6(281.14,14.19) ; v6(225.67,62.14) 225.62,62.1 C59.2 ; RV51.1 v6(246.61,42.75) ; CD108.2 v2(93.83,13.95) ; CD19.2 v6(57.03,19.58) ; CB18.2 v6(313.41,4.59)
  TOP w0.381: v6(57.02,25.35) 57.08,25.29 CD33.2 CD39.2 ; v6(289.42,50.49) 289.41,50.48 CI14.2 ; CD36.2 72.62,22.66 72.41,22.66 v2(72.2,22.87) ; v6(25.75,77.67) 25.99,77.91 RT180.1 ; v6(276.81,22.26) 276.49,22.26 276.14,22.61 CA35.2 CA34.2 ; v6(57.02,24.66) 57.02,24.05 CD17.2 ; CB15.2 v6(309.65,4.59) ; CD11.2 v2(72.98,25.2) ; v2(73.03,23.86) 72.95,23.93 CD14.2 ; v6(25.13,77.73) 24.95,77.91 RT163.2 CT200.2 CT199.2 22.62,77.91 v6(22.55,77.83) ; CT98.2 27.93,77.86 27.45,77.86 RT178.1 ; CR11.2 299.24,38.32 CR12.2 ; RT265.1 RT266.1 ; CT192.2 v2(24.29,73.72) ; CT196.2 CT197.2 ; RI67.2 v6(22.53,13.16) ; CD113.2 v2(75.48,13.99) ; v2(78.89,13.8) 78.89,13.87 78.9,13.89 CD112.2 ; CI13.2 v6(285.14,42.14) ; v6(292.33,30.56) CR1.2 ; CT181.2 v2(23.72,66.48)
  TOP w0.508: CR14.2 293.09,30.62 v6(293.73,29.97) ; RA5.1 v6(289.13,17.16) 289.5,17.53 RA1.1 ; JCR1.23 313.98,28.74 v6(313.65,29.08) ; CD104.2 v2(76.55,14.05) ; v2(73.1,27.35) 73.1,27.25 CD2.2 ; DA1.2 v6(294.35,29.88) ; v6(313.62,33.96) 313.86,34.2 JCR1.17 ; v6(221.8,60.34) 221.51,60.34 221.32,60.53 CN22.2 ; v6(293.92,41.95) 293.93,41.94 CR3.2 ; v6(28.39,4.95) 28.39,4.59 28.71,4.26 SW3.5 ; JCR1.14 314.42,37.7 v6(314.42,38.16) ; CD62.2 57.17,22.55 57.06,22.66 v6(57.06,23.01) ; JCR1.20 314.45,31.47 314.12,31.14 v6(313.66,31.14) ; v6(296.39,63.39) 296.47,63.39 296.9,63.82 PC425.2 ; v6(249.66,22.78) 249.76,22.68 249.76,21.94 CN13.2 ; CD109.2 v2(77.95,14.05) ; SW3.4 v6(20.56,4.55) ; CD40.2 72.26,21.3 v6(71.81,21.76) ; CR11.2 298.55,39.18 v6(298.56,39.19) ; QK1.3 216.33,14.85 v6(215.65,14.18) ; PC1022.2 v6(102.29,70.38) ; PQ1500.3 v6(20.5,6.95) ; 283.12,63.52 282.85,63.25 v6(282.85,62.4) CI25.2 ; PC1116.2 v6(126.49,60.3) ; PQ1502.3 22.43,65.86 23.05,66.48 v2(23.72,66.48) ; CD41.2 72.23,19.53 v6(71.85,19.9) ; PQ205.3 23.52,12.48 v6(23.31,12.27) ; v6(249.83,29.08) CN12.2 ; DA5.1 v6(295.76,27.05)
  GND1 w0.089: 92.11,77.93 92.19,78.01 93.59,78.01 93.69,77.92 ; 218.54,78.01 217.14,78.01
  GND1 w0.203: H31.1 2.98,79.67 ; H31.1 2.98,76.55 ; H31.1 4.13,76.95 ; H31.1 4.13,79.27 ; H31.1 1.41,78.11 ; H31.1 1.82,79.27 ; H31.1 1.82,76.95 ; H31.1 4.54,78.11 ; JUSBC2.1 3.34,73.78 ; JUSBC2.1 0.45,73.78 ; JUSBC2.1 1.9,72.98 ; JUSBC2.1 3.34,74.58 ; JUSBC2.1 1.9,74.58 ; JUSBC2.1 0.45,72.98 ; JUSBC2.1 0.45,74.58 ; JUSBC2.1 3.34,72.98 ; JUSBC2.3 3.34,64.34 ; JUSBC2.3 3.34,65.14 ; JUSBC2.3 1.9,65.94 ; JUSBC2.3 1.9,64.34 ; JUSBC2.3 3.34,65.94 ; JUSBC2.3 0.45,65.94 ; JUSBC2.3 0.45,65.14 ; JUSBC2.3 0.45,64.34 ; 10.7,32.23 JHDMI1.11 ; JHDMI1.11 11.8,32.23 ; JHDMI1.11 10.81,32.67 ; JHDMI1.11 10.81,31.8 ; JHDMI1.11 11.69,31.8 ; JHDMI1.11 11.69,32.67 ; JHDMI1.17 11.69,34.8 ; JHDMI1.17 11.8,35.23 ; JHDMI1.17 11.69,35.67 ; JHDMI1.17 10.7,35.23 ; JHDMI1.17 10.81,35.67 ; JHDMI1.17 10.81,34.8 ; JUSBC1.6 7.04,49.17 ; JUSBC1.6 7.04,51.12 ; JUSBC1.6 5.65,49.17 ; JUSBC1.6 5.65,50.25 ; JUSBC1.6 5.65,51.12 ; JUSBC1.6 6.35,51.12 ; JUSBC1.6 6.35,49.17 ; JUSBC1.1 3.34,59.36 ; JUSBC1.1 0.45,57.76 ; JUSBC1.1 0.45,58.56 ; JUSBC1.1 1.9,57.76 ; JUSBC1.1 3.34,57.76 ; JUSBC1.1 0.45,59.36 ; JUSBC1.1 1.9,59.36 ; JUSBC1.1 3.34,58.56 ; JCR1.13 312.16,26.46 ; JCR1.13 309.95,27.86 ; JCR1.13 311.05,26.46 ; JCR1.13 312.16,27.86 ; JCR1.13 311.05,27.86 ; JCR1.13 312.16,27.16 ; JCR1.13 309.95,26.46 ; JCR1.13 309.95,27.16 ; 302.6,51.61 JUSB1.7 ; JUSB1.7 302.74,51.09 ; JUSB1.7 303.26,50.95 ; JUSB1.7 303.26,52.27 ; JUSB1.7 302.74,52.13 ; JUSB1.7 303.92,51.61 ; 10.72,19.04 H33.1 ; H33.1 13.03,19.04 ; H33.1 10.72,21.36 ; H33.1 13.03,21.36 ; H33.1 10.31,20.2 ; H33.1 11.88,18.64 ; H33.1 11.88,21.76 ; H33.1 13.44,20.2 ; JUSBC1.5 6.35,59.31 ; JUSBC1.5 7.04,59.31 ; JUSBC1.5 5.65,59.31 ; JUSBC1.5 5.65,57.36 ; JUSBC1.5 5.65,58.24 ; JUSBC1.5 6.35,57.36 ; JUSBC1.5 7.04,57.36 ; JHDMI1.22 4.75,41.44 ; JHDMI1.22 1.35,40.48 ; JHDMI1.22 3.05,41.44 ; JHDMI1.22 1.35,41.44 ; JHDMI1.22 4.75,40.48 ; JUSBC1.3 3.34,49.12 ; JUSBC1.3 0.45,49.92 ; JUSBC1.3 0.45,50.72 ; JUSBC1.3 1.9,50.72 ; JUSBC1.3 0.45,49.12 ; JUSBC1.3 1.9,49.12 ; JUSBC1.3 3.34,49.92 ; JUSBC1.3 3.34,50.72 ; 33.9,11.14 JBATT1.13 ; JBATT1.13 35.85,10.46 ; JBATT1.13 34.87,11.81 ; JBATT1.13 35.85,11.14 ; JBATT1.13 33.9,10.46 ; JBATT1.13 34.87,10.46 ; JBATT1.13 35.85,11.81 ; JBATT1.13 33.9,11.81 ; H6.1 245.7,29.22 ; H6.1 242.06,29.22 ; H6.1 242.06,32.86 ; H6.1 245.7,32.86 ; H6.1 243.88,33.54 ; H6.1 243.88,28.54 ; H6.1 241.37,31.04 ; H6.1 246.38,31.04 ; 10.09,38.98 JHDMI1.23 ; JHDMI1.23 10.09,38.03 ; JHDMI1.23 12.71,38.98 ; JHDMI1.23 10.09,39.94 ; JHDMI1.23 11.4,39.94 ; JHDMI1.23 12.71,38.03 ; JHDMI1.23 11.4,38.03 ; JHDMI1.23 12.71,39.94 ; JUSB1.10 310.22,58.71 ; JUSB1.10 307.7,60.21 ; JUSB1.10 310.22,59.46 ; JUSB1.10 307.7,59.46 ; JUSB1.10 308.96,58.71 ; JUSB1.10 310.22,60.21 ; JUSB1.10 308.96,60.21 ; 91.4,74.54 H36.1 ; H36.1 94.35,77.48 ; H36.1 94.88,76.01 ; H36.1 92.88,74 ; H36.1 91.4,77.48 ; H36.1 90.87,76.01 ; H36.1 94.35,74.54 ; 1.6,2.64 JUSB2.11 ; JUSB2.11 1.6,1.14 ; JUSB2.11 4.12,2.64 ; JUSB2.11 4.12,1.14 ; JUSB2.11 2.86,2.64 ; JUSB2.11 2.86,1.14 ; JUSB2.11 1.6,1.89 ; JUSB2.11 4.12,1.89 ; H34.1 245.64,75.25 ; H34.1 242.92,74.09 ; H34.1 245.23,76.41 ; H34.1 245.23,74.09 ; H34.1 242.51,75.25 ; H34.1 242.92,76.41 ; H34.1 244.08,73.69 ; H34.1 244.08,76.81 ; 311.65,43.76 JUSB1.12 ; JUSB1.12 312.91,43.01 ; JUSB1.12 311.65,44.51 ; JUSB1.12 314.17,44.51 ; JUSB1.12 312.91,44.51 ; JUSB1.12 314.17,43.01 ; JUSB1.12 311.65,43.01 ; JUSB1.12 314.17,43.76 ; 6.95,57.81 JUSBC1.2 ; JUSBC1.2 5.64,58.56 ; JUSBC1.2 8.25,59.31 ; JUSBC1.2 8.25,58.56 ; JUSBC1.2 5.64,59.31 ; JUSBC1.2 6.95,59.31 ; JUSBC1.2 8.25,57.81 ; 297.42,50.07 H30.1 ; H30.1 298.57,50.47 ; H30.1 298.57,47.35 ; H30.1 300.14,48.91 ; H30.1 299.73,47.75 ; H30.1 299.73,50.07 ; H30.1 297.42,47.75 ; H30.1 297.01,48.91 ; JBATT1.12 32.38,26.56 ; JBATT1.12 30.42,25.21 ; JBATT1.12 30.42,25.89 ; JBATT1.12 31.4,25.21 ; JBATT1.12 31.4,26.56 ; JBATT1.12 30.42,26.56 ; JBATT1.12 32.38,25.89 ; JBATT1.12 32.38,25.21 ; 203.27,21.75 H35.1 ; H35.1 205.58,21.75 ; H35.1 205.58,24.07 ; H35.1 204.43,24.47 ; H35.1 202.86,22.91 ; H35.1 205.99,22.91 ; H35.1 203.27,24.07 ; H35.1 204.43,21.35 ; JUSB2.7 13.03,9.22 ; JUSB2.7 11.85,9.74 ; JUSB2.7 13.03,10.26 ; JUSB2.7 12.51,10.4 ; JUSB2.7 12.51,9.08 ; JUSB2.7 13.17,9.74 ; JUSBC2.2 8.25,73.03 ; JUSBC2.2 6.95,74.53 ; JUSBC2.2 8.25,73.78 ; JUSBC2.2 5.64,73.78 ; JUSBC2.2 6.95,73.03 ; JUSBC2.2 5.64,74.53 ; JUSBC2.2 8.25,74.53 ; H5.1 266.89,72.24 ; H5.1 265.07,71.56 ; H5.1 268.71,67.92 ; H5.1 264.38,69.74 ; H5.1 268.71,71.56 ; H5.1 266.89,67.24 ; H5.1 265.07,67.92 ; H5.1 269.39,69.74 ; JHDMI1.20 12.71,25.44 ; JHDMI1.20 12.71,23.53 ; JHDMI1.20 11.4,23.53 ; JHDMI1.20 11.4,25.44 ; JHDMI1.20 12.71,24.48 ; JHDMI1.20 10.09,23.53 ; JHDMI1.20 10.09,25.44 ; JHDMI1.20 10.09,24.48 ; JUSBC2.6 7.04,64.39 ; JUSBC2.6 5.65,64.39 ; JUSBC2.6 5.65,65.46 ; JUSBC2.6 6.35,64.39 ; JUSBC2.6 5.65,66.34 ; JUSBC2.6 7.04,66.34 ; JUSBC2.6 6.35,66.34 ; JUSB2.12 4.12,16.84 ; JUSB2.12 1.6,16.84 ; JUSB2.12 1.6,18.34 ; JUSB2.12 2.86,16.84 ; JUSB2.12 1.6,17.59 ; JUSB2.12 4.12,17.59 ; JUSB2.12 4.12,18.34 ; JUSB2.12 2.86,18.34 ; 308.96,43.01 JUSB1.13 ; JUSB1.13 307.7,43.76 ; JUSB1.13 307.7,43.01 ; JUSB1.13 308.96,44.51 ; JUSB1.13 310.22,44.51 ; JUSB1.13 310.22,43.01 ; JUSB1.13 310.22,43.76 ; 300.54,27.16 JCR1.10 ; JCR1.10 301.65,26.46 ; JCR1.10 302.76,27.16 ; JCR1.10 300.54,27.86 ; JCR1.10 302.76,26.46 ; JCR1.10 301.65,27.86 ; JCR1.10 302.76,27.86 ; JCR1.10 300.54,26.46 ; H38.1 288.13,74.85 ; H38.1 286.98,74.45 ; H38.1 288.13,77.17 ; H38.1 285.82,74.85 ; H38.1 286.98,77.57 ; H38.1 288.54,76.01 ; H38.1 285.41,76.01 ; H38.1 285.82,77.17 ; 6.95,49.17 JUSBC1.4 ; JUSBC1.4 8.25,50.67 ; JUSBC1.4 5.64,49.17 ; JUSBC1.4 5.64,49.92 ; JUSBC1.4 6.95,50.67 ; JUSBC1.4 8.25,49.17 ; JUSBC1.4 8.25,49.92 ; H9.1 290.64,53.54 ; H9.1 288.82,52.86 ; H9.1 288.82,57.86 ; H9.1 287,57.18 ; H9.1 290.64,57.18 ; H9.1 291.32,55.36 ; H9.1 287,53.54 ; H9.1 286.31,55.36 ; 216.4,74.54 H37.1 ; H37.1 215.87,76.01 ; H37.1 217.88,74 ; H37.1 219.35,74.54 ; H37.1 219.35,77.48 ; H37.1 219.88,76.01 ; H37.1 216.4,77.48 ; JUSB2.4 11.71,7.4 ; JUSB2.4 12.37,6.74 ; JUSB2.4 11.71,6.08 ; 1.41,45.03 H32.1 ; H32.1 1.82,43.87 ; H32.1 4.13,46.19 ; H32.1 2.98,46.59 ; H32.1 4.13,43.87 ; H32.1 2.98,43.47 ; H32.1 1.82,46.19 ; H32.1 4.54,45.03 ; 311.65,60.21 JUSB1.11 ; JUSB1.11 314.17,59.46 ; JUSB1.11 311.65,59.46 ; JUSB1.11 314.17,58.71 ; JUSB1.11 312.91,60.21 ; JUSB1.11 311.65,58.71 ; JUSB1.11 312.91,58.71 ; JUSB1.11 314.17,60.21 ; 5.64,64.39 JUSBC2.4 ; JUSBC2.4 5.64,65.14 ; JUSBC2.4 8.25,64.39 ; JUSBC2.4 6.95,65.89 ; JUSBC2.4 6.95,64.39 ; JUSBC2.4 8.25,65.89 ; JUSBC2.4 8.25,65.14 ; 309.95,41.46 JCR1.12 ; JCR1.12 312.16,40.06 ; JCR1.12 311.05,40.06 ; JCR1.12 312.16,41.46 ; JCR1.12 312.16,40.76 ; JCR1.12 311.05,41.46 ; 300.54,40.06 JCR1.11 ; JCR1.11 301.65,41.46 ; JCR1.11 300.54,40.76 ; JCR1.11 302.76,40.76 ; JCR1.11 302.76,40.06 ; JCR1.11 300.54,41.46 ; JCR1.11 301.65,40.06 ; JCR1.11 302.76,41.46 ; JUSB1.4 304.06,55.27 ; JUSB1.4 303.4,54.61 ; JUSB1.4 304.06,53.95 ; JHDMI1.8 13.24,30.3 ; JHDMI1.8 12.36,30.3 ; JHDMI1.8 12.25,30.74 ; JHDMI1.8 13.35,30.74 ; JHDMI1.8 12.36,31.17 ; JHDMI1.8 13.24,31.17 ; JUSBC2.5 7.04,74.53 ; JUSBC2.5 6.35,72.58 ; JUSBC2.5 7.04,72.58 ; JUSBC2.5 5.65,73.46 ; JUSBC2.5 6.35,74.53 ; JUSBC2.5 5.65,74.53 ; JUSBC2.5 5.65,72.58 ; 1.35,22.03 JHDMI1.21 ; JHDMI1.21 1.35,22.98 ; JHDMI1.21 4.75,22.98 ; JHDMI1.21 4.75,22.03 ; JHDMI1.21 3.05,22.03 ; JUSB2.10 8.07,1.89 ; JUSB2.10 8.07,1.14 ; JUSB2.10 5.55,1.89 ; JUSB2.10 6.81,1.14 ; JUSB2.10 5.55,2.64 ; JUSB2.10 5.55,1.14 ; JUSB2.10 6.81,2.64 ; 5.55,18.34 JUSB2.13 ; JUSB2.13 6.81,16.84 ; JUSB2.13 5.55,17.59 ; JUSB2.13 8.07,18.34 ; JUSB2.13 5.55,16.84 ; JUSB2.13 8.07,17.59 ; JUSB2.13 6.81,18.34 ; JHDMI1.2 13.24,28.17 ; JHDMI1.2 12.25,27.74 ; JHDMI1.2 13.35,27.74 ; JHDMI1.2 13.24,27.3 ; JHDMI1.2 12.36,28.17 ; JHDMI1.2 12.36,27.3 ; JHDMI1.2 12.8,27.19 ; JBATT1.11 35.85,25.21 ; JBATT1.11 33.9,26.56 ; JBATT1.11 33.9,25.89 ; JBATT1.11 34.87,26.56 ; JBATT1.11 34.87,25.21 ; JBATT1.11 33.9,25.21 ; JBATT1.11 35.85,25.89 ; JBATT1.11 35.85,26.56 ; 31.4,10.46 JBATT1.14 ; JBATT1.14 30.42,11.14 ; JBATT1.14 31.4,11.81 ; JBATT1.14 30.42,11.81 ; JBATT1.14 32.38,11.14 ; JBATT1.14 32.38,11.81 ; JBATT1.14 30.42,10.46 ; JBATT1.14 32.38,10.46 ; JHDMI1.5 11.69,29.67 ; JHDMI1.5 10.7,29.23 ; JHDMI1.5 11.69,28.8 ; JHDMI1.5 10.81,28.8 ; JHDMI1.5 10.81,29.67 ; JHDMI1.5 11.8,29.23 ; 301.88,67.74 H10.1 ; H10.1 303.7,68.42 ; H10.1 300.06,68.42 ; H10.1 300.06,72.06 ; H10.1 304.38,70.24 ; H10.1 301.88,72.74 ; H10.1 299.37,70.24 ; H10.1 303.7,72.06
  IN1 w0.203: v5(93.47,25.87) v4(93.7,26.11) ; v4(67.63,50.99) 67.67,51 v2(67.88,51.26) ; v4(79.29,51.15) 79.1,50.95 v2(79.04,50.88) ; v5(69.97,26.23) v4(70.13,26.52) ; v4(62.18,23.37) 62.18,23.37 62.17,23.35 v5(62.17,23.03) ; v2(91.89,44.31) v4(92.08,44.04) v2(91.89,43.75) ; v2(91.88,47.68) v4(92.08,47.41) v2(91.88,47.12) ; v2(91.88,48.8) v4(92.08,48.53) v2(91.88,48.24) ; v4(12.85,51.63) v8(13.08,51.39) ; v4(80.22,51.15) 79.97,50.87 v2(79.97,50.87) ; v5(62.17,25.87) v4(62.17,25.54) ; v2(66.13,50.36) v4(66.36,50.6) ; v5(90.22,23.83) v4(89.9,24.23) v5(89.57,24.63) ; v4(12.56,51.92) v8(12.32,52.15) ; v5(90.87,26.23) v4(90.78,26.56) ; v2(86.4,46.54) v4(86.73,46.54) ; v2(89.47,44.66) v4(89.13,44.66) ; v5(64.12,23.03) v4(64.12,22.69) ; v2(64.16,47.13) 64.16,46.86 v4(64.25,46.77) ; v2(91.88,45.41) v4(92.08,45.14) v2(91.88,44.85) ; v5(92.17,25.87) v4(92.17,25.54) ; v5(60.87,25.87) v4(60.64,26.11) ; v2(89.45,46.51) v4(89.1,46.51) ; v2(91.91,45.98) v4(92.1,46.27) v2(91.91,46.54) ; v5(64.77,24.63) v4(64.44,24.23) v5(64.12,23.83) ; v5(94.77,51.38) v4(95,51.61) ; v2(91.88,43.2) v4(92.08,42.93) v2(91.88,42.64) ; v5(88.92,26.23) v4(88.6,26.63) ; v5(68.67,26.23) v4(68.78,26.55) ; v5(88.27,24.63) v4(88.6,24.23) ; v5(63.47,26.23) v4(63.56,26.56) ; v2(86.4,44.68) v4(86.74,44.68) ; v5(65.42,26.23) v4(65.74,26.63) ; v2(91.88,42.06) v4(92.22,42.06) ; v5(66.07,24.63) v4(65.74,24.23)
  IN1 w0.229: v5(69.32,21.43) v4(69.57,21.22) ; v5(84.37,21.43) v4(84.12,21.22) ; v4(20.1,51.21) v5(20.33,50.97) ; v5(92.82,21.43) v4(93.08,21.22) ; v4(78.57,34.98) 78.36,34.98 v8(78.24,35.11) ; v5(91.52,21.43) v4(91.78,21.65) ; v5(92.82,20.63) v4(93.08,20.42) ; v4(69.82,37.46) v8(69.59,37.69) ; v5(85.67,26.23) v4(85.56,26.55) ; v5(64.77,18.23) v4(64.98,18.49) ; v5(69.97,21.43) v4(70.22,21.22) ; v4(87.59,34.77) v8(87.59,34.44) ; v5(20.33,52.92) 20.17,53.08 v4(20.03,53.08) ; v5(85.67,19.03) v4(85.42,19.25) ; v2(64.12,19.83) v4(63.72,20.05) ; v5(66.72,21.43) v4(66.97,21.65) ; v5(86.32,19.83) v4(86.58,20.05) ; v5(90.22,21.43) v4(90.48,21.65) ; v5(90.87,21.43) v4(91.13,21.65) ; v5(64.12,21.43) v4(63.87,21.65) ; v2(93.47,19.83) v4(93.73,19.62) ; v5(84.37,18.23) v4(84.12,18.02) ; v2(87.62,19.83) v4(87.23,20.05) v5(86.97,19.83) ; v2(69.97,19.03) v4(69.57,19.25) ; v5(86.97,20.63) v4(86.72,20.85) ; v4(21.4,51.86) v5(21.63,51.62) ; v4(19.45,54.46) v5(19.68,54.22) ; v4(69.82,36.81) v8(69.63,37.07) ; v5(62.17,19.03) v4(61.92,19.25) ; v5(62.82,19.83) v4(62.57,20.05) ; v5(60.87,20.63) v4(60.62,20.85) ; v5(86.97,21.43) v4(86.72,21.65) ; v4(22.05,54.46) v5(22.28,54.22) ; v5(63.47,21.43) 63.27,21.6 v4(63.22,21.65) ; v5(85.02,20.63) v4(84.77,20.42) ; v5(65.42,19.83) v4(65.67,20.05) ; v2(64.12,19.03) v4(63.82,19.32) ; v5(68.02,20.63) v4(68.27,20.85) ; v4(81.23,36.16) v8(81.46,36.39) ; v5(62.82,21.43) v4(62.57,21.65) ; v5(93.47,20.63) v4(93.73,20.42) ; v4(22.7,51.39) v5(22.93,51.62) ; v4(91.15,33.46) 91.15,33.13 v8(91.15,33.13) ; v2(88.27,18.23) v4(88.36,17.91) ; v4(19.45,52.51) v5(19.68,52.27) ; v4(72.11,40.15) v5(71.88,39.92) ; v2(87.62,19.03) v4(87.35,19.47) ; v5(62.82,20.63) v4(62.57,20.85) ; v2(61.52,19.03) v4(61.27,19.25) ; v2(85.02,19.03) 84.78,18.83 v4(84.77,18.82) ; v5(61.52,20.63) v4(61.27,20.85) ; v5(86.32,21.43) v4(86.07,21.65) ; v5(92.17,19.03) v4(92.43,19.25) ; v4(63.22,20.85) 63.27,20.8 v5(63.47,20.63) ; v5(90.87,20.63) v4(91.27,20.85) ; v4(69.82,36.16) v8(69.63,36.42) ; v5(84.37,26.23) v4(84.14,26.47) ; v5(86.32,20.63) v4(86.07,20.85) ; v5(93.47,21.43) v4(93.73,21.22) ; v5(69.97,20.63) v4(70.22,20.42) ; v2(93.47,19.03) v4(93.08,19.25) ; v5(60.87,21.43) v4(60.62,21.65) ; v5(85.02,21.43) v4(84.77,21.22) ; v5(88.92,19.83) v4(88.67,20.05) ; v5(68.02,21.43) v4(68.27,21.65) ; v5(66.07,18.23) v4(66.21,18.53) ; v5(61.52,21.43) v4(61.27,21.65) ; v4(88.75,34.71) v8(88.75,35.04) ; v5(60.87,18.23) v4(60.62,18.45) ; v5(67.37,20.63) v4(67.62,20.85) ; v5(87.62,21.43) v4(87.37,21.65) ; v5(89.57,18.23) v4(89.83,18.02) ; v5(68.67,19.03) v4(68.92,19.25) ; v5(67.37,21.43) v4(67.62,21.65) ; v5(84.37,20.63) v4(84.12,20.42) ; v2(69.97,19.83) v4(70.22,19.62) ; v5(69.32,20.63) v4(69.57,20.42) ; v4(68.18,33.91) v8(68.18,33.57)
  IN1 w0.254: v4(86.7,37.46) v5(86.46,37.69) ; v2(41.47,12.6) 41.84,12.6 v4(41.92,12.52) 42,12.6 v2(42.36,12.6) ; v8(97.9,44) 97.9,44.21 v4(98.04,44.35) ; v4(76.05,34.69) v5(76.05,35.02) ; v4(72.56,38.11) v5(72.79,38.34) ; v8(85.57,53.46) 85.58,53.46 85.58,53.47 85.63,53.47 v4(85.83,53.66) ; v4(91.33,52.23) 91.12,52.01 v5(91.07,52.01) ; v4(68.91,39.23) v5(69.15,38.99) ; v4(66.55,43.02) v5(66.78,42.79) ; v2(281.68,72.24) v4(282.05,72.24) ; v4(10.11,68.06) 10.09,68.07 9.79,67.87 9.77,67.86 v2(9.77,67.85) ; v4(266.38,58.24) 266.39,58.24 v2(266.62,58.01) ; v2(69.5,43.55) 69.36,43.41 v4(69.36,43.15) 69.62,42.9 v8(69.62,42.9) ; v4(24,55.76) v5(24.23,55.52) ; v5(107.72,53.56) v4(108.05,53.51) ; v4(84.84,50.96) v2(84.94,50.5) ; v8(80.35,36.45) v4(80.35,36.78) ; v4(83.91,49.58) v5(83.68,49.81) ; v4(81.21,52.36) 81.56,52.36 v8(81.57,52.38) ; v4(67.1,50.6) v5(66.87,50.37) ; v8(100.39,49.14) 100.43,49.14 v4(100.69,49.4) 101.05,49.2 v5(101.06,49.16) 101.76,49.86 v4(101.76,49.93) ; v4(14.52,49.95) v8(14.76,49.72) ; v4(88.63,34.15) v5(88.63,33.82) ; v2(16.45,65.86) 16.45,66 v4(16.29,66.16) ; v4(73.47,38.76) v5(73.7,38.99) ; v4(82.14,38.11) v5(81.91,38.34) ; v4(264.7,55.62) 264.7,55.62 v2(265.04,55.62) ; v8(97.71,46.15) 97.95,46.15 v4(98.06,46.04) ; v4(64.83,54.04) v5(65.06,53.81) ; v2(96.95,41.37) v4(96.7,41.59) ; v5(70.26,39.97) v4(70.49,40.2) ; v4(103.89,43.51) v5(103.66,43.28) ; v4(85.09,34.79) v8(85.09,34.46) ; v2(42.48,31.39) v4(42.48,31.77) ; v2(9.78,51.51) v4(10.11,51.3) ; v2(94.87,40.36) 94.87,40.38 95.44,40.68 v4(95.45,40.68) ; v2(64.21,42.37) 64.21,42.78 v4(64.37,42.93) 64.59,42.71 v2(64.59,42.35) ; v5(99.76,49.16) v4(99.34,49.39) ; v4(14.18,51.98) v5(13.95,52.21) ; v4(72.56,36.16) v5(72.79,36.39) ; v4(67.24,52.43) v5(67,52.19) ; v2(265.02,59.61) 265.02,59.28 v4(265.07,59.23) ; v4(97.39,40.15) v5(97.16,39.92) ; v2(69.34,50.27) 69.73,50.27 v4(69.73,50.27) ; v4(106.67,44.51) v5(106.44,44.28) ; v2(69.49,46.34) 69.49,46.68 v4(69.38,46.79) ; v5(80.91,49.81) v4(81.14,49.58) ; v8(24.7,76.4) 24.71,76.4 24.81,76.3 v4(24.81,76.06) ; v4(75.29,36.81) v8(74.96,36.81) ; v4(65.48,44.91) v5(65.71,44.67) ; v4(25.3,50.09) v2(25.53,49.85) ; v4(72.56,38.76) v5(72.79,38.99) ; v4(12.84,68) v4(12.55,68.29) ; v4(14.74,51.42) v8(14.97,51.19) ; v4(95.81,37.28) v8(96.15,37.28) ; v4(25.3,54.46) v5(25.53,54.22) ; v4(91.25,38.11) v5(91.02,38.34) ; v4(14.28,68.83) 14.27,68.82 13.69,68.82 v2(13.68,68.81) ; v4(98.79,40.09) 98.69,40.09 98.52,39.92 v5(98.46,39.92) ; v4(24,52.69) v5(24.23,52.92) ; v4(94.93,54.63) v5(94.7,54.4) ; v4(69.82,38.76) v5(70.06,38.99) ; v5(104.49,41.16) 104.54,41.21 v4(104.54,41.5) ; v2(79.89,53.23) 80.16,53.5 v4(80.37,53.5) ; v4(87.61,38.11) v5(87.37,38.34) ; v4(28.99,76.93) 28.58,76.93 v8(28.58,76.94) ; v4(79.29,51.15) v5(79.06,51.38) ; v4(73.3,34.79) v5(73.53,35.02) ; v4(67.1,39.25) v8(66.77,39.25) ; v4(91.3,51.61) v5(91.07,51.38) ; v4(86.79,29.52) 86.74,29.48 86.74,29.07 v2(86.71,29.03) ; v5(77.31,33.07) v4(77.31,32.74) ; v5(78.57,33.82) 78.57,34.09 v4(78.63,34.15) ; v8(81.46,37.69) v4(81.23,37.46) ; v4(103.74,34.69) v5(103.74,35.02) ; v2(16.36,14.53) 16.66,14.84 v4(16.66,14.94) ; v2(26.16,53.54) 25.95,53.75 v4(25.95,53.81) ; v4(67.24,51.3) v5(67,51.06) ; v4(76.67,36.81) v8(76.91,36.58) ; v4(84.87,37.46) v5(84.64,37.69) ; v4(24,52.04) v5(24.23,52.27) ; v4(70.67,54.4) v5(70.29,54.4) ; v5(89.22,49.81) 89.22,49.56 v4(89.09,49.43) ; v5(93.84,51.38) 93.88,51.38 94.04,51.54 v4(94.04,51.66) ; v4(10.26,56.92) 9.98,56.92 v2(9.78,56.72) ; v4(95.91,51.64) 95.69,51.42 v5(95.69,51.38) ; v4(70.06,52.91) v5(69.82,52.68) ; v4(98.69,46.87) v5(98.46,46.64) ; v4(108.11,32.44) 107.93,32.62 v5(107.93,32.75) ; v4(86.84,49.75) 86.75,49.84 v5(86.45,49.84) ; v4(20.1,55.76) 19.8,55.45 v2(19.77,55.45) ; v4(84.64,39.59) 84.87,39.82 v2(84.89,39.82) ; v4(101.29,44.35) v5(101.06,44.12) ; v4(101.94,46.87) v5(101.71,46.64) ; v2(17.8,67.27) 17.47,67.27 v4(17.47,67.26) ; v4(70.52,50.04) v5(70.28,50.27) ; v4(105.16,51.61) v5(104.93,51.38) ; v4(70.06,52.26) v5(69.82,52.03) ; v4(65.92,53.16) v5(65.67,52.91) ; v5(99.96,35.02) 100.16,34.82 v4(100.16,34.69) ; v4(75.4,53.62) v5(75.17,53.39) ; v4(95.38,41.3) 95.32,41.36 v2(95.05,41.39) ; v4(104.86,47.35) 104.81,47.31 104.53,47.31 v8(104.5,47.33) ; v4(89.43,38.58) v5(89.2,38.34) ; v4(17.49,65.35) 17.49,65.35 v2(17.49,64.98) ; v4(104.93,38.11) v5(104.69,38.34) ; v4(101.94,42.67) v5(101.71,42.44) ; v4(103.24,43.51) v5(103.01,43.28) ; v4(83.05,37.46) v5(82.82,37.69) ; v4(101.47,52.91) v8(101.7,52.68) ; v4(100.73,38.02) v5(101.05,38.34) ; v4(82.73,53.62) 82.52,53.41 v8(82.46,53.41) ; v4(66.68,52.84) v5(67.01,52.84) ; v4(98.94,34.79) v5(98.7,35.02) ; v4(86.31,53.6) 86.49,53.43 v5(86.72,53.43) ; v5(74.79,33.07) v4(74.79,32.74) ; v4(65.29,32.51) v8(64.96,32.51) ; v4(22.05,52.04) v2(22.28,51.8) ; v5(73.52,51.38) 73.65,51.38 v4(73.82,51.55) ; v4(101.29,46.87) v5(101.06,46.64) ; v8(77.31,34.55) v4(77.54,34.79) ; v2(87.41,39.82) v4(87.04,39.92) ; v5(69.61,40.88) v4(69.84,41.11) ; v4(24,50.74) 24.26,51 v2(24.26,51.01) ; v8(65.45,33.28) v4(65.45,33.61) ; v4(65.15,50.37) v5(65.48,50.37) ; v4(89.75,39.97) 89.86,39.87 v2(90.08,39.87) ; v4(74.14,37.15) 74.5,37.15 v5(74.62,37.04) ; v4(72.56,36.81) v5(72.79,37.04) ; v4(67.43,44.91) v5(67.66,44.67) ; v4(20.75,48.14) v2(20.98,47.9) ; v4(107.29,53.53) 106.84,53.31 v2(106.82,53.32) ; v4(299.95,58.19) 300.17,58.19 v2(300.28,58.09) ; v5(80.08,39.92) 79.65,39.92 v4(79.63,39.9) ; v8(97.15,48.26) 97.15,48.3 v4(97.39,48.55) ; v4(74.68,51.63) 74.66,51.63 74.4,51.37 v2(74.4,51.34) ; v4(19.45,55.11) v5(19.68,54.87) ; v5(68.67,23.03) v4(68.43,23.27) ; v4(84.19,39.93) 84.14,39.95 v2(83.83,39.78) ; v4(23.35,52.69) v5(23.58,52.92) ; v4(21.4,48.14) v2(21.63,47.9) ; v4(78.37,49.58) v5(78.14,49.81) ; v4(65.25,43.02) v5(65.48,42.79) ; v4(84.87,38.11) v5(84.64,38.34) ; v4(22.7,55.76) v5(22.93,55.52) ; v8(87.37,50.72) v4(87.61,50.96) ; v2(28.1,66.29) 28.17,66.29 v4(28.37,66.5) ; v5(79.63,40.38) v4(79.86,40.62) ; v4(95.81,36.63) v8(96.05,36.86) ; v4(83.96,38.11) v5(83.73,38.34) ; v8(95.16,34.46) v4(95.16,34.79) ; v4(22.05,50.74) v5(22.28,50.97) ; v8(84.93,53.88) 85.03,53.88 85.12,53.79 v4(85.28,53.79) ; v8(68.5,32.51) v4(68.5,32.84) ; v4(69.38,48.68) v5(69.61,48.44) ; v2(9.78,66.73) v4(10.11,66.52) ; v8(75.53,39.65) v4(75.53,39.32) ; v4(79.41,39.23) v8(79.64,39.46) ; v8(67.13,34.33) v4(67.13,34) ; v4(81.44,39.94) 81.46,39.96 81.79,39.94 v2(81.85,39.89) ; v4(86.7,35.51) v8(86.7,35.18) ; v4(101.29,42.67) v5(101.06,42.44) ; v4(74.84,39.22) v5(75.07,39.46) ; v4(65.48,48.68) v5(65.71,48.44) ; v11(90.47,53.43) 90.3,53.43 v4(90.09,53.64) ; v4(78.35,39.32) 78.49,39.46 v8(78.73,39.46) ; v8(72.74,53.38) 72.74,53.51 72.59,53.67 v4(72.59,53.69) ; v4(76.67,39.23) v8(76.91,39.46) ; v4(81.69,41.29) 81.67,41.29 v2(81.44,41.52) ; v4(13.97,50.51) v5(13.73,50.74) ; v4(104.72,44.51) v5(104.49,44.28) ; v8(82.91,35.21) v4(83.05,35.51) ; v8(73.53,32.98) v4(73.53,33.31) ; v8(65.74,46.55) 65.72,46.55 v4(65.48,46.79) 65.48,46.83 v2(65.79,47.15) ; v2(103.99,51.38) v4(104.24,51.61) ; v4(94.46,54.82) v5(94.7,55.05) ; v4(75.45,54.12) v5(75.17,54.4) ; v4(20.75,55.11) v5(20.98,54.87) ; v4(97.39,44.35) v5(97.16,44.12) ; v2(67.58,29.1) 67.58,28.78 v4(67.57,28.76) ; v8(99.45,41.51) 99.34,41.62 v4(99.34,41.83) ; v4(71.91,52.25) 71.69,52.03 v5(71.67,52.03) ; v2(22.54,75.33) 22.54,75.42 v4(22.91,75.78) ; v4(23.77,71.06) 23.68,71.16 v2(23.38,71.16) ; v4(93.47,18.58) 93.47,18.58 v5(93.47,18.23) ; v4(95.81,35.98) v8(96.05,36.21) ; v4(88.52,36.81) v8(88.75,37.04) ; v4(100.64,46.87) v5(100.41,46.64) ; v4(81.68,40.62) 81.49,40.43 v2(81.32,40.43) ; v5(82.34,33.07) v4(82.34,32.74) ; v4(92.49,53.62) v5(92.26,53.39) ; v5(81,38.34) v4(81.23,38.11) ; v4(80.29,54.63) v5(80.05,54.4) ; v8(73.42,53.85) 73.2,54.07 v4(72.83,54.07) ; v4(22.05,48.14) v2(22.28,48.42) ; v4(84.87,36.81) v8(85.11,37.04) ; v2(68.33,42.92) 68.3,42.92 v4(68.08,43.15) ; v4(90.38,50.96) 90.37,50.95 v2(90.1,50.54) ; v5(70.26,40.88) v4(70.49,41.11) ; v2(98.26,42.97) v4(98.04,42.67) ; v4(64.37,49.31) 64.38,49.32 v2(64.38,49.66) ; v8(93.9,34.46) v4(93.9,34.79) ; v4(22.05,49.44) v5(22.28,49.67) ; v2(87.98,53.31) v4(88.27,53.66) ; v8(81.46,37.04) v4(81.23,36.81) ; v2(101.03,44.94) v4(101.29,45.19) ; v4(25.3,53.81) v5(25.53,53.57) ; v4(72.56,37.46) v5(72.79,37.69) ; v4(71.65,38.76) v5(71.88,38.99) ; v4(65.9,43.02) v5(66.13,42.79) ; v4(73.47,36.81) v5(73.7,37.04) ; v4(44.77,22.26) 44.62,22.1 v2(44.37,22.1) ; v2(9.78,70.84) v4(10.11,70.63) ; v4(103.1,36.16) v8(102.86,36.41) ; v4(67.64,54.11) 67.64,54.19 v5(67.85,54.4) ; v2(9.78,71.94) 10.12,72.16 v4(10.21,72.14) ; v4(77.58,39.23) v8(77.82,39.46) ; v4(83.05,38.11) v5(82.82,38.34) ; v2(77.02,51.29) 77.43,51.62 v4(77.45,51.61) ; v4(75.13,49.58) v5(75.37,49.81) ; v2(87.98,52.67) 87.98,52.67 v4(87.65,52.31) v5(87.37,52.03) ; v4(68,38.76) v5(68.24,38.99) ; v2(96.3,43.96) 96.67,44.33 v4(96.67,44.34) ; v4(95.13,49.84) 95.1,49.81 v5(94.77,49.81) ; v4(90.34,37.46) v5(90.11,37.69) ; v4(102.59,44.35) v5(102.36,44.12) ; v4(107.97,45.56) v5(107.74,45.32) ; v2(76.36,51.29) 76.36,51.32 76.62,51.59 v4(76.62,51.65) ; v4(22.05,48.79) v5(22.28,49.02) ; v5(89.22,52.03) 89.36,52.17 v4(89.53,52.17) ; v4(71.01,34.69) v8(71.01,34.36) ; v4(80.08,39.37) v5(80.08,38.99) ; v8(82.57,34.46) v4(82.57,34.79) ; v4(89.39,53.66) v5(89.16,53.43) ; v4(92.17,38.11) v5(91.93,38.34) ; v2(9.78,52.61) v4(10.11,52.82) ; v8(92.64,34.46) v4(92.64,34.79) ; v4(68.18,53.99) v5(67.94,53.75) ; v4(92.17,36.16) v8(92.4,36.39) ; v4(102.39,51.61) v5(102.16,51.38) ; v4(77.38,54.16) v5(77.61,54.4) ; v4(78.37,52.91) v5(78.14,52.68) ; v2(22.38,50.37) 22.7,50.7 v4(22.7,50.74) ; v4(69.38,44.91) v5(69.61,44.67) ; v4(72.51,34.79) v8(72.51,34.46) ; v4(23.35,55.76) v5(23.58,55.52) ; v8(67.69,46.53) 67.68,46.53 v4(67.43,46.79) 67.43,46.91 v2(67.67,47.15) ; v4(21.4,50.56) v2(21.17,50.32) ; v4(103.89,48.55) v5(103.66,48.32) ; v2(70.74,52.03) v4(70.98,52.26) ; v4(99.34,43.51) v5(99.11,43.28) ; v4(93.9,33.58) v5(93.67,33.82) ; v4(101.29,40.15) v5(101.06,39.92) ; v8(11.02,50.64) 11.44,50.22 v4(11.52,50.22) ; v4(84.87,36.16) v8(85.11,36.39) ; v4(67.11,40.27) v5(66.78,40.27) ; v4(99.34,46.03) v5(99.11,45.8) ; v4(102.59,43.51) v5(102.36,43.28) ; v4(72.83,49.58) v5(72.59,49.81) ; v4(103.24,47.71) v5(103.01,47.48) ; v4(70.74,38.76) v5(70.97,38.99) ; v4(80.22,51.15) v5(79.98,51.38) ; v5(91.99,50.73) v4(92.23,50.96) ; v2(9.78,55.62) v4(10.11,55.41) ; v4(98.69,46.03) v5(98.46,45.8) ; v4(70.52,53.62) v5(70.29,53.39) ; v4(88.52,37.46) v5(88.29,37.69) ; v4(77.58,36.81) v8(77.82,36.58) ; v2(97.01,42.18) v4(96.68,42.18) ; v4(92.17,36.81) v8(92.4,37.04) ; v4(82.99,51.61) v5(82.76,51.38) ; v4(90.13,34.79) v5(89.89,35.02) ; v2(51.45,24.77) v4(51.08,24.77) ; v4(67.43,48.68) v5(67.66,48.44) ; v4(70.03,42.24) v5(70.26,42) ; v4(103.89,47.71) v5(103.66,47.48) ; v4(67.43,43.15) v5(67.66,42.91) ; v2(281.81,76.1) v4(282.17,76.1) ; v4(68.73,43.15) v5(68.96,42.91) ; v4(102.59,45.19) v5(102.36,44.96) ; v4(88.52,38.11) v5(88.29,38.34) ; v4(67.89,41.11) v8(68.13,41.35) ; v4(92.23,49.58) v8(91.9,49.58) ; v4(75.6,51.61) v5(75.37,51.38) ; v4(82.07,51.61) v5(81.83,51.38) ; v4(86.7,38.11) v5(86.46,38.34) ; v4(85.79,38.11) v5(85.55,38.34) ; v2(97.01,43.07) v4(96.67,43.07) ; v4(69.82,38.11) v5(70.06,38.34) ; v4(92.17,37.46) v5(91.93,37.69) ; v4(97.39,46.87) v5(97.16,46.64) ; v2(65.43,51.65) v4(65.15,51.86) ; v2(68.89,50.71) v4(68.82,50.27) 68.81,50.28 v2(68.43,50.28) ; v4(97.14,54.73) v8(97.14,55.06) ; v5(83.6,33.82) v4(83.6,34.15) ; v8(80.06,32.51) v4(80.06,32.84) ; v4(23.35,52.04) v5(23.58,52.27) ; v4(70.03,43.15) v5(70.26,42.91) ; v4(24,54.46) v5(24.23,54.22)
  IN1 w0.305: v8(88.75,36.39) v4(88.52,36.16)
  IN1 w0.356: v4(83.29,14.83) 83.31,14.85 v2(83.68,14.85) ; v2(93.83,13.95) 93.89,14.01 v4(94.19,14.01) ; v2(91.62,14.02) v4(92.09,14.02) ; v2(297.57,33.93) v4(297.91,33.93) ; v2(298.42,34.38) 298.59,34.22 298.9,34.22 v4(298.9,34.22) v2(299.31,34.22) ; v2(305.79,25.37) 305.71,25.37 v4(305.5,25.58) ; v2(89.48,14.05) 89.88,14.05 v4(89.91,14.01) ; v2(304.52,25.55) v4(304.92,25.55)
  IN1 w0.381: v2(59.48,14.84) v4(59.88,14.84) ; v2(28.01,77.85) 28.01,77.84 27.66,77.84 v4(27.65,77.84) ; v4(72.44,23.14) 72.44,23.11 v2(72.2,22.87) ; v4(78.39,14.09) 78.63,14.09 78.89,13.83 v2(78.89,13.8) ; v2(63.95,14.84) 63.95,14.63 64.15,14.43 v4(64.18,14.43) 64.35,14.27 v2(65.11,14.27) ; v2(81.51,21.35) v4(81.25,21.61) ; v2(60.84,14.27) 60.97,14.4 v4(60.97,14.83) ; v2(88.15,14.84) v4(87.79,14.84) ; v2(15.89,68.51) 15.72,68.51 v4(15.54,68.69) ; v4(258.22,60.53) 258.22,60.53 v2(258.63,60.53) ; v2(26.81,77.87) v4(27.15,77.87)
  IN1 w0.508: v4(26.41,12.33) 26.14,12.07 v2(25.88,12.07) ; v2(73.1,27.35) 73.14,27.39 v4(73.14,27.69) ; v4(25.6,13.09) 25.81,12.88 v2(26,12.88) ; v2(26.77,11.15) v4(27.3,11.15) ; v2(81.24,70.99) v4(81.68,70.99) ; v2(76.55,14.05) 76.52,14.09 v4(76.17,14.09) ; v4(78.39,14.09) 77.98,14.09 v2(77.95,14.05)
  GND2 w0.089: 218.54,78.01 217.14,78.01
  GND2 w0.203: 5.55,18.34 JUSB2.13 ; JUSB2.13 8.07,18.34 ; JUSB2.13 6.81,16.84 ; JUSB2.13 6.81,18.34 ; JUSB2.13 8.07,17.59 ; JUSB2.13 5.55,17.59 ; JUSB2.13 5.55,16.84 ; H32.1 4.54,45.03 ; H32.1 1.41,45.03 ; H32.1 1.82,43.87 ; H32.1 2.98,46.59 ; H32.1 4.13,46.19 ; H32.1 1.82,46.19 ; H32.1 4.13,43.87 ; H32.1 2.98,43.47 ; 10.81,28.8 JHDMI1.5 ; JHDMI1.5 10.7,29.23 ; JHDMI1.5 10.81,29.67 ; JHDMI1.5 11.69,28.8 ; JHDMI1.5 11.8,29.23 ; JHDMI1.5 11.69,29.67 ; 0.45,65.94 JUSBC2.3 ; JUSBC2.3 1.9,65.94 ; JUSBC2.3 3.34,65.94 ; JUSBC2.3 1.9,64.34 ; JUSBC2.3 0.45,65.14 ; JUSBC2.3 0.45,64.34 ; JUSBC2.3 3.34,65.14 ; JUSBC2.3 3.34,64.34 ; H34.1 245.23,76.41 ; H34.1 242.92,76.41 ; H34.1 244.08,73.69 ; H34.1 242.92,74.09 ; H34.1 242.51,75.25 ; H34.1 244.08,76.81 ; H34.1 245.23,74.09 ; H34.1 245.64,75.25 ; JCR1.11 301.65,41.46 ; JCR1.11 300.54,41.46 ; JCR1.11 302.76,40.06 ; JCR1.11 300.54,40.06 ; JCR1.11 301.65,40.06 ; JCR1.11 302.76,41.46 ; JCR1.11 302.76,40.76 ; JCR1.11 300.54,40.76 ; JUSB2.10 8.07,1.14 ; JUSB2.10 8.07,1.89 ; JUSB2.10 5.55,1.89 ; JUSB2.10 5.55,2.64 ; JUSB2.10 6.81,2.64 ; JUSB2.10 5.55,1.14 ; JUSB2.10 6.81,1.14 ; JUSBC2.5 7.04,74.53 ; JUSBC2.5 5.65,74.53 ; JUSBC2.5 5.65,72.58 ; JUSBC2.5 5.65,73.46 ; JUSBC2.5 7.04,72.58 ; JUSBC2.5 6.35,74.53 ; JUSBC2.5 6.35,72.58 ; 5.65,64.39 JUSBC2.6 ; JUSBC2.6 5.65,66.34 ; JUSBC2.6 7.04,64.39 ; JUSBC2.6 6.35,64.39 ; JUSBC2.6 7.04,66.34 ; JUSBC2.6 6.35,66.34 ; JUSBC2.6 5.65,65.46 ; 2.86,16.84 JUSB2.12 ; JUSB2.12 2.86,18.34 ; JUSB2.12 1.6,17.59 ; JUSB2.12 4.12,16.84 ; JUSB2.12 1.6,16.84 ; JUSB2.12 4.12,17.59 ; JUSB2.12 1.6,18.34 ; JUSB2.12 4.12,18.34 ; JHDMI1.17 11.8,35.23 ; JHDMI1.17 11.69,34.8 ; JHDMI1.17 10.81,35.67 ; JHDMI1.17 10.7,35.23 ; JHDMI1.17 10.81,34.8 ; JHDMI1.17 11.69,35.67 ; 215.87,76.01 H37.1 ; H37.1 217.88,74 ; H37.1 219.88,76.01 ; H37.1 216.4,77.48 ; H37.1 219.35,74.54 ; H37.1 219.35,77.48 ; H37.1 216.4,74.54 ; JUSBC2.2 8.25,73.03 ; JUSBC2.2 8.25,73.78 ; JUSBC2.2 8.25,74.53 ; JUSBC2.2 6.95,73.03 ; JUSBC2.2 5.64,74.53 ; JUSBC2.2 6.95,74.53 ; JUSBC2.2 5.64,73.78 ; 303.26,50.95 JUSB1.7 ; JUSB1.7 302.74,52.13 ; JUSB1.7 302.74,51.09 ; JUSB1.7 303.92,51.61 ; JUSB1.7 303.26,52.27 ; JUSB1.7 302.6,51.61 ; 301.65,26.46 JCR1.10 ; JCR1.10 302.76,27.16 ; JCR1.10 300.54,27.16 ; JCR1.10 300.54,27.86 ; JCR1.10 302.76,26.46 ; JCR1.10 300.54,26.46 ; JCR1.10 302.76,27.86 ; JCR1.10 301.65,27.86 ; H38.1 288.13,77.17 ; H38.1 286.98,77.57 ; H38.1 286.98,74.45 ; H38.1 288.13,74.85 ; H38.1 288.54,76.01 ; H38.1 285.82,77.17 ; H38.1 285.41,76.01 ; H38.1 285.82,74.85 ; JUSB1.11 312.91,60.21 ; JUSB1.11 311.65,58.71 ; JUSB1.11 314.17,58.71 ; JUSB1.11 311.65,60.21 ; JUSB1.11 314.17,59.46 ; JUSB1.11 314.17,60.21 ; JUSB1.11 311.65,59.46 ; JUSB1.11 312.91,58.71 ; 312.91,43.01 JUSB1.12 ; JUSB1.12 311.65,43.01 ; JUSB1.12 314.17,43.01 ; JUSB1.12 311.65,43.76 ; JUSB1.12 314.17,44.51 ; JUSB1.12 314.17,43.76 ; JUSB1.12 311.65,44.51 ; JUSB1.12 312.91,44.51 ; 1.82,79.27 H31.1 ; H31.1 4.54,78.11 ; H31.1 1.82,76.95 ; H31.1 2.98,79.67 ; H31.1 2.98,76.55 ; H31.1 4.13,79.27 ; H31.1 4.13,76.95 ; H31.1 1.41,78.11 ; JUSB2.11 4.12,1.14 ; JUSB2.11 1.6,2.64 ; JUSB2.11 2.86,2.64 ; JUSB2.11 1.6,1.14 ; JUSB2.11 4.12,2.64 ; JUSB2.11 4.12,1.89 ; JUSB2.11 2.86,1.14 ; JUSB2.11 1.6,1.89 ; 304.06,53.95 JUSB1.4 ; JUSB1.4 303.4,54.61 ; JUSB1.4 304.06,55.27 ; 10.09,38.03 JHDMI1.23 ; JHDMI1.23 11.4,39.94 ; JHDMI1.23 11.4,38.03 ; JHDMI1.23 12.71,39.94 ; JHDMI1.23 10.09,38.98 ; JHDMI1.23 12.71,38.03 ; JHDMI1.23 12.71,38.98 ; JHDMI1.23 10.09,39.94 ; 12.8,27.19 JHDMI1.2 ; JHDMI1.2 13.24,28.17 ; JHDMI1.2 13.35,27.74 ; JHDMI1.2 12.36,28.17 ; JHDMI1.2 12.25,27.74 ; JHDMI1.2 12.36,27.3 ; JHDMI1.2 13.24,27.3 ; H10.1 301.88,72.74 ; H10.1 300.06,72.06 ; H10.1 303.7,68.42 ; H10.1 301.88,67.74 ; H10.1 299.37,70.24 ; H10.1 304.38,70.24 ; H10.1 303.7,72.06 ; H10.1 300.06,68.42 ; 311.05,40.06 JCR1.12 ; JCR1.12 312.16,40.06 ; JCR1.12 312.16,40.76 ; JCR1.12 309.95,41.46 ; JCR1.12 312.16,41.46 ; JCR1.12 311.05,41.46 ; 33.9,25.21 JBATT1.11 ; JBATT1.11 33.9,25.89 ; JBATT1.11 34.87,26.56 ; JBATT1.11 35.85,26.56 ; JBATT1.11 33.9,26.56 ; JBATT1.11 35.85,25.21 ; JBATT1.11 34.87,25.21 ; JBATT1.11 35.85,25.89 ; 5.65,59.31 JUSBC1.5 ; JUSBC1.5 6.35,57.36 ; JUSBC1.5 7.04,57.36 ; JUSBC1.5 5.65,57.36 ; JUSBC1.5 7.04,59.31 ; JUSBC1.5 5.65,58.24 ; JUSBC1.5 6.35,59.31 ; 307.7,43.01 JUSB1.13 ; JUSB1.13 308.96,43.01 ; JUSB1.13 308.96,44.51 ; JUSB1.13 310.22,44.51 ; JUSB1.13 310.22,43.76 ; JUSB1.13 310.22,43.01 ; JUSB1.13 307.7,43.76 ; 286.31,55.36 H9.1 ; H9.1 287,53.54 ; H9.1 290.64,53.54 ; H9.1 288.82,52.86 ; H9.1 291.32,55.36 ; H9.1 290.64,57.18 ; H9.1 287,57.18 ; H9.1 288.82,57.86 ; H30.1 298.57,50.47 ; H30.1 299.73,47.75 ; H30.1 297.01,48.91 ; H30.1 297.42,47.75 ; H30.1 297.42,50.07 ; H30.1 298.57,47.35 ; H30.1 299.73,50.07 ; H30.1 300.14,48.91 ; 202.86,22.91 H35.1 ; H35.1 205.58,24.07 ; H35.1 204.43,24.47 ; H35.1 204.43,21.35 ; H35.1 203.27,24.07 ; H35.1 203.27,21.75 ; H35.1 205.99,22.91 ; H35.1 205.58,21.75 ; JCR1.13 312.16,27.86 ; JCR1.13 309.95,27.16 ; JCR1.13 311.05,26.46 ; JCR1.13 309.95,27.86 ; JCR1.13 311.05,27.86 ; JCR1.13 312.16,27.16 ; JCR1.13 312.16,26.46 ; JCR1.13 309.95,26.46 ; JUSB2.4 12.37,6.74 ; JUSB2.4 11.71,7.4 ; JUSB2.4 11.71,6.08 ; JHDMI1.20 11.4,25.44 ; JHDMI1.20 10.09,24.48 ; JHDMI1.20 11.4,23.53 ; JHDMI1.20 10.09,23.53 ; JHDMI1.20 12.71,23.53 ; JHDMI1.20 12.71,24.48 ; JHDMI1.20 12.71,25.44 ; JHDMI1.20 10.09,25.44 ; 308.96,58.71 JUSB1.10 ; JUSB1.10 307.7,60.21 ; JUSB1.10 310.22,58.71 ; JUSB1.10 310.22,60.21 ; JUSB1.10 310.22,59.46 ; JUSB1.10 307.7,59.46 ; JUSB1.10 308.96,60.21 ; JUSB2.7 13.03,9.22 ; JUSB2.7 12.51,10.4 ; JUSB2.7 13.03,10.26 ; JUSB2.7 12.51,9.08 ; JUSB2.7 13.17,9.74 ; JUSB2.7 11.85,9.74 ; 92.88,74 H36.1 ; H36.1 94.88,76.01 ; H36.1 90.87,76.01 ; H36.1 91.4,77.48 ; H36.1 94.35,74.54 ; H36.1 94.35,77.48 ; H36.1 91.4,74.54 ; 5.64,65.14 JUSBC2.4 ; JUSBC2.4 5.64,64.39 ; JUSBC2.4 8.25,65.89 ; JUSBC2.4 6.95,65.89 ; JUSBC2.4 8.25,65.14 ; JUSBC2.4 6.95,64.39 ; JUSBC2.4 8.25,64.39 ; JUSBC2.1 3.34,74.58 ; JUSBC2.1 1.9,72.98 ; JUSBC2.1 3.34,73.78 ; JUSBC2.1 0.45,73.78 ; JUSBC2.1 3.34,72.98 ; JUSBC2.1 1.9,74.58 ; JUSBC2.1 0.45,72.98 ; JUSBC2.1 0.45,74.58 ; JBATT1.14 31.4,11.81 ; JBATT1.14 30.42,11.14 ; JBATT1.14 31.4,10.46 ; JBATT1.14 30.42,10.46 ; JBATT1.14 32.38,10.46 ; JBATT1.14 32.38,11.81 ; JBATT1.14 32.38,11.14 ; JBATT1.14 30.42,11.81 ; JHDMI1.8 13.35,30.74 ; JHDMI1.8 12.25,30.74 ; JHDMI1.8 13.24,31.17 ; JHDMI1.8 13.24,30.3 ; JHDMI1.8 12.36,31.17 ; JHDMI1.8 12.36,30.3 ; JHDMI1.22 4.75,40.48 ; JHDMI1.22 3.05,41.44 ; JHDMI1.22 1.35,40.48 ; JHDMI1.22 4.75,41.44 ; JHDMI1.22 1.35,41.44 ; JUSBC1.3 3.34,50.72 ; JUSBC1.3 3.34,49.92 ; JUSBC1.3 0.45,50.72 ; JUSBC1.3 0.45,49.92 ; JUSBC1.3 0.45,49.12 ; JUSBC1.3 3.34,49.12 ; JUSBC1.3 1.9,50.72 ; JUSBC1.3 1.9,49.12 ; 243.88,28.54 H6.1 ; H6.1 242.06,32.86 ; H6.1 241.37,31.04 ; H6.1 245.7,32.86 ; H6.1 245.7,29.22 ; H6.1 243.88,33.54 ; H6.1 242.06,29.22 ; H6.1 246.38,31.04 ; 31.4,25.21 JBATT1.12 ; JBATT1.12 32.38,25.21 ; JBATT1.12 30.42,25.89 ; JBATT1.12 32.38,26.56 ; JBATT1.12 31.4,26.56 ; JBATT1.12 32.38,25.89 ; JBATT1.12 30.42,25.21 ; JBATT1.12 30.42,26.56 ; 5.64,59.31 JUSBC1.2 ; JUSBC1.2 5.64,58.56 ; JUSBC1.2 8.25,59.31 ; JUSBC1.2 6.95,57.81 ; JUSBC1.2 8.25,58.56 ; JUSBC1.2 8.25,57.81 ; JUSBC1.2 6.95,59.31 ; 0.45,57.76 JUSBC1.1 ; JUSBC1.1 0.45,59.36 ; JUSBC1.1 3.34,57.76 ; JUSBC1.1 3.34,59.36 ; JUSBC1.1 0.45,58.56 ; JUSBC1.1 1.9,57.76 ; JUSBC1.1 1.9,59.36 ; JUSBC1.1 3.34,58.56 ; JHDMI1.21 4.75,22.03 ; JHDMI1.21 4.75,22.98 ; JHDMI1.21 1.35,22.98 ; JHDMI1.21 3.05,22.03 ; JHDMI1.21 1.35,22.03 ; H5.1 268.71,71.56 ; H5.1 264.38,69.74 ; H5.1 265.07,71.56 ; H5.1 269.39,69.74 ; H5.1 266.89,72.24 ; H5.1 265.07,67.92 ; H5.1 268.71,67.92 ; H5.1 266.89,67.24 ; H33.1 13.44,20.2 ; H33.1 11.88,21.76 ; H33.1 11.88,18.64 ; H33.1 13.03,19.04 ; H33.1 10.31,20.2 ; H33.1 13.03,21.36 ; H33.1 10.72,19.04 ; H33.1 10.72,21.36 ; JBATT1.13 35.85,10.46 ; JBATT1.13 35.85,11.14 ; JBATT1.13 35.85,11.81 ; JBATT1.13 33.9,10.46 ; JBATT1.13 34.87,10.46 ; JBATT1.13 33.9,11.14 ; JBATT1.13 33.9,11.81 ; JBATT1.13 34.87,11.81 ; JUSBC1.6 7.04,51.12 ; JUSBC1.6 6.35,49.17 ; JUSBC1.6 5.65,50.25 ; JUSBC1.6 5.65,51.12 ; JUSBC1.6 5.65,49.17 ; JUSBC1.6 6.35,51.12 ; JUSBC1.6 7.04,49.17 ; JUSBC1.4 8.25,50.67 ; JUSBC1.4 8.25,49.17 ; JUSBC1.4 5.64,49.92 ; JUSBC1.4 8.25,49.92 ; JUSBC1.4 6.95,50.67 ; JUSBC1.4 6.95,49.17 ; JUSBC1.4 5.64,49.17 ; JHDMI1.11 11.8,32.23 ; JHDMI1.11 10.81,31.8 ; JHDMI1.11 10.81,32.67 ; JHDMI1.11 11.69,32.67 ; JHDMI1.11 10.7,32.23 ; JHDMI1.11 11.69,31.8
  VCC w0.089: 93.69,77.92 93.59,78.01 92.19,78.01 92.11,77.93 ; 218.54,78.01 217.14,78.01
  VCC w0.203: 30.42,11.14 JBATT1.14 ; JBATT1.14 32.38,10.46 ; JBATT1.14 32.38,11.81 ; JBATT1.14 30.42,11.81 ; JBATT1.14 30.42,10.46 ; JBATT1.14 31.4,10.46 ; JBATT1.14 31.4,11.81 ; JBATT1.14 32.38,11.14 ; 5.55,1.14 JUSB2.10 ; JUSB2.10 5.55,2.64 ; JUSB2.10 8.07,1.89 ; JUSB2.10 5.55,1.89 ; JUSB2.10 6.81,2.64 ; JUSB2.10 6.81,1.14 ; JUSB2.10 8.07,1.14 ; 6.95,73.03 JUSBC2.2 ; JUSBC2.2 5.64,74.53 ; JUSBC2.2 8.25,73.78 ; JUSBC2.2 5.64,73.78 ; JUSBC2.2 8.25,74.53 ; JUSBC2.2 8.25,73.03 ; JUSBC2.2 6.95,74.53 ; H37.1 219.35,74.54 ; H37.1 216.4,77.48 ; H37.1 219.88,76.01 ; H37.1 215.87,76.01 ; H37.1 219.35,77.48 ; H37.1 217.88,74 ; H37.1 216.4,74.54 ; JCR1.10 301.65,27.86 ; JCR1.10 302.76,27.16 ; JCR1.10 301.65,26.46 ; JCR1.10 302.76,27.86 ; JCR1.10 302.76,26.46 ; JCR1.10 300.54,27.16 ; JCR1.10 300.54,26.46 ; JCR1.10 300.54,27.86 ; JUSBC2.5 7.04,74.53 ; JUSBC2.5 6.35,74.53 ; JUSBC2.5 6.35,72.58 ; JUSBC2.5 5.65,72.58 ; JUSBC2.5 5.65,73.46 ; JUSBC2.5 5.65,74.53 ; JUSBC2.5 7.04,72.58 ; JUSB2.12 4.12,17.59 ; JUSB2.12 1.6,18.34 ; JUSB2.12 1.6,17.59 ; JUSB2.12 4.12,16.84 ; JUSB2.12 2.86,18.34 ; JUSB2.12 1.6,16.84 ; JUSB2.12 2.86,16.84 ; JUSB2.12 4.12,18.34 ; JUSBC1.6 7.04,49.17 ; JUSBC1.6 6.35,51.12 ; JUSBC1.6 7.04,51.12 ; JUSBC1.6 5.65,50.25 ; JUSBC1.6 5.65,51.12 ; JUSBC1.6 5.65,49.17 ; JUSBC1.6 6.35,49.17 ; 10.31,20.2 H33.1 ; H33.1 13.44,20.2 ; H33.1 11.88,18.64 ; H33.1 11.88,21.76 ; H33.1 13.03,21.36 ; H33.1 10.72,21.36 ; H33.1 13.03,19.04 ; H33.1 10.72,19.04 ; JHDMI1.2 13.24,27.3 ; JHDMI1.2 12.8,27.19 ; JHDMI1.2 12.25,27.74 ; JHDMI1.2 13.35,27.74 ; JHDMI1.2 12.36,27.3 ; JHDMI1.2 13.24,28.17 ; JHDMI1.2 12.36,28.17 ; JUSB1.13 310.22,43.76 ; JUSB1.13 308.96,44.51 ; JUSB1.13 307.7,43.76 ; JUSB1.13 310.22,44.51 ; JUSB1.13 310.22,43.01 ; JUSB1.13 307.7,43.01 ; JUSB1.13 308.96,43.01 ; 2.98,43.47 H32.1 ; H32.1 1.82,46.19 ; H32.1 2.98,46.59 ; H32.1 4.54,45.03 ; H32.1 4.13,43.87 ; H32.1 4.13,46.19 ; H32.1 1.41,45.03 ; H32.1 1.82,43.87 ; JCR1.12 311.05,41.46 ; JCR1.12 312.16,41.46 ; JCR1.12 309.95,41.46 ; JCR1.12 312.16,40.06 ; JCR1.12 311.05,40.06 ; JCR1.12 312.16,40.76 ; JUSB1.11 312.91,60.21 ; JUSB1.11 314.17,58.71 ; JUSB1.11 311.65,59.46 ; JUSB1.11 314.17,60.21 ; JUSB1.11 314.17,59.46 ; JUSB1.11 311.65,58.71 ; JUSB1.11 311.65,60.21 ; JUSB1.11 312.91,58.71 ; JUSBC2.6 7.04,64.39 ; JUSBC2.6 5.65,66.34 ; JUSBC2.6 6.35,64.39 ; JUSBC2.6 7.04,66.34 ; JUSBC2.6 5.65,65.46 ; JUSBC2.6 5.65,64.39 ; JUSBC2.6 6.35,66.34 ; JUSB2.13 6.81,18.34 ; JUSB2.13 5.55,17.59 ; JUSB2.13 8.07,18.34 ; JUSB2.13 5.55,18.34 ; JUSB2.13 6.81,16.84 ; JUSB2.13 5.55,16.84 ; JUSB2.13 8.07,17.59 ; 302.74,52.13 JUSB1.7 ; JUSB1.7 303.92,51.61 ; JUSB1.7 302.74,51.09 ; JUSB1.7 303.26,52.27 ; JUSB1.7 302.6,51.61 ; JUSB1.7 303.26,50.95 ; 11.4,38.03 JHDMI1.23 ; JHDMI1.23 10.09,38.98 ; JHDMI1.23 10.09,38.03 ; JHDMI1.23 10.09,39.94 ; JHDMI1.23 12.71,38.03 ; JHDMI1.23 12.71,38.98 ; JHDMI1.23 11.4,39.94 ; 5.65,59.31 JUSBC1.5 ; JUSBC1.5 5.65,57.36 ; JUSBC1.5 6.35,59.31 ; JUSBC1.5 5.65,58.24 ; JUSBC1.5 6.35,57.36 ; JUSBC1.5 7.04,57.36 ; JUSBC1.5 7.04,59.31 ; JHDMI1.5 11.69,28.8 ; JHDMI1.5 10.81,29.67 ; JHDMI1.5 11.69,29.67 ; JHDMI1.5 11.8,29.23 ; JHDMI1.5 10.81,28.8 ; JHDMI1.5 10.7,29.23 ; JHDMI1.20 12.71,24.48 ; JHDMI1.20 10.09,25.44 ; JHDMI1.20 10.09,23.53 ; JHDMI1.20 12.71,23.53 ; JHDMI1.20 12.71,25.44 ; JHDMI1.20 10.09,24.48 ; JHDMI1.20 11.4,25.44 ; JHDMI1.20 11.4,23.53 ; 309.95,27.16 JCR1.13 ; JCR1.13 309.95,26.46 ; JCR1.13 311.05,26.46 ; JCR1.13 309.95,27.86 ; JCR1.13 312.16,26.46 ; JCR1.13 312.16,27.16 ; JCR1.13 311.05,27.86 ; JCR1.13 312.16,27.86 ; JHDMI1.17 11.69,35.67 ; JHDMI1.17 10.81,35.67 ; JHDMI1.17 11.8,35.23 ; JHDMI1.17 10.81,34.8 ; JHDMI1.17 11.69,34.8 ; JHDMI1.17 10.7,35.23 ; H31.1 4.54,78.11 ; H31.1 2.98,79.67 ; H31.1 2.98,76.55 ; H31.1 1.41,78.11 ; H31.1 1.82,79.27 ; H31.1 4.13,79.27 ; H31.1 1.82,76.95 ; H31.1 4.13,76.95 ; 0.45,65.94 JUSBC2.3 ; JUSBC2.3 1.9,65.94 ; JUSBC2.3 3.34,65.14 ; JUSBC2.3 3.34,64.34 ; JUSBC2.3 3.34,65.94 ; JUSBC2.3 0.45,64.34 ; JUSBC2.3 0.45,65.14 ; JUSBC2.3 1.9,64.34 ; JUSB1.12 314.17,43.76 ; JUSB1.12 311.65,43.01 ; JUSB1.12 314.17,44.51 ; JUSB1.12 312.91,43.01 ; JUSB1.12 314.17,43.01 ; JUSB1.12 311.65,44.51 ; JUSB1.12 311.65,43.76 ; JUSB1.12 312.91,44.51 ; 11.85,9.74 JUSB2.7 ; JUSB2.7 13.03,10.26 ; JUSB2.7 13.03,9.22 ; JUSB2.7 13.17,9.74 ; JUSB2.7 12.51,9.08 ; JUSBC2.4 6.95,65.89 ; JUSBC2.4 5.64,65.14 ; JUSBC2.4 6.95,64.39 ; JUSBC2.4 5.64,64.39 ; JHDMI1.22 4.75,41.44 ; JHDMI1.22 4.75,40.48 ; JHDMI1.22 1.35,40.48 ; JHDMI1.22 1.35,41.44 ; JHDMI1.22 3.05,41.44 ; JUSB1.10 310.22,60.21 ; JUSB1.10 310.22,58.71 ; JUSB1.10 307.7,60.21 ; JUSB1.10 308.96,60.21 ; JUSB1.10 310.22,59.46 ; JUSB1.10 307.7,59.46 ; JUSB1.10 308.96,58.71 ; 6.95,57.81 JUSBC1.2 ; JUSBC1.2 5.64,58.56 ; JUSBC1.2 6.95,59.31 ; JUSBC1.2 5.64,59.31 ; JUSBC1.1 3.34,58.56 ; JUSBC1.1 0.45,59.36 ; JUSBC1.1 3.34,57.76 ; JUSBC1.1 3.34,59.36 ; JUSBC1.1 0.45,57.76 ; JUSBC1.1 1.9,57.76 ; JUSBC1.1 1.9,59.36 ; JUSBC1.1 0.45,58.56 ; JUSBC2.1 3.34,73.78 ; JUSBC2.1 0.45,74.58 ; JUSBC2.1 3.34,72.98 ; JUSBC2.1 1.9,74.58 ; JUSBC2.1 1.9,72.98 ; JUSBC2.1 0.45,73.78 ; JUSBC2.1 3.34,74.58 ; JUSBC2.1 0.45,72.98 ; 242.92,76.41 H34.1 ; H34.1 242.92,74.09 ; H34.1 245.23,76.41 ; H34.1 245.23,74.09 ; H34.1 244.08,76.81 ; H34.1 245.64,75.25 ; H34.1 242.51,75.25 ; H34.1 244.08,73.69 ; JUSB2.11 4.12,1.89 ; JUSB2.11 1.6,2.64 ; JUSB2.11 2.86,2.64 ; JUSB2.11 1.6,1.89 ; JUSB2.11 4.12,1.14 ; JUSB2.11 4.12,2.64 ; JUSB2.11 1.6,1.14 ; JUSB2.11 2.86,1.14 ; JCR1.11 302.76,40.76 ; JCR1.11 302.76,41.46 ; JCR1.11 302.76,40.06 ; 304.06,53.95 JUSB1.4 ; JUSB1.4 303.4,54.61 ; JUSB1.4 304.06,55.27 ; JHDMI1.11 11.8,32.23 ; JHDMI1.11 10.81,31.8 ; JHDMI1.11 11.69,32.67 ; JHDMI1.11 10.81,32.67 ; JHDMI1.11 11.69,31.8 ; JHDMI1.11 10.7,32.23 ; JUSB2.4 11.71,7.4 ; JUSB2.4 12.37,6.74 ; JUSB2.4 11.71,6.08 ; H36.1 94.79,76.82 ; H36.1 91.4,77.48 ; H36.1 93.68,77.92 ; 1.35,22.98 JHDMI1.21 ; JHDMI1.21 1.35,22.03 ; JHDMI1.21 4.75,22.03 ; JHDMI1.21 4.75,22.98 ; JHDMI1.21 3.05,22.03 ; JUSBC1.3 3.34,49.92 ; JUSBC1.3 0.45,49.92 ; JUSBC1.3 3.34,50.72 ; JUSBC1.3 1.9,50.72 ; JUSBC1.3 1.9,49.12 ; JUSBC1.3 0.45,49.12 ; JUSBC1.3 0.45,50.72 ; JUSBC1.3 3.34,49.12 ; 33.9,11.81 JBATT1.13 ; JBATT1.13 33.9,11.14 ; JBATT1.13 33.9,10.46 ; JHDMI1.8 13.24,31.17 ; JHDMI1.8 12.36,31.17 ; JHDMI1.8 13.24,30.3 ; JHDMI1.8 13.35,30.74 ; JHDMI1.8 12.25,30.74 ; JHDMI1.8 12.36,30.3 ; H10.1 303.7,68.42 ; H10.1 303.7,72.06 ; H10.1 304.38,70.24 ; 5.64,49.17 JUSBC1.4 ; JUSBC1.4 5.64,49.92 ; JUSBC1.4 6.95,49.17 ; JUSBC1.4 6.95,50.67
  VCC w0.254: H36.1 94.3,77.43 94.3,77.62 94.18,77.73 v6(94.21,77.76) ; H36.1 v6(95.08,76.01) 95.17,76.01 ; H36.1 90.63,76.01 90.69,75.95 v6(90.69,75.95)
  GND3 w0.089: 93.69,77.92 93.59,78.01 92.19,78.01 92.11,77.93 ; 218.54,78.01 217.14,78.01
  GND3 w0.203: 10.81,35.67 JHDMI1.17 ; JHDMI1.17 11.69,34.8 ; JHDMI1.17 11.69,35.67 ; JHDMI1.17 11.8,35.23 ; JHDMI1.17 10.7,35.23 ; JHDMI1.17 10.81,34.8 ; 2.98,43.47 H32.1 ; H32.1 1.82,43.87 ; H32.1 4.13,46.19 ; H32.1 2.98,46.59 ; H32.1 4.13,43.87 ; H32.1 4.54,45.03 ; H32.1 1.41,45.03 ; H32.1 1.82,46.19 ; 300.06,68.42 H10.1 ; H10.1 303.7,68.42 ; H10.1 304.38,70.24 ; H10.1 303.7,72.06 ; H10.1 301.88,67.74 ; H10.1 300.06,72.06 ; H10.1 301.88,72.74 ; H10.1 299.37,70.24 ; 1.9,64.34 JUSBC2.3 ; JUSBC2.3 3.34,65.14 ; JUSBC2.3 0.45,64.34 ; JUSBC2.3 0.45,65.94 ; JUSBC2.3 3.34,64.34 ; JUSBC2.3 1.9,65.94 ; JUSBC2.3 3.34,65.94 ; JUSBC2.3 0.45,65.14 ; 5.55,1.14 JUSB2.10 ; JUSB2.10 8.07,1.14 ; JUSB2.10 5.55,2.64 ; JUSB2.10 6.81,2.64 ; JUSB2.10 8.07,1.89 ; JUSB2.10 5.55,1.89 ; JUSB2.10 6.81,1.14 ; JHDMI1.21 4.75,22.03 ; JHDMI1.21 3.05,22.03 ; JHDMI1.21 1.35,22.03 ; JHDMI1.21 1.35,22.98 ; JHDMI1.21 4.75,22.98 ; JUSBC2.1 1.9,74.58 ; JUSBC2.1 3.34,73.78 ; JUSBC2.1 3.34,74.58 ; JUSBC2.1 3.34,72.98 ; JUSBC2.1 0.45,74.58 ; JUSBC2.1 1.9,72.98 ; JUSBC2.1 0.45,72.98 ; JUSBC2.1 0.45,73.78 ; H36.1 94.35,74.54 ; H36.1 94.88,76.01 ; H36.1 92.88,74 ; H36.1 91.4,77.48 ; H36.1 90.87,76.01 ; H36.1 94.35,77.48 ; H36.1 91.4,74.54 ; JUSB1.4 304.06,55.27 ; JUSB1.4 303.4,54.61 ; JUSB1.4 304.06,53.95 ; 297.01,48.91 H30.1 ; H30.1 299.73,50.07 ; H30.1 297.42,50.07 ; H30.1 298.57,47.35 ; H30.1 299.73,47.75 ; H30.1 297.42,47.75 ; H30.1 300.14,48.91 ; H30.1 298.57,50.47 ; JHDMI1.2 13.35,27.74 ; JHDMI1.2 13.24,28.17 ; JHDMI1.2 12.36,27.3 ; JHDMI1.2 13.24,27.3 ; JHDMI1.2 12.8,27.19 ; JHDMI1.2 12.25,27.74 ; JHDMI1.2 12.36,28.17 ; 5.55,18.34 JUSB2.13 ; JUSB2.13 5.55,16.84 ; JUSB2.13 6.81,16.84 ; JUSB2.13 8.07,17.59 ; JUSB2.13 5.55,17.59 ; JUSB2.13 8.07,18.34 ; JUSB2.13 6.81,18.34 ; 6.95,64.39 JUSBC2.4 ; JUSBC2.4 8.25,65.89 ; JUSBC2.4 5.64,64.39 ; JUSBC2.4 8.25,64.39 ; JUSBC2.4 6.95,65.89 ; JUSBC2.4 8.25,65.14 ; JUSBC2.4 5.64,65.14 ; JHDMI1.23 11.4,39.94 ; JHDMI1.23 11.4,38.03 ; JHDMI1.23 12.71,38.03 ; JHDMI1.23 12.71,39.94 ; JHDMI1.23 12.71,38.98 ; JHDMI1.23 10.09,39.94 ; JHDMI1.23 10.09,38.03 ; JHDMI1.23 10.09,38.98 ; JCR1.11 302.76,40.06 ; JCR1.11 302.76,40.76 ; JCR1.11 300.54,41.46 ; JCR1.11 301.65,40.06 ; JCR1.11 302.76,41.46 ; JCR1.11 300.54,40.06 ; JCR1.11 300.54,40.76 ; JCR1.11 301.65,41.46 ; JCR1.13 312.16,26.46 ; JCR1.13 309.95,27.86 ; JCR1.13 309.95,26.46 ; JCR1.13 309.95,27.16 ; JCR1.13 311.05,26.46 ; JCR1.13 312.16,27.86 ; JCR1.13 312.16,27.16 ; JCR1.13 311.05,27.86 ; H31.1 2.98,79.67 ; H31.1 4.54,78.11 ; H31.1 4.13,79.27 ; H31.1 4.13,76.95 ; H31.1 1.41,78.11 ; H31.1 1.82,79.27 ; H31.1 1.82,76.95 ; H31.1 2.98,76.55 ; JHDMI1.8 13.24,31.17 ; JHDMI1.8 13.24,30.3 ; JHDMI1.8 13.35,30.74 ; JHDMI1.8 12.25,30.74 ; JHDMI1.8 12.36,31.17 ; JHDMI1.8 12.36,30.3 ; JHDMI1.22 3.05,41.44 ; JHDMI1.22 4.75,40.48 ; JHDMI1.22 4.75,41.44 ; JHDMI1.22 1.35,40.48 ; JHDMI1.22 1.35,41.44 ; H37.1 219.35,74.54 ; H37.1 217.88,74 ; H37.1 215.87,76.01 ; H37.1 219.35,77.48 ; H37.1 216.4,77.48 ; H37.1 219.88,76.01 ; H37.1 216.4,74.54 ; JUSBC2.6 7.04,64.39 ; JUSBC2.6 6.35,66.34 ; JUSBC2.6 7.04,66.34 ; JUSBC2.6 6.35,64.39 ; JUSBC2.6 5.65,65.46 ; JUSBC2.6 5.65,64.39 ; JUSBC2.6 5.65,66.34 ; JUSB2.7 13.17,9.74 ; JUSB2.7 13.03,10.26 ; JUSB2.7 11.85,9.74 ; JUSB2.7 12.51,10.4 ; JUSB2.7 13.03,9.22 ; JUSB2.7 12.51,9.08 ; 1.6,18.34 JUSB2.12 ; JUSB2.12 4.12,17.59 ; JUSB2.12 1.6,17.59 ; JUSB2.12 4.12,18.34 ; JUSB2.12 2.86,16.84 ; JUSB2.12 2.86,18.34 ; JUSB2.12 1.6,16.84 ; JUSB2.12 4.12,16.84 ; JBATT1.14 31.4,11.81 ; JBATT1.14 32.38,11.81 ; JBATT1.14 31.4,10.46 ; JBATT1.14 32.38,11.14 ; JBATT1.14 32.38,10.46 ; JBATT1.14 30.42,11.14 ; JBATT1.14 30.42,11.81 ; JBATT1.14 30.42,10.46 ; 309.95,41.46 JCR1.12 ; JCR1.12 311.05,40.06 ; JCR1.12 312.16,40.06 ; JCR1.12 311.05,41.46 ; JCR1.12 312.16,40.76 ; JCR1.12 312.16,41.46 ; JUSB1.13 310.22,44.51 ; JUSB1.13 308.96,44.51 ; JUSB1.13 310.22,43.76 ; JUSB1.13 307.7,43.76 ; JUSB1.13 310.22,43.01 ; JUSB1.13 307.7,43.01 ; JUSB1.13 308.96,43.01 ; 202.86,22.91 H35.1 ; H35.1 205.58,21.75 ; H35.1 204.43,21.35 ; H35.1 203.27,24.07 ; H35.1 204.43,24.47 ; H35.1 205.58,24.07 ; H35.1 203.27,21.75 ; H35.1 205.99,22.91 ; 10.7,29.23 JHDMI1.5 ; JHDMI1.5 10.81,28.8 ; JHDMI1.5 10.81,29.67 ; JHDMI1.5 11.69,28.8 ; JHDMI1.5 11.69,29.67 ; JHDMI1.5 11.8,29.23 ; JHDMI1.20 12.71,25.44 ; JHDMI1.20 10.09,23.53 ; JHDMI1.20 12.71,24.48 ; JHDMI1.20 11.4,25.44 ; JHDMI1.20 11.4,23.53 ; JHDMI1.20 10.09,24.48 ; JHDMI1.20 12.71,23.53 ; JHDMI1.20 10.09,25.44 ; 6.35,49.17 JUSBC1.6 ; JUSBC1.6 7.04,49.17 ; JUSBC1.6 5.65,49.17 ; JUSBC1.6 5.65,51.12 ; JUSBC1.6 6.35,51.12 ; JUSBC1.6 7.04,51.12 ; JUSBC1.6 5.65,50.25 ; JUSB1.10 308.96,60.21 ; JUSB1.10 310.22,60.21 ; JUSB1.10 310.22,58.71 ; JUSB1.10 308.96,58.71 ; JUSB1.10 307.7,59.46 ; JUSB1.10 310.22,59.46 ; JUSB1.10 307.7,60.21 ; JBATT1.12 31.4,26.56 ; JBATT1.12 30.42,25.21 ; JBATT1.12 32.38,25.21 ; JBATT1.12 30.42,26.56 ; JBATT1.12 30.42,25.89 ; JBATT1.12 31.4,25.21 ; JBATT1.12 32.38,26.56 ; JBATT1.12 32.38,25.89 ; 264.38,69.74 H5.1 ; H5.1 265.07,71.56 ; H5.1 268.71,71.56 ; H5.1 265.07,67.92 ; H5.1 268.71,67.92 ; H5.1 266.89,72.24 ; H5.1 266.89,67.24 ; H5.1 269.39,69.74 ; 311.65,44.51 JUSB1.12 ; JUSB1.12 312.91,44.51 ; JUSB1.12 314.17,44.51 ; JUSB1.12 314.17,43.01 ; JUSB1.12 312.91,43.01 ; JUSB1.12 311.65,43.76 ; JUSB1.12 311.65,43.01 ; JUSB1.12 314.17,43.76 ; JUSBC1.5 6.35,59.31 ; JUSBC1.5 5.65,57.36 ; JUSBC1.5 5.65,58.24 ; JUSBC1.5 7.04,59.31 ; JUSBC1.5 5.65,59.31 ; JUSBC1.5 6.35,57.36 ; JUSBC1.5 7.04,57.36 ; JUSBC2.2 8.25,73.78 ; JUSBC2.2 6.95,74.53 ; JUSBC2.2 5.64,73.78 ; JUSBC2.2 8.25,73.03 ; JUSBC2.2 6.95,73.03 ; JUSBC2.2 8.25,74.53 ; JUSBC2.2 5.64,74.53 ; 5.64,49.17 JUSBC1.4 ; JUSBC1.4 8.25,49.17 ; JUSBC1.4 6.95,49.17 ; JUSBC1.4 5.64,49.92 ; JUSBC1.4 8.25,49.92 ; JUSBC1.4 6.95,50.67 ; JUSBC1.4 8.25,50.67 ; 303.26,50.95 JUSB1.7 ; JUSB1.7 302.74,52.13 ; JUSB1.7 303.26,52.27 ; JUSB1.7 303.92,51.61 ; JUSB1.7 302.74,51.09 ; JUSB1.7 302.6,51.61 ; 300.54,26.46 JCR1.10 ; JCR1.10 302.76,27.86 ; JCR1.10 300.54,27.16 ; JCR1.10 300.54,27.86 ; JCR1.10 302.76,27.16 ; JCR1.10 301.65,27.86 ; JCR1.10 302.76,26.46 ; JCR1.10 301.65,26.46 ; 1.9,49.12 JUSBC1.3 ; JUSBC1.3 3.34,50.72 ; JUSBC1.3 3.34,49.92 ; JUSBC1.3 0.45,50.72 ; JUSBC1.3 1.9,50.72 ; JUSBC1.3 0.45,49.92 ; JUSBC1.3 0.45,49.12 ; JUSBC1.3 3.34,49.12 ; H6.1 245.7,29.22 ; H6.1 241.37,31.04 ; H6.1 245.7,32.86 ; H6.1 246.38,31.04 ; H6.1 243.88,28.54 ; H6.1 242.06,32.86 ; H6.1 242.06,29.22 ; H6.1 243.88,33.54 ; 5.65,74.53 JUSBC2.5 ; JUSBC2.5 5.65,73.46 ; JUSBC2.5 6.35,74.53 ; JUSBC2.5 6.35,72.58 ; JUSBC2.5 5.65,72.58 ; JUSBC2.5 7.04,72.58 ; JUSBC2.5 7.04,74.53 ; 10.31,20.2 H33.1 ; H33.1 13.44,20.2 ; H33.1 10.72,21.36 ; H33.1 10.72,19.04 ; H33.1 13.03,21.36 ; H33.1 11.88,18.64 ; H33.1 13.03,19.04 ; H33.1 11.88,21.76 ; 312.91,58.71 JUSB1.11 ; JUSB1.11 311.65,59.46 ; JUSB1.11 314.17,60.21 ; JUSB1.11 314.17,59.46 ; JUSB1.11 311.65,58.71 ; JUSB1.11 314.17,58.71 ; JUSB1.11 311.65,60.21 ; JUSB1.11 312.91,60.21 ; JHDMI1.11 11.8,32.23 ; JHDMI1.11 11.69,31.8 ; JHDMI1.11 11.69,32.67 ; JHDMI1.11 10.81,32.67 ; JHDMI1.11 10.81,31.8 ; JHDMI1.11 10.7,32.23 ; H9.1 290.64,57.18 ; H9.1 287,53.54 ; H9.1 287,57.18 ; H9.1 291.32,55.36 ; H9.1 290.64,53.54 ; H9.1 288.82,57.86 ; H9.1 286.31,55.36 ; H9.1 288.82,52.86 ; JUSBC1.2 8.25,59.31 ; JUSBC1.2 8.25,57.81 ; JUSBC1.2 8.25,58.56 ; JUSBC1.2 6.95,57.81 ; JUSBC1.2 5.64,58.56 ; JUSBC1.2 6.95,59.31 ; JUSBC1.2 5.64,59.31 ; 0.45,57.76 JUSBC1.1 ; JUSBC1.1 3.34,57.76 ; JUSBC1.1 0.45,59.36 ; JUSBC1.1 3.34,59.36 ; JUSBC1.1 0.45,58.56 ; JUSBC1.1 3.34,58.56 ; JUSBC1.1 1.9,59.36 ; JUSBC1.1 1.9,57.76 ; 2.86,1.14 JUSB2.11 ; JUSB2.11 1.6,1.14 ; JUSB2.11 4.12,2.64 ; JUSB2.11 1.6,2.64 ; JUSB2.11 4.12,1.14 ; JUSB2.11 1.6,1.89 ; JUSB2.11 2.86,2.64 ; JUSB2.11 4.12,1.89 ; 242.51,75.25 H34.1 ; H34.1 244.08,76.81 ; H34.1 242.92,76.41 ; H34.1 245.23,76.41 ; H34.1 245.23,74.09 ; H34.1 242.92,74.09 ; H34.1 245.64,75.25 ; H34.1 244.08,73.69 ; JUSB2.4 12.37,6.74 ; JUSB2.4 11.71,7.4 ; JUSB2.4 11.71,6.08 ; 33.9,10.46 JBATT1.13 ; JBATT1.13 34.87,11.81 ; JBATT1.13 35.85,10.46 ; JBATT1.13 33.9,11.14 ; JBATT1.13 35.85,11.14 ; JBATT1.13 35.85,11.81 ; JBATT1.13 34.87,10.46 ; JBATT1.13 33.9,11.81 ; 285.41,76.01 H38.1 ; H38.1 288.13,74.85 ; H38.1 285.82,74.85 ; H38.1 286.98,77.57 ; H38.1 288.13,77.17 ; H38.1 286.98,74.45 ; H38.1 288.54,76.01 ; H38.1 285.82,77.17 ; 33.9,26.56 JBATT1.11 ; JBATT1.11 34.87,26.56 ; JBATT1.11 35.85,25.89 ; JBATT1.11 34.87,25.21 ; JBATT1.11 33.9,25.21 ; JBATT1.11 35.85,26.56 ; JBATT1.11 33.9,25.89 ; JBATT1.11 35.85,25.21
  IN3 w0.076: 67.7,34.67 v5(67.63,34.67) ; v5(91.15,33.13) v4(91.15,33.46) ; v4(91.15,34.15) v5(91.15,33.82) ; v5(89.57,18.23) v4(89.83,18.02)
  IN3 w0.203: v5(65.42,26.23) v4(65.74,26.63) ; v5(74.16,40.38) v4(74.39,40.62) ; v5(90.22,23.83) v4(89.9,24.23) v5(89.57,24.63) ; v4(25.47,77.22) 25.22,76.98 v5(25.22,76.93) ; v5(64.12,23.03) v4(64.12,22.69) ; v5(66.18,32.75) v4(65.94,32.52) ; v5(66.07,18.23) 66.21,18.37 v4(66.21,18.53) ; v5(71.67,52.03) 71.69,52.03 v4(71.91,52.25) ; v4(77.54,34.79) 77.73,34.98 v5(77.73,35.08) ; v5(63.47,26.23) v4(63.56,26.56) ; v5(60.87,25.87) v4(60.64,26.11) ; v5(62.17,25.87) v4(62.17,25.54) ; v5(66.07,24.63) 65.74,24.31 v4(65.74,24.23) ; v5(93.47,25.87) v4(93.7,26.11) ; v5(65.38,51.63) v4(65.15,51.86) ; v5(79.82,33.07) v4(80.06,32.84) ; v5(64.77,24.63) v4(64.44,24.23) v5(64.12,23.83) ; v5(72.59,51.38) v4(72.85,51.61) ; v5(90.87,26.23) v4(90.78,26.56) ; v5(65.79,34.67) 65.95,34.67 v4(66.41,35.12) ; v5(70.75,52.03) v4(70.98,52.26) ; v5(82.34,33.07) v4(82.34,32.74) ; v5(88.92,26.23) v4(88.6,26.63) ; v5(62.17,23.03) 62.17,23.35 62.18,23.37 v4(62.18,23.37) ; v5(92.17,25.87) v4(92.17,25.54) ; v5(88.27,24.63) v4(88.6,24.23)
  IN3 w0.229: v5(70.06,35.74) v4(69.82,36.16) ; v5(86.32,19.83) v4(86.58,20.05) ; v5(64.77,18.23) v4(64.98,18.49) ; v5(84.37,19.83) v4(84.12,19.62) ; v5(65.79,35.19) 65.86,35.12 v4(66.41,35.12) ; v5(68.54,35.02) v4(68,34.85) 67.7,34.67 ; v5(86.97,21.43) v4(86.72,21.65) ; v5(93.47,21.43) v4(93.73,21.22) ; v5(85.67,19.03) v4(85.42,19.25) ; v5(69.97,26.23) v4(70.13,26.52) ; v5(91.52,19.83) v4(91.13,20.05) ; v5(84.37,21.43) v4(84.12,21.22) ; v5(90.87,20.63) v4(91.27,20.85) ; v5(86.32,21.43) v4(86.07,21.65) ; v5(90.87,21.43) v4(91.13,21.65) ; v5(90.22,23.03) v4(90.48,22.74) ; v5(92.82,19.03) v4(93.08,19.25) ; v5(93.47,20.63) v4(93.73,20.42) ; v5(66.13,40.27) v4(65.8,40.27) 65.75,40.32 v5(65.13,40.32) ; v5(88.31,17.58) 88.31,17.86 v4(88.36,17.91) ; v5(85.67,26.23) v4(85.56,26.55) ; v5(92.82,21.43) v4(93.08,21.22) ; v5(84.37,19.03) 84.13,18.83 v4(84.12,18.82) ; v5(84.37,20.63) v4(84.12,20.42) ; v5(90.22,21.43) v4(90.48,21.65) ; v5(67.67,36.49) v4(67.21,36.27) ; v5(84.37,18.23) v4(84.12,18.02) ; v5(92.82,20.63) v4(93.08,20.42) ; v5(66.13,37.75) v4(66.4,37.94) ; v5(86.32,20.63) v4(86.07,20.85) ; v5(92.17,23.03) v4(92.43,23.25) ; v5(87.62,21.43) v4(87.37,21.65) ; v5(65.42,19.83) v4(65.67,20.05) ; v5(85.67,23.03) v4(85.42,23.25) ; v5(86.97,20.63) v4(86.72,20.85) ; v5(69.76,35.38) v4(69.82,35) ; v5(92.17,19.03) v4(92.43,19.25) ; v5(71.01,34.17) v4(71.01,33.66) ; v5(90.22,19.83) v4(90.62,20.05) ; v5(68.67,26.23) v4(68.78,26.55) ; v5(91.52,21.43) v4(91.78,21.65) ; v5(85.02,21.43) v4(84.77,21.22) ; v5(87.62,23.03) v4(87.37,22.82) ; v5(85.02,19.83) v4(84.77,19.62) ; v5(85.02,20.63) v4(84.77,20.42) ; v5(88.92,19.83) v4(88.67,20.05)
  IN3 w0.254: v4(74.68,51.63) 74.44,51.39 v5(74.44,51.38) ; v4(85.28,53.79) 85.09,53.79 84.97,53.9 v5(84.93,53.9) ; v5(22.28,52.27) v4(22.05,52.04) ; v5(69.82,52.68) v4(70.06,52.91) ; v5(99.11,45.8) v4(99.34,46.03) ; v5(89.89,35.02) v4(90.13,34.79) ; v5(67.66,40.88) v4(67.89,41.11) ; v5(70.06,37.04) v4(69.82,36.81) ; v5(87.37,52.03) v4(87.65,52.31) ; v5(67.51,50.27) v4(67.84,50.27) ; v5(65.71,48.44) v4(65.48,48.68) ; v5(76.05,34.15) v4(76.05,34.69) v5(76.05,35.02) ; v5(25.88,47.21) v4(25.54,47.21) ; v5(91.6,54.08) v4(91.94,53.91) 91.6,53.57 v5(91.6,53.43) ; v4(11.13,70.5) 10.9,70.27 v10(10.89,70.27) ; v5(99.11,39.92) 98.94,40.09 v4(98.79,40.09) 98.63,40.09 v5(98.46,39.92) ; v5(91.07,52.01) 91.12,52.01 v4(91.33,52.23) ; v5(114.61,28.16) 114.64,28.2 v4(114.95,28.2) ; v4(80.9,39.6) 81,39.91 v5(81,39.92) ; v5(87.37,38.34) v4(87.61,38.11) ; v5(102.36,43.28) v4(102.59,43.51) ; v5(82.82,35.74) v4(83.05,35.51) ; v5(70.26,40.88) v4(70.49,41.11) ; v5(20.33,52.92) 20.17,53.08 v4(20.03,53.08) ; v5(80.08,37.04) v4(80.35,36.78) ; v5(22.28,49.02) v4(22.05,48.79) ; v5(61.52,19.83) v4(61.27,20.05) ; v5(26.18,50.32) v4(25.95,50.09) ; v5(69.61,40.88) v4(69.84,41.11) ; v5(18.98,48.59) 18.99,48.63 18.78,48.87 v4(18.78,48.92) v10(18.42,48.83) ; v5(26.18,54.22) v4(25.95,54.46) ; v5(98.46,47.48) v4(98.69,47.71) ; v5(89.2,38.34) v4(89.43,38.58) ; v5(90.11,37.69) v4(90.34,37.46) ; v5(90.11,39.92) 89.8,39.92 v4(89.75,39.97) ; v5(72.79,38.34) v4(72.56,38.11) ; v5(46.61,22.83) v4(46.32,22.54) ; v5(88.03,53.41) 88.27,53.65 v4(88.27,53.66) ; v4(9.9,54.03) v10(10.13,54.26) ; v5(91.93,37.04) v4(92.17,36.81) ; v5(78.14,52.68) v4(78.37,52.91) ; v5(101.06,46.64) v4(101.29,46.87) ; v5(24.23,52.27) v4(24,52.04) ; v5(65.06,53.81) v4(64.83,54.04) ; v5(84.64,37.69) v4(84.87,37.46) ; v5(69.61,46.56) v4(69.38,46.79) ; v5(20.33,50.97) v4(20.1,51.21) ; v5(86.12,33.82) v4(86.12,34.15) ; v5(97.54,51.38) v4(97.77,51.61) ; v4(15.37,12.72) 15.19,12.91 v5(15.04,12.91) ; v5(82.82,37.69) v4(83.05,37.46) ; v5(92.41,35.02) v4(92.64,34.79) ; v5(77.61,53.39) v4(77.85,53.62) ; v5(101.06,44.96) v4(101.29,45.19) ; v5(84.64,39.92) v4(84.64,39.59) ; v5(19.68,54.22) v4(19.45,54.46) ; v5(67.85,54.4) 67.64,54.19 v4(67.64,54.11) ; v4(71.01,33.66) v5(71.01,33.17) ; v5(204.79,58.11) 204.37,58.11 v4(204.37,58.11) ; v4(69.36,43.15) 69.6,42.91 v5(69.61,42.91) ; v5(75.37,51.38) v4(75.6,51.61) ; v5(65.71,44.67) v4(65.48,44.91) ; v5(80.51,39.45) 80.51,39.14 v4(80.56,39.1) v5(81,38.99) ; v10(9.81,67.89) 9.82,67.92 10.11,68.06 v4(10.11,68.06) ; v5(24.72,76.93) v4(24.89,77.22) ; v5(85.55,38.34) v4(85.79,38.11) ; v5(69.15,38.99) v4(68.91,39.23) ; v5(93.67,33.82) v4(93.9,33.58) ; v5(82.34,35.02) v4(82.57,34.79) ; v4(78.63,34.15) 78.57,34.09 v5(78.57,33.82) ; v5(94.77,49.81) 94.77,49.82 95.1,49.82 v4(95.13,49.84) ; v5(103.01,43.28) v4(103.24,43.51) ; v4(9.86,70.06) v10(10.19,70.06) ; v5(95.69,51.38) 95.69,51.42 v4(95.91,51.64) ; v5(69.61,44.67) v4(69.38,44.91) ; v5(21.63,50.32) v4(21.4,50.56) ; v5(68.02,21.43) v4(68.27,21.65) ; v5(19.68,54.87) v4(19.45,55.11) ; v5(81.91,39.92) 81.47,39.92 v4(81.44,39.94) ; v5(93.84,51.38) 93.88,51.38 94.04,51.54 v4(94.04,51.66) ; v5(93.67,35.02) v4(93.9,34.79) ; v5(104.69,38.34) v4(104.93,38.11) ; v5(68.44,50.27) v4(68.82,50.27) ; v5(104.93,51.38) v4(105.16,51.61) ; v5(69.32,19.03) v4(69.57,19.25) ; v5(67.33,37.75) v4(67.33,38.08) ; v5(20.33,54.22) v4(20.1,54.46) ; v5(70.26,42.91) v4(70.03,43.15) ; v5(72.73,53.39) 72.73,53.55 v4(72.59,53.69) ; v5(83.6,35.02) v4(83.6,34.69) ; v5(64.12,21.43) v4(63.87,21.65) ; v5(72.59,49.81) v4(72.83,49.58) ; v5(104.49,44.28) v4(104.72,44.51) ; v4(21.87,47.2) 21.88,47.21 v5(22.2,47.21) ; v4(9.9,69.25) v10(10.13,69.48) ; v5(77.61,54.4) v4(77.38,54.16) ; v4(78.35,39.32) 78.26,39.23 v5(78.26,38.99) ; v5(5.49,56.64) v4(5.16,56.64) ; v5(94.7,55.05) v4(94.46,54.82) ; v5(103.08,51.38) v4(103.31,51.61) ; v5(87.37,35.02) v4(87.59,34.77) ; v4(99.55,41.04) 99.27,40.76 v5(99.11,40.76) ; v5(88.63,33.82) v4(88.63,34.15) ; v5(68.5,33.17) v4(68.5,32.84) ; v5(97.81,45.8) v4(98.06,46.04) ; v5(99.11,49.16) v4(99.34,49.39) ; v5(79.63,40.38) v4(79.86,40.62) ; v5(69.97,20.63) v4(70.22,20.42) ; v5(68.96,42.91) v4(68.73,43.15) ; v4(105.89,53.37) 106.19,53.37 v5(106.24,53.43) ; v5(69.97,21.43) v4(70.22,21.22) ; v5(26.18,50.97) 26.13,50.97 v4(25.91,50.76) ; v5(102.02,53.39) v4(102.32,53.69) ; v5(91.02,38.34) v4(91.25,38.11) ; v5(91.93,36.39) v4(92.17,36.16) ; v5(80.54,40.38) v4(80.77,40.62) ; v5(99.85,50.78) 100.43,50.78 v4(100.51,50.7) ; v5(75.98,39.46) v4(76.22,39.69) ; v5(70.06,38.34) v4(69.82,38.11) ; v5(95.58,36.39) v4(95.81,36.63) ; v5(97.16,39.92) v4(97.39,40.15) ; v5(65.69,33.38) v4(65.45,33.61) ; v5(66.34,33.38) v4(66.1,33.14) ; v4(10.11,70.63) v10(10.4,70.78) ; v4(10.11,66.52) v10(9.81,66.67) ; v5(69.36,50.27) 69.36,50.27 v4(69.73,50.27) ; v5(102.36,44.12) v4(102.59,44.35) ; v5(100.41,46.64) v4(100.64,46.87) ; v5(99.11,43.28) v4(99.34,43.51) ; v4(86.84,49.75) 86.75,49.84 v5(86.45,49.84) ; v5(102.16,51.38) v4(102.39,51.61) ; v5(19.68,52.27) v4(19.45,52.51) ; v5(99.96,35.02) 100.16,34.82 v4(100.16,34.69) ; v5(61.52,20.63) v4(61.27,20.85) ; v5(67.37,21.43) v4(67.62,21.65) ; v5(20.98,54.87) v4(20.75,55.11) ; v5(78.26,37.04) v4(78.49,36.81) ; v5(42.13,31.77) v4(42.48,31.77) ; v5(25.53,48.37) v4(25.3,48.14) ; v5(70.06,38.99) v4(69.82,38.76) ; v5(73.53,35.02) v4(73.3,34.79) ; v5(91.07,51.38) v4(91.3,51.61) ; v4(20.95,47.2) 20.96,47.21 v5(21.28,47.21) ; v5(109.69,52.29) 109.85,52.14 v4(110.06,52.14) ; v5(89.22,52.03) 89.31,52.03 89.45,52.17 v4(89.53,52.17) ; v5(22.93,50.97) v4(22.7,50.74) ; v5(67.66,46.56) v4(67.43,46.79) ; v4(69.82,36.16) v5(70.06,36.39) ; v5(22.28,48.37) v4(22.05,48.14) ; v5(25.53,54.22) v4(25.3,54.46) ; v5(91.15,35.02) v4(91.15,34.69) ; v5(24.88,55.52) v4(24.65,55.76) ; v5(93.75,35.74) v4(93.99,35.51) ; v4(86.31,53.6) 86.54,53.6 v5(86.72,53.43) ; v4(100.02,56.75) 100.02,56.84 v5(100.28,57.09) ; v5(86.12,35.02) v4(86.12,34.69) ; v5(26.8,47.21) v4(26.45,47.21) ; v4(104.54,41.5) 104.54,41.21 v5(104.49,41.16) ; v5(67.01,52.84) v4(66.68,52.84) ; v4(76.62,51.65) 76.62,51.59 76.42,51.38 v5(76.28,51.38) ; v4(94.93,54.63) v5(94.7,54.4) ; v5(20.36,47.21) v4(20.02,47.21) ; v5(76.44,37.04) v4(76.67,36.81) ; v4(92.23,49.58) v5(91.99,49.81) ; v5(23.12,47.21) v4(22.78,47.21) ; v5(20.33,56.17) 20.34,56.17 v4(20.71,55.81) 20.98,55.53 v5(20.98,55.52) ; v4(62.57,20.05) 62.78,19.83 v5(62.82,19.83) ; v5(83.73,38.34) v4(83.96,38.11) ; v5(21.63,50.97) v4(21.4,51.21) ; v5(25.53,50.97) v4(25.3,50.74) ; v5(15.04,6.94) v4(15.37,6.94) ; v5(102.36,44.96) v4(102.59,45.19) ; v5(106.51,38.34) v4(106.75,38.11) ; v5(25.53,53.57) v4(25.3,53.81) ; v5(86.46,38.34) v4(86.7,38.11) ; v5(84.37,26.23) v4(84.14,26.47) ; v5(86.46,37.69) v4(86.7,37.46) ; v5(73.53,32.81) v4(73.53,33.31) v5(73.53,33.82) ; v5(86.74,29.19) 86.74,29.48 v4(86.79,29.52) ; v5(66.26,53.29) v4(65.92,53.16) v5(65.67,52.91) ; v5(103.01,40.76) v4(103.24,40.99) ; v5(60.87,19.03) v4(60.62,19.25) ; v5(92.26,53.39) v4(92.49,53.62) ; v5(81.45,40.38) v4(81.68,40.62) ; v5(73.7,38.99) v4(73.47,38.76) ; v5(97.16,46.64) v4(97.39,46.87) ; v5(104,51.38) v4(104.24,51.61) ; v5(68.31,42.91) v4(68.08,43.15) ; v5(66.13,42.79) v4(65.9,43.02) ; v5(79.64,39.47) 79.64,39.46 v4(79.41,39.23) v5(79.17,38.99) ; v5(60.87,18.23) v4(60.62,18.45) ; v5(91.93,37.69) v4(92.17,37.46) ; v5(97.16,48.32) v4(97.39,48.55) ; v5(22.93,48.37) v4(22.7,48.14) ; v5(24.23,50.97) v4(24,50.74) ; v5(23.58,52.27) v4(23.35,52.04) ; v5(95.58,37.04) v4(95.81,37.28) ; v5(25.53,50.32) v4(25.3,50.09) ; v4(66.21,18.53) 66.71,19.03 v5(66.72,19.03) ; v5(67.66,42.91) v4(67.43,43.15) ; v5(103.74,35.02) v4(103.74,34.69) ; v5(101.23,52.68) v4(101.47,52.91) ; v5(20.33,55.52) v4(20.1,55.76) ; v5(72.79,37.04) v4(72.56,36.81) ; v4(10.11,52.82) v10(9.81,52.67) ; v5(84.64,38.34) v4(84.87,38.11) ; v5(72.79,38.99) v4(72.56,38.76) ; v5(68.24,38.99) v4(68,38.76) ; v4(6.38,72.35) v5(6.05,72.13) ; v5(66.13,50.37) v4(66.36,50.6) ; v4(6.38,66.7) v5(6.05,66.91) ; v5(78.24,35.11) 78.37,34.98 v4(78.57,34.98) ; v5(81.91,38.34) v4(82.14,38.11) ; v5(67.66,44.67) v4(67.43,44.91) ; v5(24.04,47.21) v4(23.7,47.21) ; v5(67.37,20.63) v4(67.62,20.85) ; v5(100.31,51.38) v4(100.54,51.61) ; v5(24.96,47.21) v4(24.61,47.21) ; v5(63.47,20.63) 63.27,20.8 v4(63.22,20.85) ; v5(81,36.39) v4(81.23,36.16) ; v5(80.05,53.39) 80.26,53.39 v4(80.37,53.5) ; v5(65.48,42.79) v4(65.25,43.02) ; v5(80.08,39.92) 79.65,39.92 v4(79.63,39.9) 79.62,39.92 v5(79.17,39.92) ; v5(65.48,37.75) v4(65.75,37.94) ; v5(77.35,37.04) v4(77.58,36.81) ; v5(204.81,55.11) v4(204.42,55.11) ; v5(24.88,49.02) v4(24.65,48.79) ; v5(60.87,21.43) v4(60.62,21.65) ; v5(88.63,35.02) v4(88.75,34.71) ; v4(63.22,21.65) 63.27,21.6 v5(63.47,21.43) ; v5(75.53,37.04) v4(75.29,36.81) ; v5(66.78,42.79) v4(66.55,43.02) ; v5(85.59,53.43) v4(85.83,53.66) ; v5(19.68,50.97) v4(19.45,51.21) ; v4(6.38,51.48) v5(6.05,51.69) ; v4(74.14,37.15) 74.5,37.15 v5(74.62,37.04) ; v5(107.93,32.75) 107.93,32.62 v4(108.11,32.44) ; v5(62.82,20.63) v4(62.57,20.85) ; v5(24.23,54.22) v4(24,54.46) ; v5(91.99,50.73) v4(92.23,50.96) ; v5(24.23,52.92) v4(24,52.69) ; v5(81.83,51.38) v4(82.07,51.61) ; v5(74.79,33.07) v4(74.79,32.74) ; v5(93.47,18.23) 93.47,18.58 v4(93.47,18.58) ; v5(15.04,5.54) v4(15.38,5.54) ; v5(98.46,46.64) v4(98.69,46.87) ; v5(65.71,46.56) v4(65.48,46.79) ; v5(87.37,54.4) 87.09,54.11 v4(87.09,53.67) v5(87.37,53.39) ; v5(70.97,38.99) v4(70.74,38.76) ; v5(83.6,33.82) v4(83.6,34.15) ; v5(97.81,44.12) v4(98.04,44.35) ; v5(5.49,71.86) v4(5.16,71.86) ; v5(15.04,10) v4(15.37,10) ; v5(65.52,32.75) v4(65.29,32.51) ; v5(84.64,37.04) v4(84.87,36.81) ; v5(76.44,38.99) v4(76.67,39.23) ; v5(71.88,38.99) v4(71.65,38.76) ; v5(101.71,46.64) v4(101.94,46.87) ; v5(84.6,50.73) v4(84.84,50.96) ; v5(80.08,38.99) v4(80.08,39.37) ; v5(73.7,37.04) v4(73.47,36.81) ; v5(24.23,48.37) v4(24,48.14) ; v5(20.33,50.32) v4(20.1,50.56) ; v5(72.27,35.02) v4(72.51,34.79) ; v5(83.68,49.81) v4(83.91,49.58) ; v5(24.72,76.43) 24.79,76.37 24.79,76.07 v4(24.81,76.06) 24.82,76.06 24.87,76.06 25.22,76.42 v5(25.22,76.43) ; v4(11.22,55.29) 10.98,55.06 v10(10.9,55.06) ; v5(70.29,54.4) v4(70.67,54.4) ; v5(75.07,39.46) v4(74.84,39.22) ; v5(77.31,33.07) v4(77.31,32.74) ; v5(24.88,48.37) v4(24.65,48.14) ; v5(94.93,35.02) v4(95.16,34.79) ; v5(99.58,54.4) 99.66,54.31 v4(100.33,54.31) ; v4(9.32,50.97) v10(9.32,51.3) ; v5(97.16,44.12) v4(97.39,44.35) ; v5(66.78,40.27) v4(67.11,40.27) ; v5(97.81,42.44) v4(98.04,42.67) ; v5(71.01,35.02) v4(71.01,34.69) ; v5(23.58,55.52) v4(23.35,55.76) ; v5(99.11,41.6) v4(99.34,41.83) ; v5(102.36,40.76) v4(102.59,40.99) ; v4(15.37,8.45) v5(15.04,8.45) ; v5(67.33,39.01) v4(67.1,39.25) ; v4(95,51.61) v5(94.77,51.38) ; v5(15.04,11.51) v4(15.37,11.51) ; v5(67,52.19) v4(67.24,52.43) ; v5(67.94,53.75) v4(68.18,53.99) ; v5(66.72,21.43) v4(66.97,21.65) ; v5(88.03,54.08) 87.69,53.73 v4(87.69,53.7) ; v5(73.52,51.38) 73.65,51.38 v4(73.82,51.55) ; v5(86.46,35.74) v4(86.7,35.51) ; v4(10.11,51.3) v10(9.81,51.45) ; v5(91.93,38.34) v4(92.17,38.11) ; v5(22.93,51.62) v4(22.7,51.39) ; v5(24.23,51.62) v4(24,51.39) ; v5(66.87,50.37) v4(67.1,50.6) ; v5(102.87,36.39) v4(103.1,36.16) ; v5(68.5,33.82) 68.49,33.82 v4(68.18,33.91) ; v5(60.87,19.83) v4(60.62,20.05) ; v4(93.08,38.11) v5(92.84,38.34) ; v5(75.37,49.81) v4(75.13,49.58) ; v5(67.46,34) v4(67.13,34) ; v5(95.58,35.74) v4(95.81,35.98) ; v5(292.33,47.9) 292.16,47.73 v4(292.16,47.47) ; v5(104.48,47.38) 104.5,47.35 v4(104.86,47.35) ; v4(100.69,49.4) 100.44,49.16 v5(100.41,49.16) ; v5(88.29,37.69) v4(88.52,37.46) ; v5(21.63,48.37) v4(21.4,48.14) ; v5(20.33,54.87) v4(20.1,55.11) ; v5(82.76,51.38) v4(82.99,51.61) ; v5(22.28,49.67) v4(22.05,49.44) ; v5(80.05,54.4) v4(80.29,54.63) ; v5(20.33,53.57) v4(20.1,53.81) ; v5(65.48,50.37) v4(65.15,50.37) ; v5(68.67,23.03) v4(68.43,23.27) ; v4(72.83,54.07) 72.83,54.29 v5(72.73,54.4) ; v5(79.98,51.38) v4(80.22,51.15) ; v5(103.66,47.48) v4(103.89,47.71) ; v5(81,37.69) v4(81.23,37.46) ; v5(82.82,38.34) v4(83.05,38.11) ; v5(101.06,42.44) v4(101.29,42.67) ; v5(23.58,48.37) v4(23.35,48.14) ; v5(15.81,13.62) 15.81,13.42 v4(15.59,13.2) ; v5(88.29,36.39) v4(88.52,36.16) ; v5(71.88,39.92) v4(72.11,40.15) ; v4(92.77,39.49) 92.77,39.84 v5(92.84,39.92) ; v5(65.38,36.49) 65.45,36.49 v4(65.65,36.69) ; v5(20.98,50.32) v4(20.75,50.56) ; v5(79.06,51.38) v4(79.29,51.15) ; v5(69.32,21.43) v4(69.57,21.22) ; v5(72.79,37.69) v4(72.56,37.46) ; v5(21.63,51.62) v4(21.4,51.86) ; v5(88.29,38.34) v4(88.52,38.11) ; v5(81.08,35.02) v4(81.08,34.64) ; v5(62.17,19.03) v4(61.92,19.25) ; v5(22.28,50.97) v4(22.05,50.74) ; v4(81.21,52.36) 80.91,52.66 v5(80.91,52.68) ; v4(99.01,51.3) 99.37,51.3 v10(99.61,51.55) ; v5(81,38.34) v4(81.23,38.11) ; v5(61.52,21.43) v4(61.27,21.65) ; v5(103.01,45.8) v4(103.24,46.03) ; v5(60.87,20.63) v4(60.62,20.85) ; v5(78.14,49.81) v4(78.37,49.58) ; v5(89.16,53.43) v4(89.39,53.66) ; v5(103.01,47.48) v4(103.24,47.71) ; v5(101.06,44.12) v4(101.29,44.35) ; v5(86.97,19.83) v4(87.23,20.05) ; v5(67.33,41.44) v4(67.09,41.66) ; v5(82.49,53.39) v4(82.73,53.62) ; v5(106.44,44.28) v4(106.67,44.51) ; v5(70.06,37.69) v4(69.82,37.46) ; v5(24.88,49.67) v4(24.65,49.44) ; v5(24.23,55.52) v4(24,55.76) ; v5(67.66,48.44) v4(67.43,48.68) ; v5(101.05,38.34) v4(100.73,38.02) ; v5(22.28,54.22) v4(22.05,54.46) ; v5(98.7,35.02) v4(98.94,34.79) ; v5(84.86,35.02) v4(85.09,34.79) ; v5(26.18,53.57) v4(25.95,53.81) ; v5(62.82,21.43) v4(62.57,21.65) ; v4(28.05,72.41) 28.05,72.11 v5(28.23,71.93) ; v5(87.37,50.73) v4(87.61,50.96) ; v5(40.29,51.21) 39.83,51.21 v4(39.78,51.26) ; v4(10.26,56.92) v10(10.68,56.92) ; v5(75.17,54.4) v4(75.45,54.12) ; v5(101.06,39.92) v4(101.29,40.15) ; v5(98.46,45.8) v4(98.69,46.03) ; v5(28.23,76.93) v4(28.99,76.93) ; v4(9.86,54.84) v10(10.19,54.84) ; v5(19.68,50.32) v4(19.45,50.56) ; v5(72.79,36.39) v4(72.56,36.16) ; v5(84.64,36.39) v4(84.87,36.16) ; v5(70.28,50.27) v4(70.52,50.04) ; v5(97.14,54.4) v4(97.14,54.73) ; v5(90.11,35.74) v4(90.34,35.51) ; v5(22.93,55.52) v4(22.7,55.76) ; v5(81,37.04) v4(81.23,36.81) ; v5(69.32,20.63) v4(69.57,20.42) ; v4(10.11,55.41) v10(10.4,55.56) ; v5(89.22,49.81) 89.22,49.56 v4(89.09,49.43) ; v5(69.82,52.03) v4(70.06,52.26) ; v5(75.53,38.99) v4(75.53,39.32) ; v5(69.61,48.44) v4(69.38,48.68) ; v5(70.26,42) v4(70.03,42.24) ; v4(83.83,52.99) 83.83,52.85 v5(83.66,52.69) ; v5(23.58,49.02) v4(23.35,48.79) ; v5(70.26,39.97) v4(70.49,40.2) ; v5(68.02,20.63) v4(68.27,20.85) ; v5(19.68,53.57) v4(19.45,53.81) ; v5(74.16,39.46) v4(74.39,39.22) ; v5(87.37,39.92) v4(87.04,39.92) ; v5(88.29,37.04) v4(88.52,36.81) ; v5(23.58,52.92) v4(23.35,52.69) ; v5(103.66,43.28) v4(103.89,43.51) ; v5(204.82,56.61) v4(204.44,56.61) ; v5(22.28,51.62) v4(22.05,51.39) ; v5(70.29,53.39) v4(70.52,53.62) ; v5(90.15,50.73) v4(90.38,50.96) ; v4(10.21,72.14) 10.22,72.14 10.26,72.14 10.54,71.99 10.57,71.98 v10(10.57,71.97) ; v5(103.66,48.32) v4(103.89,48.55) ; v5(75.17,53.39) v4(75.4,53.62) ; v5(68.67,19.03) v4(68.92,19.25) ; v5(67,51.06) v4(67.24,51.3) ; v5(93.75,37.69) v4(93.99,37.46) ; v5(67.33,35.28) v4(67.05,35.12) ; v5(96.61,51.38) v4(96.86,51.63) ; v5(107.74,45.32) v4(107.97,45.56) ; v5(101.71,42.44) v4(101.94,42.67) ; v4(11.13,68.17) v10(10.8,68.17) ; v5(5.49,67.16) v4(5.37,66.81) ; v4(6.38,57.13) v5(6.05,56.91) ; v5(20.98,48.37) v4(20.75,48.14) ; v5(77.21,51.38) v4(77.45,51.61) ; v5(80.91,49.81) v4(81.14,49.58) ; v5(77.35,38.99) v4(77.58,39.23) ; v5(5.49,51.94) v4(5.37,51.59)
  IN3 w0.305: v5(65.88,30.01) 65.94,29.95 65.94,29.77 v4(65.94,29.57) ; v5(82.61,20.1) 82.61,20.15 v4(82.39,20.36)
  IN3 w0.356: v5(305.8,25.82) 305.75,25.82 v4(305.5,25.58) ; v4(60.44,14.85) 60.39,14.9 v5(60.39,15.43) ; v10(83.65,14.85) 83.65,14.85 83.31,14.85 v4(83.29,14.83) ; v10(93.82,13.95) 93.89,14.01 v4(94.19,14.01)
  IN3 w0.381: v5(86.8,30.03) v4(86.8,30.36) ; v4(81.25,21.61) 81.42,21.44 v5(81.76,21.44) ; v4(299.38,54.5) 299.38,54.53 v5(299.79,54.93) ; v4(59.88,14.84) v10(59.47,14.84) ; v5(56.35,30.38) v4(56.01,30.38) ; v5(290.99,32.24) 290.99,32.59 v4(290.99,32.6)
  IN3 w0.508: v10(76.54,14.06) 76.49,14.06 76.46,14.09 v4(76.17,14.09) ; v10(77.95,14.05) 77.99,14.09 v4(78.39,14.09) ; v5(294.99,51.38) v4(294.99,50.76)
  GND4 w0.089: 92.11,77.93 92.19,78.01 93.59,78.01 93.69,77.92 ; 218.54,78.01 217.14,78.01
  GND4 w0.203: H9.1 290.64,53.54 ; H9.1 287,53.54 ; H9.1 288.82,57.86 ; H9.1 291.32,55.36 ; H9.1 287,57.18 ; H9.1 290.64,57.18 ; H9.1 288.82,52.86 ; H9.1 286.31,55.36 ; JUSBC2.3 3.34,65.94 ; JUSBC2.3 1.9,64.34 ; JUSBC2.3 3.34,65.14 ; JUSBC2.3 3.34,64.34 ; JUSBC2.3 1.9,65.94 ; JUSBC2.3 0.45,64.34 ; JUSBC2.3 0.45,65.94 ; JUSBC2.3 0.45,65.14 ; 5.64,59.31 JUSBC1.2 ; JUSBC1.2 8.25,58.56 ; JUSBC1.2 6.95,59.31 ; JUSBC1.2 6.95,57.81 ; JUSBC1.2 8.25,57.81 ; JUSBC1.2 8.25,59.31 ; JUSBC1.2 5.64,58.56 ; H32.1 4.13,46.19 ; H32.1 1.82,43.87 ; H32.1 2.98,46.59 ; H32.1 4.13,43.87 ; H32.1 2.98,43.47 ; H32.1 4.54,45.03 ; H32.1 1.82,46.19 ; H32.1 1.41,45.03 ; 30.42,26.56 JBATT1.12 ; JBATT1.12 31.4,25.21 ; JBATT1.12 31.4,26.56 ; JBATT1.12 32.38,26.56 ; JBATT1.12 30.42,25.89 ; JBATT1.12 32.38,25.89 ; JBATT1.12 32.38,25.21 ; JBATT1.12 30.42,25.21 ; H30.1 300.14,48.91 ; H30.1 297.42,50.07 ; H30.1 297.42,47.75 ; H30.1 298.57,47.35 ; H30.1 299.73,50.07 ; H30.1 299.73,47.75 ; H30.1 298.57,50.47 ; H30.1 297.01,48.91 ; JHDMI1.5 11.69,28.8 ; JHDMI1.5 11.69,29.67 ; JHDMI1.5 10.81,28.8 ; JHDMI1.5 10.81,29.67 ; JHDMI1.5 10.7,29.23 ; JHDMI1.5 11.8,29.23 ; 1.82,76.95 H31.1 ; H31.1 2.98,76.55 ; H31.1 2.98,79.67 ; H31.1 4.13,79.27 ; H31.1 4.54,78.11 ; H31.1 1.82,79.27 ; H31.1 4.13,76.95 ; H31.1 1.41,78.11 ; 241.37,31.04 H6.1 ; H6.1 242.06,29.22 ; H6.1 245.7,32.86 ; H6.1 246.38,31.04 ; H6.1 245.7,29.22 ; H6.1 243.88,28.54 ; H6.1 243.88,33.54 ; H6.1 242.06,32.86 ; 309.95,27.86 JCR1.13 ; JCR1.13 311.05,27.86 ; JCR1.13 312.16,27.16 ; JCR1.13 312.16,26.46 ; JCR1.13 311.05,26.46 ; JCR1.13 312.16,27.86 ; JCR1.13 309.95,26.46 ; JCR1.13 309.95,27.16 ; JCR1.11 302.76,40.76 ; JCR1.11 300.54,41.46 ; JCR1.11 302.76,41.46 ; JCR1.11 300.54,40.06 ; JCR1.11 302.76,40.06 ; JCR1.11 301.65,41.46 ; JCR1.11 300.54,40.76 ; JCR1.11 301.65,40.06 ; 300.54,27.86 JCR1.10 ; JCR1.10 300.54,27.16 ; JCR1.10 300.54,26.46 ; JCR1.10 302.76,27.16 ; JCR1.10 301.65,27.86 ; JCR1.10 302.76,26.46 ; JCR1.10 302.76,27.86 ; JCR1.10 301.65,26.46 ; 311.65,43.76 JUSB1.12 ; JUSB1.12 314.17,43.76 ; JUSB1.12 314.17,44.51 ; JUSB1.12 312.91,44.51 ; JUSB1.12 314.17,43.01 ; JUSB1.12 311.65,43.01 ; JUSB1.12 312.91,43.01 ; JUSB1.12 311.65,44.51 ; H10.1 303.7,72.06 ; H10.1 299.37,70.24 ; H10.1 300.06,72.06 ; H10.1 304.38,70.24 ; H10.1 303.7,68.42 ; H10.1 301.88,72.74 ; H10.1 300.06,68.42 ; H10.1 301.88,67.74 ; JHDMI1.20 11.4,25.44 ; JHDMI1.20 10.09,25.44 ; JHDMI1.20 12.71,24.48 ; JHDMI1.20 12.71,23.53 ; JHDMI1.20 11.4,23.53 ; JHDMI1.20 12.71,25.44 ; JHDMI1.20 10.09,23.53 ; JHDMI1.20 10.09,24.48 ; H33.1 13.44,20.2 ; H33.1 10.72,19.04 ; H33.1 10.31,20.2 ; H33.1 10.72,21.36 ; H33.1 11.88,21.76 ; H33.1 11.88,18.64 ; H33.1 13.03,21.36 ; H33.1 13.03,19.04 ; JUSB2.10 6.81,2.64 ; JUSB2.10 6.81,1.14 ; JUSB2.10 5.55,2.64 ; JUSB2.10 8.07,1.14 ; JUSB2.10 5.55,1.89 ; JUSB2.10 8.07,1.89 ; JUSB2.10 5.55,1.14 ; 11.85,9.74 JUSB2.7 ; JUSB2.7 12.51,9.08 ; JUSB2.7 13.17,9.74 ; JUSB2.7 12.51,10.4 ; JUSB2.7 13.03,10.26 ; JUSB2.7 13.03,9.22 ; JUSB2.11 2.86,2.64 ; JUSB2.11 2.86,1.14 ; JUSB2.11 4.12,1.14 ; JUSB2.11 1.6,2.64 ; JUSB2.11 1.6,1.14 ; JUSB2.11 1.6,1.89 ; JUSB2.11 4.12,2.64 ; JUSB2.11 4.12,1.89 ; JUSB2.13 6.81,18.34 ; JUSB2.13 5.55,18.34 ; JUSB2.13 8.07,17.59 ; JUSB2.13 5.55,16.84 ; JUSB2.13 8.07,18.34 ; JUSB2.13 6.81,16.84 ; JUSB2.13 5.55,17.59 ; JUSB1.7 303.26,52.27 ; JUSB1.7 302.74,51.09 ; JUSB1.7 303.26,50.95 ; JUSB1.7 303.92,51.61 ; JUSB1.7 302.6,51.61 ; JUSB1.7 302.74,52.13 ; 12.36,30.3 JHDMI1.8 ; JHDMI1.8 13.35,30.74 ; JHDMI1.8 13.24,30.3 ; JHDMI1.8 13.24,31.17 ; JHDMI1.8 12.25,30.74 ; JHDMI1.8 12.36,31.17 ; 285.41,76.01 H38.1 ; H38.1 286.98,74.45 ; H38.1 288.13,74.85 ; H38.1 285.82,74.85 ; H38.1 286.98,77.57 ; H38.1 288.13,77.17 ; H38.1 288.54,76.01 ; H38.1 285.82,77.17 ; JHDMI1.17 11.8,35.23 ; JHDMI1.17 10.81,35.67 ; JHDMI1.17 11.69,34.8 ; JHDMI1.17 10.81,34.8 ; JHDMI1.17 10.7,35.23 ; JHDMI1.17 11.69,35.67 ; JUSBC2.4 8.25,64.39 ; JUSBC2.4 6.95,65.89 ; JUSBC2.4 8.25,65.89 ; JUSBC2.4 5.64,65.14 ; JUSBC2.4 8.25,65.14 ; JUSBC2.4 6.95,64.39 ; JUSBC2.4 5.64,64.39 ; JUSB2.12 4.12,18.34 ; JUSB2.12 4.12,16.84 ; JUSB2.12 2.86,16.84 ; JUSB2.12 2.86,18.34 ; JUSB2.12 1.6,18.34 ; JUSB2.12 1.6,17.59 ; JUSB2.12 4.12,17.59 ; JUSB2.12 1.6,16.84 ; JUSB1.13 308.96,44.51 ; JUSB1.13 310.22,43.76 ; JUSB1.13 308.96,43.01 ; JUSB1.13 310.22,43.01 ; JUSB1.13 307.7,43.76 ; JUSB1.13 310.22,44.51 ; JUSB1.13 307.7,43.01 ; JUSBC1.3 1.9,50.72 ; JUSBC1.3 0.45,50.72 ; JUSBC1.3 3.34,49.92 ; JUSBC1.3 3.34,50.72 ; JUSBC1.3 0.45,49.92 ; JUSBC1.3 3.34,49.12 ; JUSBC1.3 0.45,49.12 ; JUSBC1.3 1.9,49.12 ; 1.9,57.76 JUSBC1.1 ; JUSBC1.1 3.34,57.76 ; JUSBC1.1 3.34,58.56 ; JUSBC1.1 1.9,59.36 ; JUSBC1.1 0.45,57.76 ; JUSBC1.1 0.45,58.56 ; JUSBC1.1 0.45,59.36 ; JUSBC1.1 3.34,59.36 ; JHDMI1.2 13.24,27.3 ; JHDMI1.2 13.24,28.17 ; JHDMI1.2 12.8,27.19 ; JHDMI1.2 13.35,27.74 ; JHDMI1.2 12.25,27.74 ; JHDMI1.2 12.36,28.17 ; JHDMI1.2 12.36,27.3 ; JUSB1.10 310.22,60.21 ; JUSB1.10 308.96,58.71 ; JUSB1.10 308.96,60.21 ; JUSB1.10 310.22,58.71 ; JUSB1.10 307.7,60.21 ; JUSB1.10 310.22,59.46 ; JUSB1.10 307.7,59.46 ; H35.1 204.43,24.47 ; H35.1 203.27,21.75 ; H35.1 205.99,22.91 ; H35.1 205.58,21.75 ; H35.1 205.58,24.07 ; H35.1 204.43,21.35 ; H35.1 203.27,24.07 ; H35.1 202.86,22.91 ; H5.1 269.39,69.74 ; H5.1 265.07,67.92 ; H5.1 268.71,67.92 ; H5.1 268.71,71.56 ; H5.1 265.07,71.56 ; H5.1 264.38,69.74 ; H5.1 266.89,72.24 ; H5.1 266.89,67.24 ; JUSBC2.5 6.35,74.53 ; JUSBC2.5 5.65,74.53 ; JUSBC2.5 5.65,73.46 ; JUSBC2.5 7.04,74.53 ; JUSBC2.5 5.65,72.58 ; JUSBC2.5 7.04,72.58 ; JUSBC2.5 6.35,72.58 ; H37.1 219.35,77.48 ; H37.1 219.35,74.54 ; H37.1 215.87,76.01 ; H37.1 219.88,76.01 ; H37.1 217.88,74 ; H37.1 216.4,77.48 ; H37.1 216.4,74.54 ; 33.9,25.21 JBATT1.11 ; JBATT1.11 35.85,25.89 ; JBATT1.11 35.85,25.21 ; JBATT1.11 33.9,25.89 ; JBATT1.11 34.87,25.21 ; JBATT1.11 35.85,26.56 ; JBATT1.11 33.9,26.56 ; JBATT1.11 34.87,26.56 ; JUSBC1.4 8.25,50.67 ; JUSBC1.4 5.64,49.92 ; JUSBC1.4 6.95,50.67 ; JUSBC1.4 8.25,49.92 ; JUSBC1.4 8.25,49.17 ; JUSBC1.4 6.95,49.17 ; JUSBC1.4 5.64,49.17 ; 5.65,64.39 JUSBC2.6 ; JUSBC2.6 5.65,65.46 ; JUSBC2.6 5.65,66.34 ; JUSBC2.6 7.04,66.34 ; JUSBC2.6 7.04,64.39 ; JUSBC2.6 6.35,66.34 ; JUSBC2.6 6.35,64.39 ; 11.4,38.03 JHDMI1.23 ; JHDMI1.23 10.09,38.98 ; JHDMI1.23 12.71,39.94 ; JHDMI1.23 12.71,38.98 ; JHDMI1.23 10.09,39.94 ; JHDMI1.23 10.09,38.03 ; JHDMI1.23 11.4,39.94 ; JHDMI1.22 4.75,40.48 ; JHDMI1.22 1.35,40.48 ; JHDMI1.22 1.35,41.44 ; JHDMI1.22 4.75,41.44 ; JHDMI1.22 3.05,41.44 ; JHDMI1.11 11.69,31.8 ; JHDMI1.11 10.81,32.67 ; JHDMI1.11 10.7,32.23 ; JHDMI1.11 11.8,32.23 ; JHDMI1.11 10.81,31.8 ; JHDMI1.11 11.69,32.67 ; 242.92,74.09 H34.1 ; H34.1 244.08,76.81 ; H34.1 245.64,75.25 ; H34.1 242.92,76.41 ; H34.1 245.23,74.09 ; H34.1 242.51,75.25 ; H34.1 245.23,76.41 ; H34.1 244.08,73.69 ; 91.4,74.54 H36.1 ; H36.1 92.88,74 ; H36.1 91.4,77.48 ; H36.1 94.88,76.01 ; H36.1 94.35,74.54 ; H36.1 94.35,77.48 ; H36.1 90.87,76.01 ; 309.95,41.46 JCR1.12 ; JCR1.12 311.05,40.06 ; JCR1.12 312.16,41.46 ; JCR1.12 312.16,40.76 ; JCR1.12 312.16,40.06 ; JCR1.12 311.05,41.46 ; 1.9,72.98 JUSBC2.1 ; JUSBC2.1 3.34,73.78 ; JUSBC2.1 3.34,74.58 ; JUSBC2.1 0.45,73.78 ; JUSBC2.1 1.9,74.58 ; JUSBC2.1 0.45,72.98 ; JUSBC2.1 0.45,74.58 ; JUSBC2.1 3.34,72.98 ; 5.64,74.53 JUSBC2.2 ; JUSBC2.2 8.25,73.03 ; JUSBC2.2 5.64,73.78 ; JUSBC2.2 8.25,73.78 ; JUSBC2.2 8.25,74.53 ; JUSBC2.2 6.95,74.53 ; JUSBC2.2 6.95,73.03 ; JBATT1.14 32.38,11.81 ; JBATT1.14 31.4,11.81 ; JBATT1.14 30.42,11.14 ; JBATT1.14 31.4,10.46 ; JBATT1.14 30.42,11.81 ; JBATT1.14 30.42,10.46 ; JBATT1.14 32.38,10.46 ; JBATT1.14 32.38,11.14 ; 5.65,57.36 JUSBC1.5 ; JUSBC1.5 7.04,57.36 ; JUSBC1.5 6.35,59.31 ; JUSBC1.5 5.65,58.24 ; JUSBC1.5 5.65,59.31 ; JUSBC1.5 7.04,59.31 ; JUSBC1.5 6.35,57.36 ; JUSB2.4 11.71,7.4 ; JUSB2.4 12.37,6.74 ; JUSB2.4 11.71,6.08 ; 311.65,59.46 JUSB1.11 ; JUSB1.11 312.91,60.21 ; JUSB1.11 311.65,60.21 ; JUSB1.11 314.17,59.46 ; JUSB1.11 311.65,58.71 ; JUSB1.11 314.17,60.21 ; JUSB1.11 312.91,58.71 ; JUSB1.11 314.17,58.71 ; JUSBC1.6 6.35,51.12 ; JUSBC1.6 7.04,51.12 ; JUSBC1.6 5.65,50.25 ; JUSBC1.6 7.04,49.17 ; JUSBC1.6 5.65,51.12 ; JUSBC1.6 6.35,49.17 ; JUSBC1.6 5.65,49.17 ; JUSB1.4 304.06,55.27 ; JUSB1.4 303.4,54.61 ; JUSB1.4 304.06,53.95 ; JBATT1.13 34.87,11.81 ; JBATT1.13 33.9,11.14 ; JBATT1.13 35.85,11.14 ; JBATT1.13 33.9,11.81 ; JBATT1.13 35.85,10.46 ; JBATT1.13 33.9,10.46 ; JBATT1.13 34.87,10.46 ; JBATT1.13 35.85,11.81 ; 3.05,22.03 JHDMI1.21 ; JHDMI1.21 4.75,22.98 ; JHDMI1.21 1.35,22.03 ; JHDMI1.21 1.35,22.98 ; JHDMI1.21 4.75,22.03
  BOTTOM w0.076: 28.58,55.03 UT2.AC6 ; UT2.A22 v11(18.98,47.67) v11(19.44,47.67) v11(19.44,47.21) 18.97,46.73 v11(18.09,46.73) ; 20.18,46.96 19.48,46.26 19.45,46.26 19.43,46.23 ; UCPU1.J33 v5(69.76,35.38) ; UCPU1.B25 v5(65.13,40.32)
  BOTTOM w0.102: PC1417.2 v3(119.54,40.4) ; v3(48.73,39.5) 48.73,40.16
  BOTTOM w0.127: 54.15,23.2 v3(54.95,23.2) ; v3(121.98,65.63) 121.98,64.84 ; v5(107.72,53.56) 107.77,53.58 108.04,54.21 108.27,54.78 UCPU1.CN2 ; 125.54,64.76 125.55,64.78 v3(125.55,65.61) ; v6(57.02,25.35) v3(57.02,26.17) ; v3(73.94,27.9) 73.64,27.9 v6(73.1,28.43) ; v5(56.35,30.38) v3(54.97,30.38)
  BOTTOM w0.203: UCPU1.V33 74.79,34.92 74.99,34.72 v5(74.99,34.7) ; PU300.2 v11(199.39,44.01) ; v5(77.73,35.08) 77.37,35.08 UCPU1.AB33 ; v5(78.24,35.11) 78.28,35.06 78.53,35.06 UCPU1.AD33 ; v11(199.39,42.5) 199.48,42.41 PU300.6 ; PU1000.13 v11(74.94,75.36) 74.94,75.94 PC1005.2 ; UD2.D12 v5(62.17,25.87) ; UCPU1.CM1 107.93,55.65 v11(108.81,56.53) 108.9,56.62 v11(108.9,57.08) v11(108.9,58.3) 108.9,58.89 v11(109.07,59.07) v11(109.75,59.07) 109.99,59.31 v11(109.99,60.07) v11(109.99,61.65) v11(109.99,62.84) 109.99,63.13 109.78,63.33 v11(109.73,63.33) 109.73,63.33 v11(108.03,63.33) 107.98,63.33 107.98,63.33 v11(106.02,63.33) 105.96,63.33 105.76,63.14 v11(105.76,62.82) 105.85,62.74 105.85,61.51 v11(105.91,61.45) 105.89,61.43 105.89,59.97 v11(106.12,59.74) 106.12,59.43 v11(106.34,59.22) 106.54,59.01 v11(107.21,59.01) 107.21,58.23 v11(107.27,58.16) v11(107.27,57.08) 107.27,56.7 v11(107.06,56.48) 106.94,56.36 v11(106.94,55.38) 106.29,54.73 v11(106.24,54.73) v11(106.24,54.08) v5(106.24,53.43) 106.28,53.39 v5(106.89,53.39) 107.55,53.39 v5(107.72,53.56) ; PC1020.2 110.72,69.68 110.81,69.77 110.81,69.87 110.81,69.87 v11(110.81,70.28) PU1001.13 ; 74.62,39 v5(74.16,39.46) ; 74.62,39 v5(75.07,39.46) ; 74.62,39 UCPU1.V27 ; v2(88.27,18.23) 88.27,17.62 v5(88.31,17.58) ; UD3.P12 v5(92.17,25.87)
  BOTTOM w0.229: UCPU1.L35 v5(71.01,34.17) ; v5(65.79,35.19) 65.79,35.19 66.08,35.19 UCPU1.C33 ; UCPU1.F33 v5(67.63,34.67) ; UCPU1.E31 v5(67.67,36.49)
  BOTTOM w0.254: v6(206.43,59.82) 206.23,59.61 JNGFF2.21 204.3,59.61 v6(204.2,59.72) ; UCPU1.CN2 108.26,54.88 108,55.14 108,55.2 107.99,55.21 107.99,55.24 107.93,55.29 UCPU1.CM1 ; CD61.2 65.7,29.83 v5(65.88,30.01) ; JNGFF3.45 209.29,29.3 v11(209.17,29.18) ; v6(209.06,21.75) 209.11,21.8 JNGFF3.75 ; UCPU1.T36 v5(73.53,32.81) ; v11(84.86,33.07) 84.86,32.66 85.39,32.13 CC34.2 CD64.2 85.39,28.71 85.67,28.43 v5(85.67,26.23) ; v6(203.99,53.37) 204.12,53.37 204.36,53.61 JNGFF2.45 ; UCPU1.BM35 v5(96.19,33.8) ; v11(97.43,27.47) 97.37,27.4 v11(97.37,26.87) 97.37,26.12 97.56,25.93 v11(97.56,25.93) 97.23,25.6 v11(96.86,25.6) 96.45,25.6 96.3,25.45 v11(96.3,25.29) v11(96.3,24.47) v11(96.3,23.58) 96.3,23.42 96.58,23.15 v11(96.77,23.15) v11(97.71,23.15) v11(98.65,23.15) v11(99.48,23.15) v11(100.29,23.15) 100.6,23.46 v11(100.6,23.77) 100.6,24.38 v11(100.82,24.6) 100.82,25.14 v11(100.76,25.2) 100.44,25.52 v11(100.44,25.52) 100.29,25.67 v11(99.89,25.67) 99.62,25.67 v11(99.36,25.93) 99.36,26.43 v11(99.16,26.64) v11(99.16,27.25) ; PU1101.11 130.64,66.46 PC1114.2 ; UCPU1.AP3 84.93,53.9 v5(84.93,53.9) ; v11(18.09,46.73) 17.68,46.32 v11(17.68,46.23) 17.67,46.23 v11(17.67,44.76) v11(16.72,44.76) 16.64,44.76 v11(16.32,44.44) v11(16.32,43.57) v11(16.32,42.52) 16.32,41.63 v11(16.61,41.34) v11(18.35,41.34) v11(19.88,41.34) 20.24,41.34 20.53,41.63 v11(20.53,42.44) v11(20.53,43.4) 20.53,44.43 v11(20.54,44.44) v11(20.23,44.76) v11(19.43,44.76) v11(19.43,46.1) 19.43,46.23 ; PC1419.2 126.22,49.59 v6(126.15,49.52) 126.35,49.32 PU1401.11 ; CT108.1 9.6,75.08 v6(8.9,75.77) ; UCPU1.BF3 v5(92.4,54.09) ; CC35.2 80.16,32.31 79.82,32.64 v5(79.82,33.07) ; UD3.P12 92.07,26.34 CD75.2 ; PC133.2 45.83,19.92 v6(45.99,20.07) ; UCPU1.CF11 v5(104.25,49.14) ; PR607.2 46.66,24.56 47.13,25.03 v6(47.19,25.03) 47.23,25.03 47.45,24.82 PU600.15 ; v6(209.1,26.23) 209.16,26.3 JNGFF3.57 ; JNGFF3.1 v6(208.76,40.3) ; JNGFF3.51 v6(209.09,27.8) ; v6(299.39,59.87) 299.31,59.8 PU401.10 ; v5(108.74,52.86) UCPU1.CN5 ; v5(69.32,19.03) 69.32,18.88 v5(69.97,18.23) ; JNGFF3.63 209.07,24.8 v6(209.03,24.84) ; JNGFF3.69 209.09,23.3 v6(209.06,23.33) ; 86.75,29.2 v5(86.74,29.19) ; UCPU1.CM5 v5(107.94,53.12) ; JKB1.31 v6(225.33,16.85) ; v5(100.28,57.09) 100.3,57.12 CC80.2 ; 68.49,26.7 68.47,26.68 67.71,26.68 67.37,26.34 v9(67.37,26.23) ; PC411.2 41.08,42.95 41.47,42.56 v11(41.47,41.91) ; JNGFF1.45 v6(268.65,25.23) ; v5(86.12,33.82) UCPU1.AT36 86.12,32.04 87.17,30.99 CC36.2 ; UD3.T12 93.03,26.67 93.03,28.54 93.24,28.74 CD68.2 ; v6(216.52,35.72) 216.85,36.05 JNGFF3.18 ; JNGFF2.57 v6(204.18,50.61) ; JBL1.1 v11(216.96,18.65) ; v6(204.12,61.19) 204.19,61.11 JNGFF2.15 ; JFP1.15 311,64.32 v6(310.99,64.33) ; CC32.2 82.34,30.63 v5(82.34,33.07) ; UCPU1.AH35 v5(81.08,35.02) ; v5(90.87,26.23) 90.9,26.26 CD76.2 90.9,29.63 CC33.2 CC38.2 89.73,29.5 CD70.2 ; JESPI1.9 v6(225.13,71.16) ; v6(227.3,16.83) 226.93,17.21 JKB1.29 ; JNGFF3.76 211.48,41.4 212.41,40.47 v6(212.49,40.47) ; UT1.A1 28.26,69.81 v5(28.49,69.69) ; JFP1.9 v6(310.98,65.82) ; v6(209.06,35.8) 209.07,35.8 JNGFF3.19 ; JNGFF3.13 209.09,37.3 v6(209.05,37.34) ; v6(211.37,39) 211.17,38.8 JNGFF3.7 ; UCPU1.Y35 v5(76.05,34.15) ; v6(45.83,22.84) 45.64,22.65 PC132.2 ; JNGFF1.57 v6(271.65,25.23) ; CD73.2 88.44,30.2 CC37.2 88.04,31.15 87.37,31.81 UCPU1.AV36 ; U16.A4 v11(201.18,69.07) ; PC913.2 v11(40.76,61.08) ; UD2.B12 v5(60.87,25.87) ; v6(51.4,25.34) 51.33,25.27 PU600.4 ; PC512.2 v5(108.27,22.44) ; JNGFF1.51 v6(270.15,25.23)
  BOTTOM w0.305: v6(204.19,64.24) 204.31,64.11 JNGFF2.3 ; CD65.2 64.4,27.45 65.42,26.43 v5(65.42,26.23) ; JPTN1.4 v6(294.35,75.29) ; v6(231.62,71.41) 232.19,71.41 232.63,71.84 JDEG1.10 ; v5(86.8,30.03) 86.8,30.02 86.75,29.97 CD85.2 86.75,26.45 UD3.F12 ; v5(82.61,20.1) 82.26,19.75 CD49.2 ; JNGFF1.11 260.15,24.85 260.35,25.05 v6(260.35,25.33) ; JNGFF1.5 258.65,25.12 258.46,25.31 ; v5(63.47,26.23) 63.13,26.57 CD74.2 ; 258.46,25.31 258.46,25.3 258.15,24.99 JNGFF1.3 ; 258.46,25.31 v6(258.46,25.35) ; v11(61.86,29.1) 61.86,26.54 UD2.D12 ; v6(206.49,64.24) 206.12,64.61 JNGFF2.1 ; CC36.2 CC37.2 ; v5(68.67,26.23) 68.49,26.41 RD16.2 RD17.2 ; JSIM1.5 294.96,39.69 v6(294.77,39.69) ; v5(93.47,25.87) UD3.T12 ; v5(87.62,23.83) v5(87.62,23.03) ; v5(66.07,24.63) 66.72,23.98 v5(66.72,23.83) v5(66.72,23.03) ; JTP1.5 v11(193.12,16.76)
  BOTTOM w0.356: JDEG1.11 238.13,69.31 238.24,69.2 v6(238.24,68.66) ; CS8.2 293.56,39.05 CS7.2 ; JESPI1.12 v6(223.63,70.36) ; CD83.2 57.14,21.52 v6(57.06,21.6) ; JNGFF1.77 277.25,22.7 v6(276.81,22.26) ; CD84.2 57.19,19.74 v6(57.03,19.58) ; JESPI1.11 v6(230.13,70.44) ; JDEG1.12 v6(231.63,70.42) ; CS2.2 v6(290.42,33.42) ; CS13.2 v6(209.02,69.68) ; v6(292.33,30.56) 292.22,30.46 CS6.2
  BOTTOM w0.381: CD101.2 v3(78.71,18.27) v6(77,18.27) ; v6(71.46,14.95) 71.35,14.84 RD19.2 RD20.2 ; PR408.1 v6(299.39,59.87) ; v6(297.46,72.78) 297.24,72.56 JPTN1.5 ; CC36.2 87.17,30.39 86.81,30.03 v5(86.8,30.03) ; CD21.2 CD60.2 CD61.2 ; JPTN1.6 v6(295.13,76.51) ; RS2.2 293.72,29.99 v6(293.73,29.97) ; UC9.3 58.8,29.36 v6(58.48,29.69) ; CS3.2 v5(290.99,32.24)
  BOTTOM w0.508: JNGFF3.77 209.86,20.7 209.06,21.5 v6(209.06,21.75) ; JUSH1.28 279.99,15.46 v6(279.19,16.26) ; CD12.2 72.82,28.71 v6(73.1,28.43) ; JUSH1.27 v6(263.23,16.59) ; v6(212.56,14.08) 212.34,14.08 JBL1.6 ; JSIM1.9 v6(312.82,28.56) ; JSIM1.7 298.27,26.27 v6(297.2,26.27) ; v6(307.89,2.56) 308.3,2.15 JRTC1.2 ; CLIP6.1 v6(283.26,43.53) ; v6(295.4,61.2) 295.38,61.18 PC418.1 ; CLIP3.1 211.76,43.18 v6(212.15,42.79) ; CLIP4.1 270.27,21.9 v6(270.74,22.37) ; JRTC1.4 v6(311.15,4.27) ; JSIM1.4 304.54,41.76 v6(305.57,41.76) ; CLIP5.1 v6(250.61,43.57) ; PC414.2 300.1,56.28 v6(300.19,56.37) ; v6(204.22,66.18) 204.68,65.71 JNGFF2.76 ; v6(305.22,5.61) 304.5,6.33 JRTC1.3 ; JSIM1.C5 v6(313.23,38.33) ; JANT2.3 v6(193.67,74.72) ; PC223.2 v6(39.58,37.39) ; SW2.3 v6(196.23,60.17) ; v6(213.67,69.03) 212.36,67.73 CLIP1.1 ; H7.1 190.75,66.76 v6(190.74,66.77) ; JNGFF1.76 256.12,24.84 v6(255.57,25.39) ; v6(131.39,68.93) 131.36,68.97 PC1111.2 ; RA6.1 287.45,32.4 v6(287.4,32.46) ; v6(223.66,13) 222.92,12.26 JKB1.34 ; v6(218.04,15.28) 218.66,14.66 JBL1.5 ; JSIM1.3 312.17,42.05 v6(311.15,42.05) ; SW2.4 v6(193.11,61.14) ; JANT2.4 v6(194.63,74.37) ; JANT2.2 v6(192.71,74.33) ; v6(251.27,14) 251.68,13.59 JKB1.33 ; v6(294.76,40.29) 294.16,40.29 293.72,39.86 CS8.2 ; v6(203.22,59.18) 202.88,58.83 CLIP2.1 ; JSIM1.6 v6(295.61,29.86) ; PC420.2 v6(297.39,69.16) ; PC314.2 v6(200.94,54.3)
  vias: v2(5.47,72.38) v2(5.47,57.16) v2(5.65,72.65) v2(5.63,66.54) v2(5.68,57.42) v2(5.63,51.32) v2(5.79,72.33) v2(5.79,66.84) v2(5.79,57.11) v2(5.79,51.62) v2(6.05,72.33) v2(6.05,66.84) v2(6.05,57.11) v2(6.05,51.62) v2(7.39,72.08) v2(7.39,66.58) v2(7.39,56.87) v2(7.39,51.36) v2(7.65,72.08) v2(7.65,66.58) v2(7.65,56.87) v2(7.65,51.36) v2(7.9,72.08) v2(7.9,66.58) v2(7.9,56.87) v2(7.9,51.36) v2(8.31,72.08) v2(8.27,66.58) v2(8.31,56.87) v2(8.27,51.36) v2(8.53,66.58) v2(8.53,51.36) v2(8.97,66.27) v2(9.18,72.4) v2(9.18,70.68) v2(9.18,57.18) v2(9.18,55.46) v2(9.19,51.27) v2(9.3,68.29) v2(9.3,67.97) v2(9.23,66.27) v2(9.3,53.07) v2(9.3,52.75) v2(9.43,72.4) v2(9.43,70.68) v2(9.43,57.18) v2(9.43,55.46) v2(9.44,51.27) v2(9.7,69.78) v2(9.7,54.56) v2(9.74,68.95) v2(9.74,53.73) v2(10.03,69.78) v2(10.07,68.95) v2(10.03,54.56) v2(10.07,53.73) v2(10.83,70.63) v2(10.83,70.37) v2(10.83,68.29) v2(10.83,68.04) v2(10.83,55.42) v2(10.83,55.17) v2(11.37,53.09) v2(11.37,52.83) v2(13.12,73.32) v2(13.44,73.37) v2(14.43,60.63) v2(14.43,54.91) v2(14.96,33.72) v2(15.31,54) v2(15.34,59.13) v2(16.68,40.14) v2(16.68,39.88) v2(16.68,38.91) v2(16.68,38.65) v2(17.65,52.39) v2(17.65,52.1) v2(17.65,51.81) v2(17.65,51.19) v2(17.65,50.9) v2(17.66,50.57) v2(17.77,22.94) v2(18.09,62.07) v2(18.09,61.43) v2(18.09,60.87) v2(18.09,60.24) v2(18.09,59.67) v2(18.09,59.04) v2(18.21,37.64) v2(18.39,62.07) v2(18.39,61.43) v2(18.39,60.87) v2(18.39,60.24) v2(18.39,59.66) v2(18.39,59.05) v2(18.76,29.97) v2(19.06,62.08) v2(19.06,61.75) v2(19.06,61.18) v2(19.06,60.85) v2(19.06,60.3) v2(19.06,59.98) v2(19.37,32.66) v2(19.37,31.9) v2(19.38,28.81) v2(19.38,27.06) v2(19.38,26.36) v2(19.45,41) v2(19.68,51.62) v2(19.85,58.93) v2(19.85,58.35) v2(19.83,50.98) v2(20.47,49.14) v2(20.44,40.9) v2(20.56,73.44) v2(20.56,73.18) v2(21.07,51.55) v2(21.12,49.14) v2(21.06,44.6) v2(21.63,54.22) v2(21.63,52.27) v2(21.73,49.09) v2(22.39,36.86) v2(22.39,36.59) v2(22.67,68.39) v2(23.58,48.55) v2(23.64,49.07) v2(23.65,19.58) v2(24.23,53.57) v2(24.87,73.66) v2(24.83,66.53) v2(24.97,41.59) v2(25.44,71.93) v2(25.44,64.69) v2(25.49,58.44) v2(25.47,48.65) v2(25.53,55.47) v2(25.53,54.87) v2(25.53,51.62) v2(25.53,50.5) v2(25.64,76.26) v2(26.91,74.49) v2(27.71,11.99) v2(27.78,12.93) v2(29.22,67.64) v2(29.22,67.38) v2(29.37,74.68) v2(29.44,12.36) v2(29.55,71.89) v2(29.73,75.39) v2(29.73,68.22) v2(30.02,76.04) v2(30.01,69.09) v2(30.03,76.32) v2(30.28,69.09) v2(30.7,12.91) v2(30.89,55.27) v2(31.97,76.18) v2(31.97,75.9) v2(32.69,77.3) v2(32.69,77.03) v2(36.33,63.91) v2(38.14,32.12) v2(39.43,66.01) v2(40.13,58.86) v2(40.75,39.48) v2(41.03,58.87) v2(41.57,30.54) v2(42.18,29.36) v2(43.22,12.31) v2(44.07,35.55) v2(47.76,29.36) v2(47.99,28.59) v2(47.98,23.82) v2(48.59,76.38) v2(48.86,23.38) v2(49.3,22.47) v2(49.57,22.46) v2(50.35,20.25) v2(50.36,19.99) v2(50.34,19.02) v2(50.34,18.77) v2(50.34,17.78) v2(50.34,17.52) v2(50.96,71.8) v2(63.12,77.91) v2(63.47,19.83) v2(63.83,77.92) v2(64.18,72.26) v2(64.41,50.2) v2(64.45,29.1) v2(64.54,77.92) v2(64.54,47.13) v2(65.25,77.92) v2(65.37,42.37) v2(65.66,42.36) v2(65.81,50.23) v2(65.96,77.92) v2(65.98,72.26) v2(66.46,47.15) v2(66.63,42.38) v2(67.19,42.7) v2(67.3,50.13) v2(67.37,19.83) v2(67.51,50.29) v2(67.6,51.45) v2(67.78,72.26) v2(68.02,19.83) v2(68.28,47.15) v2(68.64,42.71) v2(68.88,46.3) v2(69.32,19.83) v2(69.52,51.48) v2(69.61,51.73) v2(70.24,72.03) v2(70.33,13.95) v2(70.56,50.84) v2(70.97,13.95) v2(71.48,50.85) v2(72.41,50.85) v2(72.49,51.75) v2(72.68,47.78) v2(72.65,46.59) v2(72.65,45.39) v2(72.65,44.2) v2(72.65,43) v2(72.65,41.81) v2(72.91,46.59) v2(72.91,45.39) v2(72.91,44.2) v2(72.91,43.01) v2(72.91,41.81) v2(72.94,47.78) v2(73.04,77.88) v2(73.12,51.84) v2(73.33,50.86) v2(73.75,77.88) v2(74.46,77.88) v2(74.52,52.65) v2(74.92,51.33) v2(75.09,52.69) v2(75.17,77.88) v2(75.14,47.78) v2(75.14,46.59) v2(75.14,45.39) v2(75.17,44.2) v2(75.17,43) v2(75.17,41.81) v2(75.4,47.78) v2(75.4,46.59) v2(75.4,45.4) v2(75.42,44.2) v2(75.42,43.01) v2(75.42,41.81) v2(75.75,40.28) v2(75.88,77.88) v2(76,40.28) v2(76.16,47.81) v2(76.17,46.6) v2(76.16,45.37) v2(76.16,44.15) v2(76.42,47.82) v2(76.42,45.38) v2(76.42,44.15) v2(76.43,46.6) v2(77.57,52.6) v2(79.64,47.83) v2(79.64,46.63) v2(79.64,45.39) v2(79.66,44.14) v2(79.9,47.83) v2(79.9,46.63) v2(79.89,45.39) v2(79.92,44.15) v2(80.25,77.88) v2(80.96,77.89) v2(81.67,77.89) v2(82.38,77.89) v2(82.41,14.66) v2(83.02,48.29) v2(83.02,47.08) v2(83.02,45.88) v2(83.02,44.67) v2(83.02,43.46) v2(83.02,42.26) v2(83.27,48.29) v2(83.27,47.08) v2(83.27,45.88) v2(83.27,44.67) v2(83.27,43.47) v2(83.27,42.26) v2(84.02,40.75) v2(84.06,41.33) v2(84.31,41.33) v2(84.89,40.39) v2(85.97,47.11) v2(86,43.68) v2(86.08,14) v2(86.23,47.11) v2(86.25,43.69) v2(86.66,39.82) v2(87.12,51.69) v2(87.06,50.53) v2(87.19,47.11) v2(87.2,43.7) v2(87.26,45.29) v2(87.41,40.35) v2(87.44,47.11) v2(87.52,45.29) v2(87.46,43.7) v2(87.66,13.92) v2(87.76,50.58) v2(88.4,47.11) v2(88.35,45.27) v2(88.41,43.71) v2(88.61,45.27) v2(88.66,47.11) v2(88.67,43.71) v2(89.6,47.12) v2(89.63,43.71) v2(89.85,51.85) v2(89.85,47.12) v2(89.89,43.71) v2(90.87,19.83) v2(91.52,20.63) v2(91.81,39.81) v2(92.71,48.16) v2(92.71,46.97) v2(92.71,44.58) v2(92.71,43.39) v2(92.7,42.19) v2(92.73,45.77) v2(92.82,19.83) v2(92.96,48.16) v2(92.96,46.97) v2(92.99,45.78) v2(92.97,44.58) v2(92.97,43.39) v2(92.95,42.19) v2(93.66,40.42) v2(95.3,46.61) v2(95.55,48.58) v2(95.55,48.01) v2(95.55,47.44) v2(95.55,46.62) v2(96.21,46.61) v2(96.4,47.73) v2(96.4,47.47) v2(96.47,46.62) v2(97.7,42.98) v2(104,49.47) v2(105.15,45.74) v2(106.19,49.3) v2(106.77,51.45) v2(107.03,45.7) v2(107.35,50.7) v2(107.48,40.51) v2(109.22,51.87) v2(111.77,73.33) v2(112.03,73.33) v2(112.69,73.32) v2(112.97,73.32) v2(123.26,52.82) v2(123.25,52.55) v2(124.03,77.91) v2(124.39,52.84) v2(124.38,52.57) v2(124.74,77.91) v2(125.45,77.91) v2(126.16,77.91) v2(127.66,68.38) v2(127.66,68.08) v2(127.67,67.47) v2(127.67,67.16) v2(128.79,40.11) v2(128.79,39.11) v2(195.01,31.92) v2(195.62,69.69) v2(196.19,69.69) v2(200.06,44.54) v2(200.06,42.4) v2(215.04,25.42) v2(236.63,39.88) v2(237.79,39.88) v2(238.03,39.22) v2(239.15,39.21) v2(258.82,29.75) v2(262.71,38.88) v2(263.5,38.91) v2(264.62,38.91) v2(266.64,61.21) v2(267.25,14.33) v2(275.32,53.74) v2(282.31,47.94) v2(282.32,46.77) v2(282.37,18) v2(286.45,64.73) v2(293.83,52.39) v2(294.37,52.91) v2(295.55,54.88) v2(297.57,36.87) v2(297.65,59.07) v2(299.63,58.39) v2(306.68,25.55) v3(50.6,30.78) v3(50.96,35.81) v3(50.96,33.24) v3(51.15,30.94) v3(56.83,39.66) v3(58.13,52.3) v3(60.51,39.68) v3(60.72,52.27) v3(62.55,39.68) v3(76.26,71.95) v3(103.48,67.66) v3(115.82,28.81) v3(118.06,57.41) v3(245.24,36.65) v4(3.27,54.94) v4(3.44,70.02) v4(4.93,71.36) v4(4.93,70.69) v4(4.93,70.02) v4(4.93,69.34) v4(4.93,68.67) v4(4.93,68) v4(4.93,67.32) v4(4.93,56.14) v4(4.93,55.47) v4(4.93,54.8) v4(4.93,54.12) v4(4.93,53.45) v4(4.93,52.78) v4(4.93,52.1) v4(7.06,68.79) v4(7.06,53.57) v4(7.3,70.05) v4(7.31,66.25) v4(7.3,54.83) v4(7.31,51.03) v4(7.52,72.39) v4(7.52,57.17) v4(7.59,76.29) v4(7.98,66.25) v4(7.98,51.03) v4(8.03,72.39) v4(8.03,57.17) v4(8.22,47.81) v4(8.32,46.77) v4(8.64,66.25) v4(8.64,65.85) v4(8.64,51.03) v4(9.02,68.58) v4(9.02,53.36) v4(9.05,72.71) v4(9.05,57.49) v4(9.3,70.36) v4(9.3,55.16) v4(11.84,52.96) v4(13.78,73.37) v4(13.93,26.51) v4(14.74,15.84) v4(16.37,40.01) v4(16.37,38.78) v4(16.38,37.61) v4(16.36,36.55) v4(18.24,61.77) v4(18.24,60.56) v4(18.24,59.36) v4(18.57,55.81) v4(18.61,17.68) v4(18.76,61.91) v4(18.74,61.02) v4(18.74,60.15) v4(19.07,75.31) v4(19.22,71.03) v4(19.23,68.42) v4(19.4,45.45) v4(19.63,17.71) v4(19.74,68.48) v4(19.74,40.67) v4(20.26,75.31) v4(20.41,71.03) v4(20.48,46.02) v4(20.89,44.99) v4(21.18,74.12) v4(21.24,67.18) v4(21.39,44.14) v4(21.62,71.1) v4(21.58,44.99) v4(21.71,74.62) v4(21.79,67.6) v4(21.85,44.3) v4(21.96,46.03) v4(22.69,36.72) v4(22.78,46.09) v4(23.06,44.5) v4(23.57,44.51) v4(24.08,44.51) v4(24.19,46.06) v4(24.38,75.03) v4(24.97,74.16) v4(24.97,46.02) v4(24.98,44.47) v4(25.6,74.53) v4(25.93,44.99) v4(26.52,45.85) v4(27.02,45.91) v4(31.6,76.03) v4(32.33,77.16) v4(32.54,45.65) v4(32.55,45.17) v4(33.01,45.15) v4(33.45,45.29) v4(39.85,48.09) v4(40.27,48.08) v4(42.3,39.89) v4(42.96,39.87) v4(43.84,78.39) v4(45.61,77.97) v4(46.84,78.02) v4(50.04,20.12) v4(50.03,18.89) v4(50.04,17.65) v4(52.41,75.55) v4(53.38,25.02) v4(53.39,23.77) v4(53.58,22.57) v4(63.22,20.05) v4(65.36,35.21) v4(66.85,77.3) v4(67.12,20.05) v4(67.62,20.05) v4(68.12,77.3) v4(69.23,77.3) v4(70.55,77.3) v4(70.78,30.02) v4(71.77,77.3) v4(72.01,71.72) v4(72.05,72.22) v4(72.81,48.09) v4(72.78,46.89) v4(72.78,45.7) v4(72.78,44.51) v4(72.78,43.31) v4(72.78,42.12) v4(72.87,71.14) v4(75.27,48.09) v4(75.27,46.89) v4(75.27,45.7) v4(75.3,44.51) v4(75.3,43.31) v4(75.3,42.12) v4(75.87,40.59) v4(76.29,48.12) v4(76.3,46.91) v4(76.29,45.68) v4(76.29,44.46) v4(77.01,77.29) v4(78.09,77.3) v4(79.31,77.3) v4(79.77,48.14) v4(79.77,46.94) v4(79.76,45.7) v4(79.79,44.45) v4(83.15,48.6) v4(83.15,47.39) v4(83.15,46.18) v4(83.15,44.98) v4(83.15,43.77) v4(83.15,42.56) v4(83.65,77.29) v4(84.18,41.64) v4(84.92,77.29) v4(86.03,77.29) v4(86.1,47.42) v4(86.13,43.99) v4(87.32,47.42) v4(87.35,77.29) v4(87.39,45.6) v4(87.33,44) v4(88.48,45.57) v4(88.57,77.29) v4(88.53,47.41) v4(88.54,44.02) v4(88.68,54.86) v4(89.02,70.32) v4(89.02,69.4) v4(89.08,76.59) v4(89.67,75.99) v4(89.66,69.86) v4(89.72,47.43) v4(89.74,77.29) v4(89.74,54.86) v4(89.76,44.02) v4(90.31,75.37) v4(90.29,70.32) v4(90.29,69.4) v4(90.7,61.73) v4(90.93,69.86) v4(91.57,70.32) v4(91.57,69.4) v4(91.78,20.85) v4(92.2,69.86) v4(92.84,70.32) v4(92.84,69.4) v4(92.83,48.47) v4(92.83,47.27) v4(92.86,46.08) v4(92.84,44.89) v4(92.84,43.69) v4(92.83,42.5) v4(93.48,69.86) v4(94.11,70.32) v4(94.11,69.4) v4(94.75,69.86) v4(95.38,70.32) v4(95.38,69.4) v4(95.42,46.92) v4(95.53,59.61) v4(95.77,77.3) v4(95.85,57.37) v4(96.02,69.86) v4(96.1,47.6) v4(96.34,46.92) v4(96.54,58.57) v4(96.7,77.3) v4(96.66,70.32) v4(96.66,69.4) v4(97.23,50.5) v4(97.59,77.27) v4(97.97,53.41) v4(98.32,58.55) v4(98.78,77.27) v4(99.45,58.88) v4(99.97,77.27) v4(100.52,53.42) v4(101.17,77.27) v4(102.02,57.19) v4(102.36,77.27) v4(102.49,15.3) v4(102.49,14.86) v4(102.93,15.28) v4(102.93,14.85) v4(103.55,77.27) v4(103.92,54.67) v4(103.91,18.36) v4(103.92,17.88) v4(104.44,62.18) v4(104.75,77.27) v4(104.89,62.38) v4(104.84,54.67) v4(105.78,54.35) v4(106.02,77.27) v4(106.54,65.25) v4(106.72,54.35) v4(107.29,77.27) v4(107.55,69.36) v4(107.93,26.07) v4(107.99,24.63) v4(108.08,36.84) v4(108.16,65.25) v4(108.56,77.27) v4(109.65,54.8) v4(109.79,65.23) v4(109.83,77.27) v4(110.31,54.8) v4(111.1,77.27) v4(111.41,65.24) v4(112.37,77.27) v4(113.64,77.27) v4(114.91,77.27) v4(116.18,77.27) v4(117.45,77.27) v4(118.72,77.27) v4(119.99,77.27) v4(121.26,77.27) v4(121.88,55.33) v4(122.53,77.27) v4(123.63,52.72) v4(124.76,54.8) v4(124.75,52.77) v4(125.73,55.51) v4(125.74,51.77) v4(125.99,54.76) v4(126,51.03) v4(126.88,46.73) v4(126.97,54.72) v4(127.22,53.97) v4(127.27,68.2) v4(127.27,67.53) v4(127.33,77.27) v4(127.6,46.73) v4(128.07,68.2) v4(128.07,67.53) v4(128.16,54.72) v4(128.42,53.97) v4(128.6,77.27) v4(129.01,49.61) v4(129.01,46.35) v4(129.36,54.72) v4(129.46,46.35) v4(129.61,53.97) v4(129.87,77.27) v4(129.92,64.22) v4(130.01,49.52) v4(129.93,46.34) v4(130.61,54.73) v4(130.87,53.99) v4(131.12,67.22) v4(131.14,77.27) v4(132.4,77.26) v4(192.32,73.04) v4(192.35,71.84) v4(193.59,73.04) v4(194.64,71.81) v4(194.86,73.04) v4(197.84,71.99) v4(198.67,73.04) v4(199.94,74.31) v4(201.33,72.03) v4(202.59,71.99) v4(202.97,74.46) v4(203.75,74.31) v4(203.75,73.04) v4(203.82,72.03) v4(205.02,74.31) v4(204.94,72.03) v4(205.64,36.84) v4(205.98,52.14) v4(206.47,37.63) v4(207.21,38.67) v4(207.56,71.77) v4(208.83,73.04) v4(208.83,71.77) v4(210.1,73.04) v4(210.1,71.77) v4(210.43,74.15) v4(211.37,73.04) v4(211.37,71.77) v4(212.64,73.04) v4(212.64,71.77) v4(213.91,74.31) v4(213.91,73.04) v4(213.91,71.77) v4(215.18,74.31) v4(215.18,71.77) v4(216.45,71.77) v4(217.72,71.77) v4(218.99,71.77) v4(220.26,71.77) v4(221.53,73.04) v4(221.53,71.77) v4(222.8,71.77) v4(223.84,11.19) v4(224.07,73.04) v4(224.07,71.77) v4(225.34,73.04) v4(225.34,71.77) v4(226.61,73.04) v4(226.61,71.77) v4(227.88,71.77) v4(229.15,73.04) v4(230.42,73.04) v4(231.69,73.04) v4(232.96,73.04) v4(234.23,73.04) v4(235.5,73.04) v4(236.77,73.04) v4(238.04,73.04) v4(243.12,73.04) v4(244.39,73.04) v4(245.66,73.04) v4(246.93,73.04) v4(248.2,73.04) v4(249.47,73.04) v4(250.74,73.04) v4(252.01,73.04) v4(253.28,73.04) v4(254.55,73.04) v4(255.82,73.04) v4(257.09,73.04) v4(258.36,73.04) v4(259.63,73.04) v4(260.9,73.04) v4(261.13,33.57) v4(262.17,73.04) v4(262.69,34.08) v4(263.44,73.04) v4(264.31,34) v4(269.79,73.04) v4(271.06,73.04) v4(272.33,73.04) v4(273.6,73.04) v4(274.87,73.04) v4(276.14,73.04) v4(281.35,20.19) v4(281.62,18.8) v4(290.98,70.5) v4(290.97,69.54) v4(291.86,71.06) v4(291.91,69.34) v4(292.84,71.08) v4(292.87,69.35) v4(293.81,69.39) v4(293.89,71.11) v5(3.31,70.33) v5(3.44,69.28) v5(3.44,55.84) v5(3.44,54.06) v5(3.57,70.33) v5(3.56,55.1) v5(3.58,54.84) v5(5.21,70.86) v5(5.21,70.52) v5(5.21,70.18) v5(5.21,69.85) v5(5.21,69.51) v5(5.21,69.17) v5(5.21,68.84) v5(5.21,68.5) v5(5.21,68.17) v5(5.21,55.64) v5(5.21,55.3) v5(5.21,54.96) v5(5.21,54.63) v5(5.21,54.29) v5(5.21,53.95) v5(5.21,53.62) v5(5.21,53.28) v5(5.21,52.95) v5(6.73,68.47) v5(6.77,66.44) v5(6.73,53.25) v5(6.74,51.22) v5(6.92,70.57) v5(6.92,55.35) v5(6.99,72.51) v5(6.98,68.47) v5(7.02,66.44) v5(6.99,57.29) v5(6.98,53.25) v5(6.99,51.22) v5(7.06,72.14) v5(7.07,70.95) v5(7.17,72.69) v5(7.18,70.57) v5(7.22,68) v5(7.17,57.47) v5(7.13,56.91) v5(7.13,55.81) v5(7.18,55.35) v5(7.16,52.77) v5(7.16,51.68) v5(7.23,66.9) v5(7.56,57.57) v5(7.65,66.25) v5(7.82,57.57) v5(7.85,66.86) v5(8.1,66.86) v5(8.15,76.41) v5(8.15,76.16) v5(8.31,66.25) v5(8.44,57.39) v5(8.61,48.01) v5(8.61,47.67) v5(8.7,57.39) v5(8.69,46.95) v5(8.69,46.6) v5(10.73,68.99) v5(10.73,68.65) v5(11.23,65.64) v5(11.72,65.21) v5(12.03,65.63) v5(12.36,65.21) v5(14.2,50.28) v5(14.42,51.74) v5(14.81,69.17) v5(14.79,68.87) v5(15.1,16.01) v5(15.1,15.67) v5(16.25,74.31) v5(16.41,73.49) v5(16.33,54.96) v5(16.33,53.89) v5(16.33,52.86) v5(16.33,51.79) v5(16.33,50.75) v5(16.33,49.69) v5(16.33,49.18) v5(16.33,48.11) v5(16.68,40.13) v5(16.68,39.88) v5(16.68,38.91) v5(16.68,38.65) v5(16.68,37.73) v5(16.68,37.48) v5(16.67,36.68) v5(16.67,36.43) v5(16.82,15.67) v5(16.83,16.01) v5(17.71,71.59) v5(18.13,52.14) v5(18.13,51.33) v5(18.52,57.33) v5(18.52,53.19) v5(18.52,49.51) v5(18.91,70.88) v5(18.98,77.79) v5(18.94,75.01) v5(18.98,57.33) v5(18.98,56.87) v5(18.98,54.11) v5(18.98,53.19) v5(18.98,51.35) v5(18.98,49.51) v5(19.11,68.12) v5(19.19,75.01) v5(19.27,77.79) v5(19.36,68.12) v5(19.54,70.88) v5(19.68,52.92) v5(19.68,51.62) v5(19.68,49.67) v5(19.83,68.79) v5(19.83,68.16) v5(20.1,70.89) v5(20.05,40.8) v5(20.05,40.54) v5(20.24,77.76) v5(20.35,75.62) v5(20.35,74.99) v5(20.54,77.76) v5(20.74,70.89) v5(20.88,74.25) v5(20.88,74) v5(20.93,67.31) v5(20.93,67.05) v5(20.98,53.57) v5(21.3,71.01) v5(21.28,47.67) v5(21.27,44.45) v5(21.39,77.78) v5(21.52,44.45) v5(21.59,74.31) v5(21.71,77.78) v5(21.69,67.26) v5(21.63,55.52) v5(21.63,54.22) v5(21.63,52.27) v5(21.73,43.99) v5(21.84,74.31) v5(21.94,71.01) v5(21.95,67.26) v5(21.98,43.99) v5(22.2,47.67) v5(22.31,61.14) v5(22.28,55.52) v5(22.42,43.39) v5(22.42,43.13) v5(22.41,42.56) v5(22.41,42.31) v5(22.39,36.85) v5(22.39,36.59) v5(22.87,41.43) v5(22.93,44.2) v5(23.12,47.67) v5(23.03,41.63) v5(23.19,44.2) v5(23.44,44.2) v5(23.48,43.02) v5(23.48,42.77) v5(23.48,42.51) v5(23.48,42.25) v5(23.7,44.2) v5(23.73,43.02) v5(23.73,42.77) v5(23.74,42.51) v5(23.74,42.26) v5(23.95,44.2) v5(23.99,43.03) v5(23.99,42.77) v5(23.99,42.51) v5(23.99,42.26) v5(24.04,47.67) v5(24.21,44.2) v5(24.23,53.57) v5(24.51,75.75) v5(24.72,74.93) v5(24.72,73.93) v5(24.72,69.92) v5(24.72,69.42) v5(24.72,67.42) v5(24.72,66.92) v5(24.72,66.42) v5(24.96,47.67) v5(25.22,74.93) v5(25.22,74.43) v5(25.22,73.93) v5(25.22,69.92) v5(25.22,67.92) v5(25.22,67.42) v5(25.22,66.92) v5(25.53,51.62) v5(25.53,49.67) v5(25.73,69.92) v5(25.73,67.42) v5(25.73,66.92) v5(25.88,47.67) v5(26.18,54.87) v5(26.18,48.37) v5(26.23,73.43) v5(26.23,67.92) v5(26.23,66.92) v5(26.47,66.64) v5(26.73,66.42) v5(26.83,55.52) v5(26.83,54.87) v5(26.83,54.22) v5(26.83,53.57) v5(26.83,51.62) v5(26.83,48.37) v5(27.48,53.57) v5(27.48,51.62) v5(27.48,48.37) v5(27.72,47.67) v5(27.72,47.21) v5(28.18,57.33) v5(28.18,56.87) v5(28.18,55.03) v5(28.18,54.11) v5(28.18,53.19) v5(28.18,51.35) v5(28.18,50.43) v5(28.18,49.51) v5(28.18,48.59) v5(28.18,47.67) v5(28.62,55.02) v5(28.64,57.33) v5(28.64,56.87) v5(28.64,54.11) v5(28.64,53.19) v5(28.64,51.35) v5(28.64,50.43) v5(28.64,49.51) v5(28.64,48.59) v5(28.64,47.67) v5(32.09,57.52) v5(32.09,56.96) v5(32.03,47.26) v5(32.93,45.89) v5(32.93,45.58) v5(33.19,45.89) v5(33.19,45.58) v5(39.85,47.75) v5(40.13,47.76) v5(40.42,47.76) v5(41.97,39.87) v5(42.63,39.87) v5(43.38,50.93) v5(43.41,40) v5(43.53,52.17) v5(53.46,22.88) v5(53.68,25.14) v5(53.68,24.89) v5(53.69,23.89) v5(53.69,23.64) v5(53.72,22.88) v5(54.8,14.71) v5(62.24,14.36) v5(63.12,77.91) v5(63.47,19.83) v5(63.83,77.92) v5(64.54,77.92) v5(65.06,54.46) v5(65.25,77.92) v5(65.52,54.92) v5(65.96,77.92) v5(66.33,77.3) v5(66.72,19.83) v5(67.37,19.83) v5(67.6,77.3) v5(68.02,19.83) v5(68.62,77.31) v5(69.89,77.31) v5(71.16,77.31) v5(72.43,77.31) v5(72.49,72.22) v5(72.49,71.14) v5(72.92,72.18) v5(72.94,72.98) v5(73,70.76) v5(73.04,77.88) v5(73.21,72.98) v5(73.2,72.18) v5(73.51,72.98) v5(73.49,72.18) v5(73.75,77.88) v5(73.82,72.18) v5(73.84,72.98) v5(74.17,72.98) v5(74.15,72.18) v5(74.46,77.88) v5(75.17,77.88) v5(75.88,77.88) v5(76.48,77.3) v5(77.52,77.3) v5(78.7,77.31) v5(79.82,35.02) v5(80.25,77.88) v5(80.96,77.89) v5(81.67,77.89) v5(82.38,77.89) v5(83.13,77.29) v5(84.4,77.29) v5(84.6,51.38) v5(84.93,53.39) v5(85.42,77.3) v5(85.57,58.41) v5(86.69,77.3) v5(87.96,77.3) v5(88.03,55.38) v5(88.61,53.76) v5(88.7,70.41) v5(88.7,69.31) v5(88.77,76.87) v5(89.02,69.86) v5(89.18,77.3) v5(89.16,54.08) v5(89.36,76.27) v5(89.34,70.41) v5(89.34,69.31) v5(89.82,53.39) v5(89.97,75.66) v5(89.98,70.41) v5(89.98,69.31) v5(90.29,69.86) v5(90.4,77.31) v5(90.61,70.41) v5(90.61,69.31) v5(90.87,19.83) v5(91.04,53.75) v5(91.25,70.41) v5(91.25,69.31) v5(91.52,20.63) v5(91.67,52.93) v5(91.68,51.76) v5(91.73,69.87) v5(91.88,70.41) v5(91.88,69.31) v5(92.52,70.41) v5(92.52,69.31) v5(92.84,69.86) v5(93.09,53.04) v5(93.16,70.41) v5(93.16,69.31) v5(93.31,51.96) v5(93.66,56.76) v5(93.79,70.41) v5(93.79,69.31) v5(93.75,38.34) v5(94.11,69.86) v5(94.22,57.18) v5(94.33,51.99) v5(94.39,29.36) v5(94.5,70.43) v5(94.53,69.34) v5(94.58,51.69) v5(94.7,53.39) v5(94.67,38.34) v5(94.92,57.38) v5(95.07,70.41) v5(95.07,69.31) v5(95.27,77.32) v5(95.38,69.86) v5(95.41,51.72) v5(95.58,38.34) v5(95.58,37.69) v5(95.7,70.41) v5(95.7,69.31) v5(95.85,53.08) v5(96.15,50.27) v5(96.24,77.31) v5(96.34,70.41) v5(96.34,69.31) v5(96.4,53.03) v5(96.39,52.36) v5(96.5,15.41) v5(96.66,69.86) v5(96.97,70.41) v5(96.97,69.31) v5(97.1,77.27) v5(97.14,53.39) v5(97.33,53.05) v5(97.4,35.74) v5(97.51,56.51) v5(97.45,56.05) v5(97.44,35.02) v5(97.84,29.41) v5(98.06,52.57) v5(98.06,51.95) v5(98.21,51.67) v5(98.3,77.27) v5(98.23,56.94) v5(98.31,38.34) v5(98.7,51.02) v5(98.7,33.82) v5(98.7,33.17) v5(98.91,30.04) v5(99.19,56.38) v5(99.13,50.41) v5(99.13,49.75) v5(99.29,57.79) v5(99.49,77.27) v5(99.73,52.88) v5(99.76,51.89) v5(100.11,53.04) v5(100.09,50.4) v5(100.06,49.57) v5(100.13,36.39) v5(100.68,77.27) v5(100.86,52.58) v5(100.85,51.96) v5(101.07,53.18) v5(101.22,33.82) v5(101.22,33.17) v5(101.71,49.16) v5(101.71,39.92) v5(101.88,77.27) v5(101.9,53.97) v5(101.92,53.03) v5(101.92,51.71) v5(102.13,16.51) v5(102.13,16.26) v5(102.13,16) v5(102.13,15.32) v5(102.13,15.06) v5(102.13,14.81) v5(102.36,49.16) v5(102.36,39.92) v5(102.48,35.02) v5(103.01,39.92) v5(103.07,77.27) v5(103.6,18.6) v5(103.6,18.13) v5(103.6,17.67) v5(103.66,40.76) v5(103.66,39.92) v5(104.11,77.27) v5(104.46,53.39) v5(105.38,77.27) v5(105.6,36.39) v5(106.25,33.17) v5(106.44,41.16) v5(106.65,77.27) v5(107.74,47.84) v5(107.74,42.8) v5(107.74,40.28) v5(107.74,37.76) v5(107.74,35.24) v5(107.75,25.8) v5(107.76,24.87) v5(107.76,24.39) v5(107.76,23.81) v5(107.75,23.54) v5(107.76,23.28) v5(107.92,77.27) v5(108.62,47.84) v5(108.62,45.32) v5(108.62,40.28) v5(109.19,77.27) v5(109.27,42.8) v5(109.37,46.58) v5(110.46,77.27) v5(111.73,77.27) v5(113,77.27) v5(114.21,24.3) v5(114.21,22.15) v5(114.27,77.27) v5(114.71,22.15) v5(114.97,25.55) v5(115.21,22.15) v5(115.54,77.27) v5(116.68,22.26) v5(116.81,77.27) v5(116.89,25.84) v5(116.89,25.48) v5(116.94,22.26) v5(117.58,22.27) v5(117.83,22.27) v5(118.08,77.27) v5(118.47,21.74) v5(118.75,21.75) v5(119.02,21.74) v5(119.3,41.78) v5(119.35,77.27) v5(119.56,41.78) v5(119.81,41.78) v5(120.46,77.27) v5(120.5,41.78) v5(120.76,41.78) v5(121.01,41.78) v5(121.6,54.83) v5(121.73,77.27) v5(121.74,41.79) v5(121.87,55.66) v5(121.86,54.83) v5(121.99,41.79) v5(122.11,54.83) v5(122.24,41.79) v5(123,77.27) v5(124.03,77.91) v5(124.62,52.46) v5(124.63,55.1) v5(124.74,77.91) v5(124.89,55.1) v5(124.88,52.46) v5(125.45,77.91) v5(125.6,55.14) v5(125.62,51.4) v5(125.86,55.14) v5(125.87,51.4) v5(126.11,55.14) v5(126.16,77.91) v5(126.13,51.4) v5(126.54,46.74) v5(126.69,77.27) v5(126.84,54.34) v5(127.1,54.34) v5(127.27,68.53) v5(127.27,67.86) v5(127.27,67.19) v5(127.25,46.74) v5(127.35,54.34) v5(127.96,77.27) v5(127.97,46.74) v5(128.07,68.53) v5(128.07,67.86) v5(128.07,67.19) v5(128.05,54.34) v5(128.3,54.34) v5(128.55,54.34) v5(128.88,49.3) v5(128.88,45.95) v5(129.14,49.3) v5(129.13,45.95) v5(129.23,77.27) v5(129.24,54.34) v5(129.39,45.95) v5(129.5,54.34) v5(129.75,54.34) v5(129.88,49.21) v5(130.1,45.95) v5(130.22,64.34) v5(130.22,64.09) v5(130.14,49.21) v5(130.35,45.95) v5(130.5,77.27) v5(130.49,54.36) v5(130.61,45.95) v5(130.74,54.36) v5(131,66.92) v5(131,54.36) v5(131.25,66.92) v5(131.77,77.27) v5(132.8,77.26) v5(196.63,73.47) v5(199.78,45.98) v5(203.66,59.43) v5(203.67,58.11) v5(203.71,56.51) v5(203.68,55.85) v5(203.68,55.17) v5(203.67,53.73) v5(203.95,52.88) v5(203.95,52.37) v5(204.69,52.12) v5(205.03,37.45) v5(205.77,62.62) v5(205.74,38.28) v5(206.11,38.52) v5(206.49,38.89) v5(206.7,25.57) v5(207.44,23.17) v5(207.84,22) v5(208,25.86) v5(212.13,31.18) v5(212.81,31.92) v5(215.58,33.5) v5(261.17,34.07) v5(262.47,33.58) v5(263.07,33.64) v5(263.93,33.65) v5(284.01,31.49) v5(284.2,32.15) v5(284.31,33.65) v5(285.98,30.82) v5(299.26,57.17) v5(307.66,61.38) v5(309.05,61.38) v6(0.47,78.53) v6(0.47,77.51) v6(0.47,76.5) v6(0.47,75.48) v6(0.47,74.92) v6(0.47,72.43) v6(0.47,71.42) v6(0.47,70.4) v6(0.47,69.39) v6(0.47,68.37) v6(0.47,67.35) v6(0.47,66.19) v6(0.47,63.96) v6(0.46,59.71) v6(0.47,57.19) v6(0.47,56.18) v6(0.47,55.16) v6(0.47,54.15) v6(0.47,53.13) v6(0.47,52.11) v6(0.47,51.1) v6(0.47,48.75) v6(0.47,48.05) v6(0.47,47.03) v6(0.47,46.02) v6(0.47,45) v6(0.47,43.99) v6(0.47,42.97) v6(0.47,41.95) v6(0.72,40.96) v6(0.72,39.95) v6(0.7,22.93) v6(0.7,17.85) v6(0.7,16.91) v6(0.72,2.56) v6(0.72,1.54) v6(0.85,0.63) v6(1.21,78.08) v6(1.19,60.2) v6(1.21,45.03) v6(1.31,23.59) v6(1.36,78.94) v6(1.36,77.21) v6(1.36,63.25) v6(1.42,45.92) v6(1.42,44.15) v6(1.35,21.79) v6(1.42,20.81) v6(1.42,19.79) v6(1.42,18.78) v6(1.45,62.2) v6(1.45,61.19) v6(1.71,16.91) v6(1.71,2.58) v6(1.74,0.45) v6(2.02,79.65) v6(1.95,76.63) v6(2.02,46.58) v6(2.01,43.48) v6(2.75,0.45) v6(2.98,79.94) v6(2.93,76.36) v6(2.99,46.85) v6(2.97,43.23) v6(3.77,0.45) v6(3.88,79.71) v6(3.87,76.56) v6(3.87,46.58) v6(3.91,43.52) v6(4.33,16.91) v6(4.36,2.58) v6(4.53,79.07) v6(4.54,77.24) v6(4.58,45.91) v6(4.57,44.16) v6(4.73,78.09) v6(4.75,45.03) v6(4.79,23.59) v6(4.79,0.45) v6(4.89,79.98) v6(5.12,39.9) v6(5.35,16.91) v6(5.37,2.58) v6(5.8,23.59) v6(5.8,0.45) v6(5.9,79.98) v6(6.13,39.9) v6(6.82,23.59) v6(6.82,0.45) v6(6.95,79.9) v6(7.15,39.9) v6(7.66,79.19) v6(7.83,23.59) v6(7.83,0.45) v6(8.17,39.9) v6(8.34,78.43) v6(8.72,2.33) v6(8.8,23.16) v6(8.85,17.14) v6(8.85,0.45) v6(9.05,77.62) v6(9.13,40.4) v6(9.82,76.78) v6(9.79,2.34) v6(9.92,23.44) v6(9.87,17.14) v6(9.87,0.45) v6(10.02,39.82) v6(9.99,20.2) v6(10.1,38.32) v6(10.1,37.36) v6(10.1,36.34) v6(10.1,35.32) v6(10.1,34.31) v6(10.1,33.29) v6(10.1,32.28) v6(10.1,31.26) v6(10.1,30.24) v6(10.1,29.23) v6(10.1,28.21) v6(10.1,27.2) v6(10.1,26.18) v6(10.1,25.16) v6(10.21,21.11) v6(10.21,19.31) v6(10.48,16.55) v6(10.55,75.96) v6(10.58,15.16) v6(10.55,4.31) v6(10.53,3.12) v6(10.71,21.82) v6(10.82,18.6) v6(10.88,0.45) v6(11.44,75.3) v6(11.56,22.05) v6(11.8,14.7) v6(11.92,5) v6(11.9,0.45) v6(12.61,21.9) v6(12.53,18.48) v6(12.66,74.92) v6(12.91,0.45) v6(13.32,18.85) v6(13.61,19.5) v6(13.88,75.02) v6(13.93,0.45) v6(15,75.53) v6(14.95,0.45) v6(15.71,76.22) v6(15.96,0.45) v6(16.27,77.23) v6(16.83,78.07) v6(16.98,0.45) v6(17.32,39.47) v6(17.34,38.24) v6(17.61,78.76) v6(17.99,0.45) v6(18.53,79.16) v6(18.53,13.23) v6(19.01,0.45) v6(19.15,13.85) v6(19.15,12.6) v6(19.57,79.29) v6(19.81,28.5) v6(19.77,13.23) v6(19.95,29.05) v6(20.03,0.45) v6(20.38,28.5) v6(20.51,29.05) v6(20.59,79.29) v6(20.98,28.5) v6(21.09,29.05) v6(21.04,0.45) v6(21.6,79.29) v6(21.54,28.5) v6(21.68,29.05) v6(22.1,28.5) v6(22.06,0.45) v6(22.24,29.05) v6(22.62,79.29) v6(23.07,0.45) v6(23.63,79.29) v6(24.09,0.45) v6(24.65,79.29) v6(25.11,0.45) v6(25.67,79.29) v6(26.12,0.45) v6(26.68,79.29) v6(27.14,0.45) v6(27.42,18.82) v6(27.42,16.59) v6(27.7,79.29) v6(28.15,0.45) v6(28.54,17.71) v6(28.71,79.29) v6(29.17,0.45) v6(29.66,18.82) v6(29.66,16.59) v6(29.73,79.29) v6(30.19,0.63) v6(30.36,6.77) v6(30.36,5.76) v6(30.36,4.74) v6(30.36,3.73) v6(30.36,2.71) v6(30.36,1.69) v6(30.75,79.29) v6(30.75,7.74) v6(31.43,8.45) v6(31.76,79.29) v6(32.47,8.86) v6(32.78,79.29) v6(32.99,38.95) v6(32.93,38.37) v6(33.32,39.47) v6(33.44,38.12) v6(33.49,8.86) v6(33.79,79.29) v6(33.82,39.21) v6(33.82,38.62) v6(34.5,8.86) v6(34.81,79.29) v6(34.97,22.28) v6(35.39,48.16) v6(35.39,47.59) v6(35.39,47.03) v6(35.39,46.47) v6(35.41,22.69) v6(35.52,8.86) v6(35.81,23.09) v6(35.83,79.29) v6(36.24,23.5) v6(36.54,8.86) v6(36.68,23.88) v6(36.84,79.29) v6(37.55,8.86) v6(37.86,79.29) v6(38.25,29.85) v6(38.28,29.19) v6(38.57,8.86) v6(38.82,25.57) v6(38.87,79.29) v6(38.83,29.84) v6(38.86,29.21) v6(38.84,24.96) v6(38.84,24.33) v6(38.85,23.69) v6(39.3,51.81) v6(39.42,29.84) v6(39.33,25.24) v6(39.33,24.63) v6(39.33,24) v6(39.43,46.27) v6(39.49,45.71) v6(39.52,45.14) v6(39.45,29.21) v6(39.58,8.86) v6(39.63,46.81) v6(39.89,79.29) v6(39.9,51.82) v6(40.02,29.85) v6(40.02,29.19) v6(40.03,46.28) v6(40.05,45.72) v6(40.08,45.1) v6(40.26,46.81) v6(40.43,48.62) v6(40.61,46.31) v6(40.6,8.86) v6(40.63,45.7) v6(40.65,45.1) v6(40.66,29.85) v6(40.66,29.19) v6(40.91,79.29) v6(40.9,46.81) v6(41.19,46.3) v6(41.21,45.7) v6(41.25,45.1) v6(41.62,8.86) v6(41.92,79.29) v6(42.5,27.64) v6(42.49,26.4) v6(42.5,25.13) v6(42.63,8.86) v6(42.73,47.63) v6(42.94,79.29) v6(43.07,46.13) v6(43.09,45.36) v6(43.1,44.79) v6(43.45,39.53) v6(43.46,38.97) v6(43.46,38.39) v6(43.58,45.91) v6(43.66,45.36) v6(43.66,44.79) v6(43.65,8.86) v6(43.95,79.29) v6(44.01,42.51) v6(44,39.27) v6(44,38.71) v6(44.14,45.96) v6(44.23,45.38) v6(44.25,44.8) v6(44.58,42.51) v6(44.68,45.83) v6(44.66,8.86) v6(44.88,44.8) v6(44.97,79.29) v6(44.97,46.31) v6(44.97,45.35) v6(45.23,42.51) v6(45.68,8.86) v6(45.8,42.51) v6(45.99,79.29) v6(46.7,8.86) v6(47,79.29) v6(47.5,27.91) v6(47.73,29.89) v6(47.71,8.86) v6(47.8,72.43) v6(47.88,50.23) v6(48.02,79.29) v6(47.97,36.08) v6(48.14,49.71) v6(48.29,29.85) v6(48.29,29.28) v6(48.46,50.22) v6(48.52,43.02) v6(48.52,42.38) v6(48.53,41.75) v6(48.53,41.11) v6(48.65,77.84) v6(48.7,49.69) v6(48.73,8.86) v6(49.03,79.29) v6(49.05,50.22) v6(49.26,49.69) v6(49.72,78.94) v6(49.63,26.99) v6(49.63,25.36) v6(49.74,8.86) v6(50.18,78.17) v6(50.32,35.04) v6(50.39,34.48) v6(50.38,33.9) v6(50.76,8.86) v6(50.97,34.71) v6(50.96,34.15) v6(50.95,30.26) v6(51.1,14.89) v6(51.14,77.79) v6(51.31,29.74) v6(51.31,29.17) v6(51.3,28.6) v6(51.31,28.02) v6(51.68,14.89) v6(51.78,8.86) v6(52.16,77.79) v6(52.79,8.86) v6(53.17,77.79) v6(53.81,8.86) v6(53.9,76.83) v6(54.53,75.82) v6(54.82,8.86) v6(55.26,51.86) v6(55.47,74.96) v6(55.64,51.37) v6(55.71,40.35) v6(55.84,8.86) v6(56.1,51.86) v6(56.32,40.38) v6(56.48,51.37) v6(56.69,74.4) v6(56.92,40.37) v6(56.86,8.86) v6(56.94,51.86) v6(57.32,51.37) v6(57.58,39.68) v6(57.67,40.37) v6(57.78,51.86) v6(57.87,8.86) v6(57.95,74.21) v6(58.16,51.37) v6(58.23,39.7) v6(58.51,40.37) v6(58.63,51.86) v6(58.89,8.86) v6(58.97,74.21) v6(59.01,51.37) v6(59.07,39.7) v6(59.35,40.37) v6(59.47,51.86) v6(59.73,39.7) v6(59.85,51.37) v6(59.9,8.86) v6(59.98,74.21) v6(60.19,40.37) v6(60.31,51.87) v6(60.69,51.38) v6(60.92,8.86) v6(61,74.21) v6(61.15,51.87) v6(61.52,51.38) v6(61.89,74.69) v6(62,51.87) v6(61.94,8.86) v6(62.27,76.62) v6(62.27,75.61) v6(62.37,77.59) v6(62.37,51.38) v6(62.95,8.86) v6(63.97,8.86) v6(64.98,8.86) v6(66,8.86) v6(66.48,77.82) v6(67.02,8.86) v6(67.37,77.82) v6(68.03,8.86) v6(68.39,77.82) v6(69.05,8.86) v6(69.4,77.82) v6(70.06,8.86) v6(70.42,77.82) v6(71.08,8.86) v6(71.44,77.82) v6(72.1,8.86) v6(72.33,77.82) v6(72.54,71.67) v6(73.11,8.86) v6(73.13,71.67) v6(73.71,71.67) v6(74.05,70.11) v6(74.13,8.86) v6(74.29,71.67) v6(74.31,69.6) v6(74.61,70.11) v6(74.69,69.07) v6(74.89,69.6) v6(75.17,70.11) v6(75.14,8.86) v6(75.25,69.07) v6(75.48,69.6) v6(75.73,70.11) v6(75.81,69.09) v6(76.06,69.6) v6(76.16,8.86) v6(76.24,70.74) v6(76.31,70.11) v6(76.36,69.09) v6(76.52,77.82) v6(76.64,69.6) v6(76.81,70.74) v6(76.9,70.11) v6(77.18,8.86) v6(77.53,77.82) v6(78.19,8.86) v6(78.55,77.82) v6(79.21,8.86) v6(79.56,77.82) v6(80.22,8.86) v6(81.24,8.86) v6(82.26,8.86) v6(83.07,69.34) v6(83.27,8.86) v6(83.35,69.84) v6(83.63,77.82) v6(83.64,69.32) v6(83.91,69.83) v6(84.21,69.31) v6(84.29,8.86) v6(84.64,77.82) v6(85.3,8.86) v6(85.66,77.82) v6(86.32,8.86) v6(86.68,77.82) v6(87.34,8.86) v6(87.69,77.82) v6(88.35,8.86) v6(88.71,77.82) v6(89.37,8.86) v6(89.72,77.82) v6(90.38,8.86) v6(90.74,77.82) v6(90.87,76.93) v6(90.99,74.87) v6(91.4,8.86) v6(91.63,77.82) v6(91.64,74.17) v6(92.42,8.86) v6(92.85,73.82) v6(93.43,8.86) v6(94.07,74.15) v6(94.45,8.86) v6(94.78,77.18) v6(94.86,74.96) v6(95.31,77.82) v6(95.46,8.86) v6(96.33,77.82) v6(96.48,8.86) v6(97.34,77.82) v6(97.5,8.86) v6(98.36,77.82) v6(98.51,8.86) v6(99.38,77.82) v6(99.53,8.86) v6(100.39,77.82) v6(100.54,8.86) v6(101.41,77.82) v6(101.5,68.92) v6(101.56,8.86) v6(102.07,68.93) v6(102.42,77.82) v6(102.63,68.93) v6(103.2,68.92) v6(103.44,77.82) v6(103.59,8.86) v6(104.46,77.82) v6(104.61,8.86) v6(105.47,77.82) v6(105.62,8.86) v6(106.49,77.82) v6(106.44,19.39) v6(106.64,8.86) v6(107.5,77.82) v6(107.66,8.86) v6(107.82,25.34) v6(108.52,77.82) v6(108.67,8.86) v6(108.85,75.43) v6(108.94,74.31) v6(109.1,74.87) v6(109.13,75.94) v6(109.43,75.43) v6(109.54,77.82) v6(109.71,75.94) v6(110.02,75.45) v6(110.3,75.94) v6(110.55,77.82) v6(110.58,75.45) v6(110.7,8.86) v6(110.86,75.94) v6(111.14,75.45) v6(111.42,75.94) v6(111.57,77.82) v6(111.7,75.45) v6(111.72,8.86) v6(111.97,75.94) v6(112.25,75.45) v6(112.58,77.82) v6(112.53,75.94) v6(112.81,75.43) v6(112.74,8.86) v6(112.94,74.87) v6(113.12,75.91) v6(113.42,75.42) v6(113.6,77.82) v6(113.55,74.83) v6(113.72,73.13) v6(113.79,75.93) v6(113.75,8.86) v6(114.04,75.41) v6(114.13,74.83) v6(114.22,21.39) v6(114.3,73.13) v6(114.35,75.93) v6(114.62,77.82) v6(114.6,75.41) v6(114.72,74.83) v6(114.8,21.38) v6(114.77,8.86) v6(114.88,73.19) v6(114.96,75.93) v6(115.19,75.41) v6(115.28,74.83) v6(115.37,21.37) v6(115.47,73.19) v6(115.54,75.93) v6(115.63,77.82) v6(115.77,75.41) v6(115.78,8.86) v6(115.84,74.83) v6(116.1,73.89) v6(116.65,77.82) v6(116.68,73.89) v6(116.8,8.86) v6(117.26,73.89) v6(117.66,77.82) v6(117.82,8.86) v6(117.85,73.89) v6(118.02,74.48) v6(118.58,74.48) v6(118.68,77.82) v6(118.83,8.86) v6(119.19,74.45) v6(119.14,49.35) v6(119.45,42.44) v6(119.7,77.82) v6(119.75,74.45) v6(119.85,8.86) v6(120.31,74.45) v6(120.59,77.82) v6(120.86,74.45) v6(120.86,8.86) v6(121.42,74.45) v6(121.47,77.82) v6(121.87,54.11) v6(121.88,8.86) v6(122.01,74.45) v6(122.36,77.82) v6(122.48,64.65) v6(122.97,9.04) v6(123.13,13.02) v6(123.13,12.01) v6(123.13,10.99) v6(123.13,9.98) v6(123.25,77.82) v6(123.51,14.17) v6(123.66,64.69) v6(123.95,29.41) v6(124.14,14.95) v6(124.92,64.7) v6(125.03,15.49) v6(125.26,59.15) v6(125.26,58.59) v6(126.2,15.72) v6(126.81,77.82) v6(126.83,71.2) v6(126.83,70.62) v6(126.83,70.03) v6(126.83,69.45) v6(127.34,15.49) v6(127.82,77.82) v6(128.36,14.78) v6(128.84,77.82) v6(128.97,13.86) v6(129.22,12.92) v6(129.22,11.91) v6(129.22,10.89) v6(129.48,9.98) v6(129.86,77.82) v6(130.12,50.25) v6(130.42,9.87) v6(130.87,77.82) v6(131.43,9.87) v6(131.89,77.82) v6(132.45,9.87) v6(132.9,77.74) v6(133.23,76.78) v6(133.23,75.76) v6(133.23,74.75) v6(133.23,73.73) v6(133.23,72.71) v6(133.23,71.7) v6(133.23,70.68) v6(133.23,69.67) v6(133.23,68.65) v6(133.23,67.63) v6(133.23,66.62) v6(133.23,65.6) v6(133.23,64.59) v6(133.23,63.57) v6(133.23,62.55) v6(133.23,61.54) v6(133.23,60.52) v6(133.23,59.51) v6(133.23,58.49) v6(133.23,57.47) v6(133.23,56.46) v6(133.23,55.44) v6(133.23,54.43) v6(133.23,53.41) v6(133.23,52.39) v6(133.23,51.38) v6(133.23,50.36) v6(133.23,49.35) v6(133.34,48.3) v6(133.44,47.26) v6(133.46,9.87) v6(133.56,46.25) v6(133.74,45.26) v6(133.97,44.21) v6(134.25,43.1) v6(134.48,9.87) v6(134.56,42.08) v6(134.86,41.17) v6(135.19,40.28) v6(135.5,9.87) v6(135.62,39.24) v6(136.03,38.32) v6(136.46,37.43) v6(136.51,9.87) v6(136.94,36.57) v6(137.43,35.73) v6(137.53,9.87) v6(138.01,34.82) v6(138.54,9.87) v6(139.56,9.87) v6(140.58,9.87) v6(141.21,30.8) v6(141.59,9.87) v6(141.79,30.24) v6(142.35,29.69) v6(142.61,9.87) v6(142.91,29.18) v6(143.52,28.64) v6(143.62,9.87) v6(144.26,28.06) v6(144.64,9.87) v6(145.02,27.5) v6(145.68,9.67) v6(145.76,26.97) v6(146.34,8.83) v6(146.57,26.43) v6(147.26,8.68) v6(147.36,25.95) v6(148.2,25.47) v6(148.27,8.68) v6(149.08,25.01) v6(149.29,8.68) v6(150.1,24.53) v6(150.3,8.68) v6(151.19,24.07) v6(151.32,8.68) v6(152.34,23.62) v6(152.34,8.68) v6(153.35,23.28) v6(153.35,8.68) v6(154.42,22.98) v6(154.37,8.68) v6(155.38,8.68) v6(155.61,22.68) v6(156.4,8.68) v6(156.7,22.45) v6(157.42,8.68) v6(157.8,22.27) v6(158.43,8.68) v6(158.86,22.12) v6(159.45,8.68) v6(159.85,22.01) v6(160.46,8.68) v6(160.87,21.96) v6(161.48,8.68) v6(161.91,21.94) v6(162.5,8.68) v6(162.95,21.96) v6(163.51,8.68) v6(163.97,22.01) v6(164.53,8.68) v6(165.01,22.12) v6(165.54,8.68) v6(165.95,22.22) v6(166.56,8.68) v6(166.94,22.4) v6(167.58,8.68) v6(167.91,22.57) v6(168.59,8.68) v6(168.87,22.8) v6(169.61,8.68) v6(169.84,23.06) v6(170.62,8.68) v6(170.9,23.39) v6(171.72,23.67) v6(171.64,8.68) v6(172.55,23.97) v6(172.66,8.68) v6(173.39,24.33) v6(173.67,8.68) v6(174.18,24.68) v6(174.69,8.68) v6(174.97,25.06) v6(175.7,8.68) v6(175.81,25.49) v6(176.64,25.98) v6(176.72,8.68) v6(177.56,26.54) v6(177.74,8.68) v6(178.37,27.09) v6(178.75,8.68) v6(179.18,27.68) v6(179.77,8.68) v6(180.02,28.31) v6(180.76,28.92) v6(180.78,8.68) v6(181.6,29.69) v6(181.8,8.68) v6(182.38,30.42) v6(182.82,8.68) v6(183.17,31.26) v6(183.83,8.68) v6(183.93,32.12) v6(184.82,33.17) v6(184.85,8.68) v6(185.26,15.12) v6(185.86,8.68) v6(186.14,33.01) v6(186.65,9.24) v6(187.16,33.93) v6(187.41,9.8) v6(187.79,34.92) v6(188.1,38.5) v6(188.43,36.01) v6(188.43,9.87) v6(188.56,39.69) v6(188.86,37.2) v6(189.04,40.91) v6(189.39,42) v6(189.44,9.87) v6(189.75,43.22) v6(190.03,44.37) v6(190.26,45.59) v6(190.46,46.7) v6(190.46,9.87) v6(190.69,49.22) v6(190.64,48.13) v6(190.74,74.9) v6(190.74,73.88) v6(190.74,72.87) v6(190.74,71.85) v6(190.74,70.83) v6(190.74,69.82) v6(190.74,68.8) v6(190.74,67.79) v6(190.74,65.75) v6(190.74,64.74) v6(190.74,63.72) v6(190.74,62.71) v6(190.74,61.69) v6(190.74,60.67) v6(190.74,59.66) v6(190.74,58.64) v6(190.74,57.63) v6(190.74,56.61) v6(190.74,55.59) v6(190.74,54.58) v6(190.74,53.56) v6(190.74,52.55) v6(190.74,51.53) v6(190.74,50.51) v6(191.3,75.81) v6(191.48,9.87) v6(192.32,75.81) v6(192.49,9.87) v6(193.33,75.81) v6(193.51,9.87) v6(194.35,75.81) v6(194.52,9.87) v6(195.36,75.81) v6(195.37,74.65) v6(195.54,9.87) v6(195.81,45.1) v6(195.81,44.47) v6(195.81,43.83) v6(195.81,43.2) v6(195.81,42.56) v6(195.81,41.93) v6(195.81,41.29) v6(195.81,40.66) v6(195.81,40.02) v6(196.38,75.81) v6(196.33,44.84) v6(196.44,43.83) v6(196.44,43.2) v6(196.44,42.56) v6(196.44,41.93) v6(196.44,41.29) v6(196.44,40.66) v6(196.44,40.02) v6(196.56,9.87) v6(196.72,74.7) v6(196.79,39.44) v6(197.03,40.63) v6(197.4,75.81) v6(197.47,40.15) v6(197.57,9.87) v6(197.79,32.09) v6(198.41,75.81) v6(198.47,74.72) v6(198.59,9.87) v6(199.43,75.81) v6(199.6,9.87) v6(200.44,75.81) v6(200.62,9.87) v6(201.38,75.7) v6(201.43,74.02) v6(201.64,9.87) v6(202.5,73.55) v6(202.65,9.87) v6(202.96,75.22) v6(203.22,59.89) v6(203.29,62.59) v6(203.26,61.19) v6(203.49,75.81) v6(203.58,63.35) v6(203.67,9.87) v6(204.51,75.81) v6(204.68,9.87) v6(205.52,75.81) v6(205.7,9.87) v6(206.48,61.01) v6(206.46,58.03) v6(206.46,56.71) v6(206.43,53.78) v6(206.46,50.61) v6(206.54,75.81) v6(206.72,9.87) v6(206.79,55.01) v6(206.91,62.58) v6(207.02,63.96) v6(207.11,74.83) v6(207.56,61.23) v6(207.81,75.81) v6(207.73,9.87) v6(207.87,59.5) v6(208.19,58.69) v6(208.44,55.77) v6(208.44,53.99) v6(208.83,57.04) v6(208.75,9.87) v6(208.83,75.73) v6(208.89,74.67) v6(209.76,9.87) v6(210.6,75.81) v6(210.78,9.87) v6(211.62,75.81) v6(211.58,73.95) v6(211.8,9.87) v6(212.36,74.71) v6(212.64,75.81) v6(212.81,9.87) v6(213.19,73.98) v6(213.65,75.81) v6(213.83,9.87) v6(214.9,75.99) v6(214.84,9.87) v6(215.61,77.01) v6(215.66,76) v6(215.86,9.87) v6(215.99,74.86) v6(216.45,77.79) v6(216.76,74.1) v6(216.88,9.87) v6(217.85,73.81) v6(217.89,9.87) v6(218.91,9.87) v6(219.06,74.14) v6(219.25,77.76) v6(219.81,74.92) v6(219.92,76.84) v6(219.92,9.87) v6(220.09,75.93) v6(220.38,77.82) v6(220.76,9.54) v6(221.42,77.79) v6(221.42,8.91) v6(222.44,8.86) v6(222.8,77.82) v6(223.46,8.86) v6(223.79,77.78) v6(224.34,76.73) v6(224.47,8.86) v6(224.56,59.03) v6(224.83,50.5) v6(225,76.05) v6(225.49,8.86) v6(225.89,75.84) v6(226.5,8.86) v6(226.83,76.18) v6(227.41,76.94) v6(227.52,8.86) v6(227.88,77.79) v6(227.88,75.76) v6(228.54,8.86) v6(228.89,77.79) v6(228.89,76.78) v6(228.89,75.76) v6(229.55,8.86) v6(229.91,77.79) v6(229.91,76.78) v6(229.91,75.76) v6(230.57,8.86) v6(230.92,77.79) v6(230.92,76.78) v6(230.92,75.76) v6(231.58,8.86) v6(231.89,16.91) v6(231.89,15.09) v6(231.89,13.28) v6(231.94,77.79) v6(231.94,76.78) v6(231.94,75.76) v6(232.6,8.86) v6(232.96,77.79) v6(232.96,76.78) v6(232.96,75.76) v6(233.62,8.86) v6(233.7,16.91) v6(233.7,15.09) v6(233.7,13.28) v6(233.97,77.79) v6(233.97,76.78) v6(233.97,75.76) v6(234.33,12.62) v6(234.64,70.79) v6(234.63,8.86) v6(234.99,77.79) v6(234.99,76.78) v6(234.99,75.76) v6(235.52,16.91) v6(235.52,15.09) v6(235.52,13.28) v6(235.65,8.86) v6(236,77.79) v6(236,76.78) v6(236,75.76) v6(236.13,12.64) v6(236.66,8.86) v6(237.02,77.79) v6(237.02,76.78) v6(237.02,75.76) v6(237.68,8.86) v6(237.99,35.6) v6(238.04,77.79) v6(238.04,76.78) v6(238.04,75.76) v6(238.7,8.86) v6(239.05,77.79) v6(239.05,76.78) v6(239.05,75.76) v6(239.71,8.86) v6(239.86,35.6) v6(240.07,77.79) v6(240.07,76.78) v6(240.07,75.76) v6(240.73,8.86) v6(241.08,77.79) v6(241.08,76.78) v6(241.08,75.76) v6(241.74,8.86) v6(242.1,77.79) v6(242.32,75.19) v6(242.49,76.11) v6(242.55,74.32) v6(242.76,8.86) v6(243.12,77.79) v6(243.13,76.78) v6(243.18,73.72) v6(243.78,8.86) v6(244.08,77) v6(244.08,73.48) v6(244.13,77.79) v6(244.79,8.86) v6(245,76.76) v6(245.06,73.75) v6(245.15,77.79) v6(245.24,37.25) v6(245.66,76.12) v6(245.67,74.44) v6(245.79,37.25) v6(245.81,8.86) v6(245.88,75.25) v6(246.16,77.79) v6(246.82,8.86) v6(247.18,77.79) v6(247.66,28.61) v6(247.84,8.86) v6(248.2,77.79) v6(248.36,29.75) v6(248.63,76.93) v6(248.63,75.91) v6(248.68,74.9) v6(248.86,8.86) v6(249.19,74.11) v6(249.87,8.86) v6(250.15,73.81) v6(250.29,27.07) v6(250.29,24.53) v6(250.89,8.86) v6(251.17,73.81) v6(251.9,8.86) v6(252.18,73.81) v6(252.72,9.11) v6(253.2,73.81) v6(253.33,9.7) v6(254.21,73.81) v6(254.29,9.87) v6(255.12,39.71) v6(255.09,27.51) v6(255.23,73.81) v6(255.31,9.87) v6(256.25,73.81) v6(256.32,9.87) v6(256.9,27.49) v6(257.26,73.81) v6(257.42,38.78) v6(257.34,9.87) v6(257.8,42) v6(258.28,73.81) v6(258.36,9.87) v6(258.69,27.5) v6(259.29,73.81) v6(259.37,9.87) v6(260.31,73.81) v6(260.39,9.87) v6(261.33,73.81) v6(261.4,9.87) v6(261.78,42.03) v6(262.34,73.81) v6(262.42,9.87) v6(263.13,36.06) v6(263.36,73.81) v6(263.44,9.87) v6(264.36,73.84) v6(264.45,9.87) v6(265.19,74.31) v6(265.47,9.87) v6(265.54,76.47) v6(265.54,75.28) v6(266,77.79) v6(266.23,39.71) v6(266.48,9.87) v6(267.02,77.79) v6(267.02,76.78) v6(267.02,75.76) v6(267.02,74.75) v6(267.5,9.87) v6(268.03,77.79) v6(268.03,76.78) v6(268.03,75.76) v6(268.03,74.75) v6(268.52,9.87) v6(269.05,77.79) v6(269.05,76.78) v6(269.05,75.76) v6(269.05,74.75) v6(269.53,9.87) v6(270.06,77.79) v6(270.06,76.78) v6(270.06,75.76) v6(270.06,74.75) v6(270.55,9.87) v6(271.08,77.79) v6(271.08,76.78) v6(271.08,75.76) v6(271.08,74.75) v6(271.56,9.87) v6(272.1,77.79) v6(272.1,76.78) v6(272.1,75.76) v6(272.1,74.75) v6(272.58,9.87) v6(273.11,77.79) v6(273.11,76.78) v6(273.11,75.76) v6(273.11,74.75) v6(273.28,16.41) v6(273.6,9.87) v6(274.13,77.79) v6(274.13,76.78) v6(274.13,75.76) v6(274.13,74.75) v6(274.61,9.87) v6(275.04,16.43) v6(275.14,77.79) v6(275.14,76.78) v6(275.14,75.76) v6(275.14,74.75) v6(275.63,9.87) v6(276.16,77.79) v6(276.16,76.78) v6(276.16,74.75) v6(276.64,9.87) v6(277.18,77.79) v6(277.66,9.87) v6(278.19,77.79) v6(278.68,9.87) v6(279.21,77.79) v6(279.21,74.75) v6(279.23,73.87) v6(279.69,9.87) v6(280.22,77.79) v6(280.22,74.75) v6(280.25,73.87) v6(280.71,9.87) v6(281.24,77.79) v6(281.53,25.99) v6(281.53,24.02) v6(281.53,22.05) v6(281.72,9.87) v6(282.26,77.79) v6(282.75,12.75) v6(282.74,9.87) v6(283.27,77.79) v6(283.27,74.75) v6(283.5,25.99) v6(283.5,24.02) v6(283.5,22.05) v6(283.76,9.87) v6(284.22,77.81) v6(284.77,9.87) v6(285.22,76.01) v6(285.3,77.79) v6(285.4,76.82) v6(285.43,75.14) v6(285.47,25.99) v6(285.47,24.02) v6(285.47,22.05) v6(285.79,9.87) v6(285.98,77.46) v6(286.08,74.48) v6(286.24,47.51) v6(286.24,46.39) v6(286.24,45.27) v6(286.8,9.87) v6(286.98,77.75) v6(286.98,74.26) v6(287.13,61.8) v6(287.35,47.51) v6(287.35,46.39) v6(287.35,45.27) v6(287.76,62.43) v6(287.76,61.18) v6(287.82,9.87) v6(287.9,74.5) v6(288.01,77.47) v6(288.38,61.8) v6(288.47,47.51) v6(288.47,46.39) v6(288.47,45.27) v6(288.59,76.82) v6(288.55,75.16) v6(288.77,76.01) v6(288.84,77.79) v6(288.84,9.87) v6(289.79,66.19) v6(289.79,65.55) v6(289.79,64.92) v6(289.85,77.79) v6(289.85,9.87) v6(290.87,77.79) v6(290.87,9.87) v6(291.88,77.79) v6(291.84,75.23) v6(291.88,9.87) v6(291.97,36.44) v6(291.97,34.21) v6(292.9,77.79) v6(292.9,9.87) v6(293.09,35.32) v6(293.92,77.79) v6(293.92,9.87) v6(294.21,36.44) v6(294.21,34.21) v6(294.61,58.18) v6(294.87,57.68) v6(294.93,77.79) v6(294.93,9.87) v6(295.25,58.18) v6(295.5,57.68) v6(295.88,58.18) v6(295.95,77.79) v6(295.95,9.87) v6(296.4,36.95) v6(296.8,21.61) v6(296.96,77.79) v6(297.02,22.49) v6(297.01,20.78) v6(296.96,9.87) v6(297.98,77.79) v6(297.98,9.87) v6(298.35,17.18) v6(299,77.79) v6(299,9.87) v6(300.01,77.79) v6(299.96,9.82) v6(300.11,20.72) v6(300.13,22.48) v6(300.39,21.61) v6(300.85,9.54) v6(301.03,77.21) v6(301.66,9.04) v6(301.79,76.45) v6(302.3,8.32) v6(302.81,75.43) v6(302.73,7.41) v6(302.88,6.44) v6(302.88,5.43) v6(302.88,4.41) v6(302.88,3.4) v6(302.88,2.38) v6(302.88,1.36) v6(303.26,0.48) v6(303.82,74.42) v6(304.02,56.61) v6(304.15,46.5) v6(304.14,26.17) v6(304.28,0.45) v6(304.6,73.5) v6(304.61,72.23) v6(304.71,26.18) v6(305.08,64.5) v6(305.22,57.96) v6(305.22,56.94) v6(305.22,46.3) v6(305.22,45.28) v6(305.29,0.45) v6(305.53,70.03) v6(305.64,44.35) v6(305.75,58.92) v6(306.31,0.45) v6(306.56,44.21) v6(306.85,26.18) v6(307,59.02) v6(307.4,70.56) v6(307.48,62.55) v6(307.43,26.18) v6(307.58,44.21) v6(308.6,70.55) v6(308.95,0.45) v6(309.21,62.55) v6(309.61,70.55) v6(309.97,0.45) v6(310.43,44.44) v6(310.45,58.77) v6(310.63,70.55) v6(310.98,0.45) v6(311.47,58.77) v6(311.44,44.44) v6(311.64,70.55) v6(312,0.45) v6(312.66,70.55) v6(313.02,0.45) v6(313.42,25.57) v6(313.52,70.3) v6(313.63,69.13) v6(313.63,68.12) v6(313.63,67.1) v6(313.63,66.08) v6(313.63,65.07) v6(313.63,64.05) v6(313.63,63.04) v6(313.64,31.87) v6(313.73,62.07) v6(313.85,27.04) v6(314.03,0.45) v6(314.13,61.26) v6(314.41,44.39) v6(314.41,43.38) v6(314.41,42.36) v6(314.41,41.42) v6(314.46,58.77) v6(314.84,40.3) v6(314.92,0.6) v6(315.1,60.52) v6(315.12,59.48) v6(315.1,10.69) v6(315.1,9.67) v6(315.1,8.65) v6(315.1,7.64) v6(315.1,6.62) v6(315.1,5.61) v6(315.1,4.59) v6(315.1,3.57) v6(315.1,2.56) v6(315.1,1.54) v6(315.66,39.44) v6(315.66,38.42) v6(315.66,28.21) v6(315.66,27.2) v8(5.21,71.19) v8(5.21,70.86) v8(5.21,70.52) v8(5.21,70.18) v8(5.21,69.85) v8(5.21,69.51) v8(5.21,69.17) v8(5.21,68.84) v8(5.21,68.5) v8(5.21,68.17) v8(5.21,67.83) v8(5.21,67.49) v8(5.21,67.16) v8(5.21,55.97) v8(5.21,55.64) v8(5.21,55.3) v8(5.21,54.96) v8(5.21,54.63) v8(5.21,54.29) v8(5.21,53.95) v8(5.21,53.62) v8(5.21,53.28) v8(5.21,52.95) v8(5.21,52.61) v8(5.21,52.27) v8(5.21,51.94) v8(16.69,37.73) v8(16.69,37.48) v8(16.67,36.68) v8(16.67,36.43) v8(20.05,40.79) v8(20.05,40.54) v8(21.27,44.45) v8(21.52,44.45) v8(21.73,43.99) v8(21.98,43.99) v8(22.94,44.81) v8(23.19,44.81) v8(23.45,44.81) v8(23.7,44.81) v8(24.41,44.49) v8(25.39,74.26) v8(65.47,40.27) v8(65.94,32.85) v8(71.01,33.99) v8(71.01,33.33) v8(86.35,34.46) v8(91.38,34.46) v8(107.43,69.05) v8(107.68,69.05) v8(121.87,55.66) v8(124.63,55.11) v8(124.88,55.11) v8(125.6,55.14) v8(125.62,51.4) v8(125.86,55.14) v8(125.87,51.4) v8(126.11,55.14) v8(126.13,51.4) v8(126.54,46.74) v8(126.84,54.34) v8(127.1,54.34) v8(127.27,68.53) v8(127.27,67.86) v8(127.27,67.19) v8(127.25,46.74) v8(127.35,54.34) v8(127.96,46.74) v8(128.07,68.53) v8(128.07,67.86) v8(128.07,67.19) v8(128.04,54.34) v8(128.29,54.34) v8(128.54,54.34) v8(128.88,49.3) v8(128.87,46.03) v8(129.14,49.3) v8(129.13,46.03) v8(129.23,54.34) v8(129.38,46.03) v8(129.48,54.34) v8(129.74,54.34) v8(129.75,46.01) v8(129.89,49.21) v8(130.01,46.01) v8(130.22,64.34) v8(130.22,64.09) v8(130.15,49.21) v8(130.26,46.01) v8(130.48,54.36) v8(130.74,54.36) v8(131,66.92) v8(130.99,54.36) v8(131.25,66.92) v9(9.04,43.33) v9(9.24,45.48) v9(9.5,74.4) v9(10.54,17.77) v9(10.94,47.45) v9(11.14,44.18) v9(11.24,2.53) v9(11.81,17.77) v9(12.22,56.48) v9(12.51,2.53) v9(12.8,48.66) v9(13.08,17.77) v9(13.79,52.64) v9(13.78,2.53) v9(14.19,46.2) v9(14.35,17.77) v9(14.35,16.5) v9(14.35,15.23) v9(14.35,13.96) v9(14.35,12.69) v9(14.35,11.42) v9(14.35,10.15) v9(14.35,8.88) v9(14.35,7.61) v9(14.35,6.34) v9(14.35,5.07) v9(14.35,3.8) v9(14.7,47.36) v9(14.83,37.09) v9(14.83,35.71) v9(14.83,32.97) v9(14.83,31.58) v9(14.83,29.93) v9(14.83,28.53) v9(14.83,27.39) v9(14.83,25.99) v9(14.96,71.09) v9(15.21,44.3) v9(15.19,41.76) v9(15.14,40.1) v9(15.53,49.56) v9(15.72,33.89) v9(16.94,43.44) v9(17.18,54.16) v9(17.26,75.94) v9(17.69,45.46) v9(18.21,43.12) v9(18.43,65.18) v9(18.5,57.93) v9(18.58,45.46) v9(19.08,57.78) v9(19.13,56.19) v9(19.63,17.13) v9(20.23,44.55) v9(20.34,69.78) v9(20.83,57.78) v9(20.93,31.98) v9(20.93,17.61) v9(21.2,43.5) v9(21.63,56.76) v9(21.92,14.52) v9(22.35,52.92) v9(23.21,21.37) v9(23.54,18.26) v9(23.54,14.52) v9(23.7,56.15) v9(23.68,43.55) v9(24.04,70.73) v9(24.09,21.33) v9(24.66,46.65) v9(25.37,23.69) v9(25.47,56.55) v9(25.47,55.99) v9(25.48,46.6) v9(25.69,69.02) v9(26.1,42.06) v9(26.55,43.68) v9(26.77,52.27) v9(26.83,76.12) v9(26.92,67.39) v9(26.92,66.82) v9(26.92,66.25) v9(26.94,74) v9(26.94,73.42) v9(26.98,62.29) v9(26.98,60.38) v9(26.98,58.48) v9(26.97,56.84) v9(27.15,71.61) v9(27.15,64.43) v9(27.25,62.29) v9(27.25,60.38) v9(27.25,58.48) v9(27.77,72.14) v9(27.98,70.73) v9(28.04,23.69) v9(28.26,73.44) v9(28.35,62.29) v9(28.35,60.38) v9(28.35,58.48) v9(28.54,36.91) v9(28.64,62.29) v9(28.64,60.38) v9(28.64,58.48) v9(28.69,37.96) v9(28.75,45.02) v9(28.73,44.72) v9(29.68,62.29) v9(29.68,60.38) v9(29.68,58.48) v9(29.79,73.04) v9(29.79,72.47) v9(29.79,65.74) v9(29.79,65.17) v9(29.97,62.29) v9(29.97,60.38) v9(29.97,58.48) v9(30.03,50.56) v9(30.12,47.64) v9(30.11,46.12) v9(30.12,44.6) v9(30.2,51.38) v9(30.48,47.64) v9(30.47,46.12) v9(30.48,44.6) v9(30.9,51.38) v9(31,65.3) v9(31,64.6) v9(31.22,75.72) v9(31.33,67.79) v9(31.33,67.21) v9(31.33,66.64) v9(31.53,51.38) v9(31.69,38.28) v9(31.93,47.64) v9(31.93,46.12) v9(31.93,44.6) v9(32.08,63.32) v9(32.28,47.64) v9(32.28,46.12) v9(32.28,44.6) v9(32.55,37.32) v9(32.73,28.7) v9(32.99,55.02) v9(33.01,51.35) v9(33.04,16.27) v9(33.3,67.7) v9(33.31,21.56) v9(33.63,51.38) v9(33.72,46.12) v9(33.73,47.64) v9(33.73,44.6) v9(34.09,47.64) v9(34.07,46.12) v9(34.09,44.6) v9(34.43,39.27) v9(34.62,36.76) v9(34.82,15.5) v9(34.82,14.61) v9(34.82,13.72) v9(35.04,75.71) v9(35.06,75.11) v9(35.03,58.95) v9(35.21,66.39) v9(35.85,77.59) v9(36.05,76.5) v9(36.05,75.93) v9(36.27,75.27) v9(36.33,60.85) v9(36.46,74.5) v9(36.47,73.62) v9(36.87,75.27) v9(36.99,65.16) v9(36.97,34.49) v9(38.29,67.06) v9(38.23,61.8) v9(38.66,76.54) v9(38.66,75.96) v9(38.66,75.33) v9(39.12,61.34) v9(39.67,70.76) v9(40.06,61.35) v9(40.54,15.9) v9(40.73,67.91) v9(41.95,68.7) v9(42.9,37.89) v9(43.7,37.43) v9(43.66,34.78) v9(43.66,33.14) v9(43.66,31.49) v9(43.74,70.05) v9(43.94,34.78) v9(43.94,33.14) v9(43.94,31.49) v9(44.07,30.59) v9(44.14,29.36) v9(44.3,71.77) v9(44.26,71.2) v9(44.31,37.41) v9(44.31,28.59) v9(44.7,72.5) v9(45.19,34.78) v9(45.19,33.14) v9(45.19,31.49) v9(45.44,64.59) v9(45.48,34.78) v9(45.48,33.14) v9(45.48,31.49) v9(45.63,58.73) v9(46.27,58.73) v9(46.3,38.22) v9(46.67,34.78) v9(46.67,33.14) v9(46.67,31.49) v9(46.85,58.73) v9(46.92,45.71) v9(46.96,34.78) v9(46.96,33.14) v9(46.96,31.49) v9(47.22,64.59) v9(47.24,69.45) v9(47.46,58.9) v9(47.74,58.9) v9(48.5,73.44) v9(49,65.5) v9(49.16,69.18) v9(49.58,50.61) v9(50.52,65.33) v9(50.53,66.08) v9(51.58,72.26) v9(52.08,65.14) v9(52.18,72.26) v9(52.21,63.52) v9(53.59,29.63) v9(53.61,27.68) v9(53.61,26) v9(53.61,24.86) v9(53.61,23.59) v9(53.61,22.32) v9(53.61,21.05) v9(53.61,19.78) v9(53.61,18.64) v9(53.61,17.37) v9(53.61,16.1) v9(53.61,14.83) v9(53.61,13.56) v9(53.66,31.31) v9(54.88,69.38) v9(55.02,67.76) v9(55.1,31.34) v9(55.18,72.26) v9(55.17,10.44) v9(56.13,67.84) v9(56.13,67.27) v9(56.37,31.34) v9(56.44,10.44) v9(57,27.88) v9(57.56,14.88) v9(57.56,14.24) v9(57.64,31.34) v9(57.71,10.44) v9(58.05,63.64) v9(58.22,27.2) v9(58.48,69.38) v9(58.78,72.26) v9(58.91,31.34) v9(58.98,10.44) v9(59.07,67.84) v9(59.46,14.24) v9(59.74,29.36) v9(60.18,31.34) v9(60.28,69.38) v9(60.25,10.44) v9(60.58,72.26) v9(61.07,62.76) v9(61.23,64.42) v9(61.38,67.58) v9(61.45,31.34) v9(61.52,10.44) v9(62.01,63.43) v9(62.08,69.38) v9(62.38,72.26) v9(62.72,31.34) v9(62.76,14.1) v9(62.79,10.44) v9(63.88,69.38) v9(63.99,31.34) v9(64.06,10.44) v9(65.26,31.34) v9(65.42,50.91) v9(65.33,10.44) v9(65.58,67.04) v9(65.68,69.38) v9(66.53,31.34) v9(66.57,14.24) v9(66.6,10.44) v9(67.16,65.7) v9(67.48,69.38) v9(67.8,31.34) v9(67.84,14.24) v9(67.87,10.44) v9(68.56,62.81) v9(68.83,47.95) v9(69.07,31.34) v9(69.14,10.44) v9(69.28,69.38) v9(69.47,61.93) v9(69.47,47.95) v9(69.65,14.24) v9(70.31,66.67) v9(70.34,31.34) v9(70.41,10.44) v9(71.23,61.94) v9(71.61,31.34) v9(71.68,10.44) v9(72.15,29.36) v9(72.88,31.34) v9(72.95,10.44) v9(73.82,26.89) v9(74.15,31.34) v9(74.22,10.44) v9(74.59,26.41) v9(75.42,31.34) v9(75.49,10.44) v9(76.69,31.34) v9(76.76,10.44) v9(77.96,31.34) v9(78.03,10.44) v9(79.23,31.34) v9(79.3,10.44) v9(80.02,75.71) v9(80.24,14.9) v9(80.5,31.34) v9(80.57,10.44) v9(81.13,14.7) v9(81.29,53.23) v9(81.81,50.88) v9(81.77,31.34) v9(81.76,26.46) v9(81.76,14.7) v9(81.84,10.44) v9(81.98,75.34) v9(82.16,73.53) v9(82.69,53.23) v9(82.75,50.88) v9(83.04,31.34) v9(83.11,10.44) v9(83.37,53.23) v9(83.76,50.88) v9(84.31,31.34) v9(84.38,10.44) v9(85.58,31.34) v9(85.65,10.44) v9(85.75,74.12) v9(85.8,53.28) v9(85.8,52.65) v9(86.85,31.34) v9(86.92,10.44) v9(88.12,31.34) v9(88.19,10.44) v9(89.39,31.34) v9(89.47,40.37) v9(89.47,39.81) v9(89.46,10.44) v9(90.17,53.23) v9(90.17,52.6) v9(90.66,31.34) v9(90.73,10.44) v9(91.34,51.73) v9(91.81,40.37) v9(91.9,49.93) v9(91.93,31.34) v9(92,10.44) v9(92.4,40.99) v9(92.39,40.39) v9(92.51,53.26) v9(92.49,51.64) v9(92.58,49.93) v9(92.96,41.55) v9(93.01,13.99) v9(93.2,31.34) v9(93.27,10.44) v9(93.6,39.83) v9(94.47,31.34) v9(94.54,10.44) v9(94.8,39.83) v9(95.16,29.28) v9(95.74,31.34) v9(95.81,10.44) v9(95.99,40.51) v9(96.11,26.79) v9(96.4,28.38) v9(96.57,40.49) v9(96.63,20.99) v9(96.63,20.12) v9(96.73,19.02) v9(96.9,27.12) v9(97.01,31.34) v9(97.08,10.44) v9(97.13,40.51) v9(97.34,47.48) v9(97.71,45.64) v9(97.7,44.29) v9(97.7,41.71) v9(97.7,40.51) v9(97.74,27.02) v9(97.92,47.48) v9(97.91,13.91) v9(98.27,41.71) v9(98.27,40.51) v9(98.28,31.34) v9(98.35,10.44) v9(98.59,21.7) v9(98.68,47.67) v9(98.78,12.88) v9(99.1,41.75) v9(99.19,19.93) v9(99.3,31.34) v9(99.41,40.51) v9(99.37,10.44) v9(99.99,40.51) v9(100.27,41.48) v9(100.71,31.29) v9(100.71,30.02) v9(100.71,28.75) v9(100.71,27.48) v9(100.71,26.21) v9(100.71,24.94) v9(100.71,23.67) v9(100.71,22.4) v9(100.71,21.13) v9(100.71,19.86) v9(100.71,18.59) v9(100.71,17.37) v9(100.71,16.1) v9(100.71,14.83) v9(100.71,13.56) v9(101.74,65.12) v9(102.79,28.67) v9(102.87,31.13) v9(102.89,30.54) v9(102.93,26.55) v9(103.08,52.66) v9(103.06,52.03) v9(104.11,12.63) v9(104.62,40.51) v9(105.19,40.51) v9(106.08,30.97) v9(107.67,45.7) v9(108.5,29.95) v9(108.63,53) v9(109.05,65.78) v9(109.22,52.43) v9(109.31,43.6) v9(109.32,13.99) v9(110.74,40.28) v9(110.88,52.96) v9(110.93,41.73) v9(111.54,40.61) v9(111.9,51.57) v9(112.28,45.23) v9(112.34,43.39) v9(117.45,29.62) v9(121.08,29.1) v9(121.7,28.86) v9(124.19,31.51) v9(125.17,45.28) v9(125.4,31.51) v9(126.02,29.24) v9(128.31,30.99) v9(128.79,38.11) v9(128.79,37.11) v9(131.84,44.21) v9(131.84,31.51) v9(195.01,33.07) v9(197.42,30.93) v9(197.43,33.24) v9(197.83,68.46) v9(198.14,33.24) v9(198.13,30.93) v9(200.72,32.52) v9(200.72,31.57) v9(201.51,42.66) v9(201.84,31.86) v9(202.83,68.85) v9(203,30.5) v9(205.56,47.58) v9(211.05,18.01) v9(212.53,47.33) v9(212.53,46.75) v9(212.53,46.18) v9(212.83,44.02) v9(212.95,17.47) v9(214.1,17.89) v9(215.04,37.86) v9(215.04,36.98) v9(215.04,24.53) v9(215.2,23.77) v9(215.2,23.13) v9(215.2,22.5) v9(218.73,31.35) v9(219.98,24.53) v9(222.48,51.36) v9(224.95,38.07) v9(225.7,13.85) v9(227.05,50.86) v9(227.68,50.86) v9(228.17,11.75) v9(228.74,42.94) v9(229.08,44.18) v9(230.1,48.7) v9(231.75,10.31) v9(233.73,72.62) v9(234.03,10.31) v9(234.34,20.08) v9(239.24,10.61) v9(242.54,18.09) v9(242.54,14.15) v9(245.86,39.89) v9(250.42,45.54) v9(251.47,53.27) v9(251.47,50.66) v9(253,36.7) v9(253.4,57.11) v9(253.72,34.16) v9(253.72,33.39) v9(253.89,33.78) v9(254.1,42.67) v9(254.1,34.16) v9(254.1,33.39) v9(254.39,25.86) v9(254.74,42.67) v9(254.86,36.11) v9(255.12,38.71) v9(255.5,42.67) v9(255.5,36.11) v9(256.13,42.67) v9(256.83,50.69) v9(257.09,30.84) v9(257.28,36.7) v9(257.35,59.33) v9(257.47,60.94) v9(257.68,34.92) v9(257.68,34.56) v9(257.66,30.84) v9(258.01,54.06) v9(257.97,34.75) v9(258.27,34.92) v9(258.27,34.56) v9(258.23,30.84) v9(258.52,50.64) v9(258.86,36.89) v9(258.93,33.78) v9(259.12,48.38) v9(259.51,39.78) v9(259.6,50.78) v9(259.84,63.39) v9(259.84,62.25) v9(259.84,61.11) v9(259.83,58.82) v9(259.83,58.24) v9(259.9,54.63) v9(259.84,54.06) v9(259.84,53.49) v9(259.89,52.09) v9(260.2,55.31) v9(260.26,45.82) v9(260.26,41.76) v9(260.28,39.78) v9(260.26,36.3) v9(261.05,63.39) v9(262.32,63.39) v9(262.28,44.02) v9(262.76,45.1) v9(263.24,47.97) v9(264.51,46.35) v9(265.21,42.67) v9(265.34,48.88) v9(265.98,36.11) v9(266.04,65.27) v9(266.04,64.06) v9(266.04,34.87) v9(266.2,17.29) v9(266.55,36.11) v9(266.64,64.53) v9(266.64,63.39) v9(267.37,48.88) v9(268.01,45.22) v9(268.32,36.7) v9(268.41,65.14) v9(268.52,14.33) v9(269.8,49.42) v9(269.8,48.79) v9(269.79,14.33) v9(271.12,48.88) v9(271.06,14.33) v9(271.25,34.31) v9(271.25,33.55) v9(271.42,33.93) v9(271.63,34.31) v9(271.63,33.55) v9(272.36,63.94) v9(273.4,23.89) v9(273.93,63.52) v9(274.29,31.87) v9(274.87,31.29) v9(274.97,59.58) v9(274.97,57.23) v9(274.97,56.47) v9(274.94,55.2) v9(275.44,31.29) v9(275.63,62.38) v9(275.94,56.89) v9(276.01,31.29) v9(276.17,61.36) v9(276.9,56.7) v9(276.91,48.98) v9(276.83,33.67) v9(276.83,33.17) v9(276.96,33.42) v9(277.09,33.67) v9(277.09,33.17) v9(277.5,50) v9(277.62,26.75) v9(277.62,26.12) v9(277.8,58.12) v9(277.85,59.44) v9(277.85,58.87) v9(278.04,24.45) v9(278.78,27.32) v9(278.8,24.94) v9(279.59,29.61) v9(280.39,30) v9(281.15,29.58) v9(281.52,15.91) v9(283.16,17.58) v9(284.85,40.07) v9(285.57,40.87) v9(287.54,37.86) v9(289.53,42.14) v9(289.62,40.48) v9(289.66,32.02) v9(290.66,14.82) v9(290.66,14.52) v9(290.93,40.52) v9(291.11,39.58) v9(291.03,14.68) v9(291.07,13.88) v9(291.57,30.98) v9(293.72,14.68) v9(293.68,13.88) v9(293.85,31.44) v9(294.14,14.83) v9(294.14,14.53) v9(294.59,14.68) v9(294.62,13.88) v9(295.54,54.49) v9(297.27,14.68) v9(297.24,13.88) v9(297.63,14.84) v9(297.64,14.37) v9(298.4,16.53) v9(298.42,14.75) v9(298.47,15.64) v9(298.48,13.16) v9(299.44,56.55) v9(301.2,32.06) v9(301.43,58.53) v9(301.43,57.26) v9(301.43,55.99) v9(301.43,54.72) v9(301.43,53.45) v9(301.43,52.18) v9(301.43,50.91) v9(301.43,49.64) v9(301.43,48.37) v9(301.43,47.1) v9(301.43,45.83) v9(301.43,44.56) v9(301.43,43.29) v9(302.7,43.29) v9(302.83,58.53) v9(303.63,25.37) v9(303.97,43.29) v9(304,4.65) v9(304.23,58.53) v9(305.24,43.29) v9(306.51,43.29) v9(308.27,1.8) v9(309.27,3.4) v10(9.18,55.72) v10(9.43,55.72) v10(50.35,20.25) v10(50.36,19.99) v10(50.34,19.02) v10(50.34,18.77) v10(50.34,17.78) v10(50.34,17.52) v10(104.25,54.67) v10(104.51,54.67) v10(106.12,54.37) v10(106.37,54.37) v10(109.32,54.8) v10(109.98,54.8) v11(7.43,51.2) v11(7.71,52.24) v11(7.74,53.15) v11(7.75,52.87) v11(7.85,51.95) v11(7.94,68.1) v11(7.94,67.82) v11(8.47,60.34) v11(8.47,59.45) v11(8.6,62.99) v11(8.6,62.48) v11(8.61,61.74) v11(8.61,61.23) v11(9.6,74.81) v11(10.49,65.92) v11(10.54,52.83) v11(10.58,51.75) v11(10.64,54.73) v11(10.64,54.46) v11(10.66,53.74) v11(10.65,53.47) v11(10.64,2.19) v11(10.74,71.01) v11(11.21,51.75) v11(11.66,2.19) v11(11.78,72.01) v11(11.87,71.05) v11(11.84,52.18) v11(12.11,52.18) v11(12.67,2.19) v11(12.73,52.17) v11(12.99,65.12) v11(13,52.16) v11(13.26,65.12) v11(13.69,16.41) v11(13.69,15.4) v11(13.69,14.38) v11(13.69,11.33) v11(13.69,10.67) v11(13.69,8.29) v11(13.69,7.59) v11(13.69,5.24) v11(13.69,4.22) v11(13.69,3.21) v11(13.69,2.19) v11(13.9,51.25) v11(15.33,63.49) v11(15.33,62.22) v11(15.33,60.95) v11(15.33,59.68) v11(15.33,58.41) v11(15.33,57.14) v11(15.33,55.87) v11(15.33,54.6) v11(15.33,53.33) v11(15.33,52.06) v11(15.33,50.79) v11(15.33,49.52) v11(15.33,48.25) v11(15.33,46.98) v11(15.33,45.71) v11(15.33,44.44) v11(15.33,43.17) v11(15.33,41.9) v11(15.33,40.63) v11(15.33,39.36) v11(15.33,38.09) v11(15.33,36.82) v11(15.33,35.55) v11(15.33,34.28) v11(15.33,33.01) v11(15.33,31.74) v11(15.33,30.47) v11(15.33,29.2) v11(15.33,27.93) v11(15.47,25.46) v11(16.37,27.29) v11(16.6,63.49) v11(16.76,57.69) v11(16.76,57.13) v11(16.76,56.57) v11(16.76,56.01) v11(17.44,42.26) v11(17.64,27.29) v11(17.87,63.49) v11(17.83,48.24) v11(18.17,20.39) v11(18.91,27.29) v11(19.14,63.49) v11(19.59,43.81) v11(20.18,27.29) v11(20.41,63.49) v11(20.36,47.67) v11(21.45,27.29) v11(21.68,63.49) v11(22.72,27.29) v11(22.87,62.31) v11(22.87,59.97) v11(22.95,63.49) v11(23.43,61.14) v11(23.43,59.97) v11(23.99,59.97) v11(23.99,27.29) v11(24.22,63.49) v11(24.72,74.43) v11(24.72,68.42) v11(25.22,69.42) v11(25.26,27.29) v11(25.49,63.49) v11(25.73,74.93) v11(25.73,74.43) v11(26.23,74.93) v11(26.23,74.43) v11(26.23,73.93) v11(26.55,59.97) v11(26.53,27.29) v11(26.76,63.49) v11(27.11,59.97) v11(27.8,27.29) v11(28.03,63.49) v11(28.23,64.92) v11(29.07,27.29) v11(29.3,63.49) v11(29.78,59.93) v11(30.24,77.89) v11(30.29,75.53) v11(30.39,55.99) v11(30.34,27.29) v11(30.57,63.49) v11(31.32,78.56) v11(31.39,74.89) v11(31.61,27.29) v11(31.84,63.49) v11(32.63,78.56) v11(32.63,74.89) v11(32.88,27.29) v11(33.11,63.49) v11(33.22,78.58) v11(33.61,51.78) v11(33.62,51.26) v11(33.62,51.01) v11(33.62,50.5) v11(33.6,48.5) v11(33.62,48.25) v11(33.62,47.99) v11(33.62,47.73) v11(33.62,47.48) v11(33.62,47.22) v11(33.63,51.52) v11(33.63,50.75) v11(33.64,50.24) v11(33.64,49.97) v11(33.65,49.71) v11(33.65,49.45) v11(33.63,46.96) v11(33.76,46.72) v11(33.76,46.46) v11(33.76,46.19) v11(33.83,78.56) v11(33.83,74.89) v11(33.89,51.77) v11(33.9,51.51) v11(33.91,51.24) v11(33.92,50.98) v11(33.88,48.5) v11(33.89,48.24) v11(33.9,47.94) v11(33.91,47.68) v11(34.15,27.29) v11(34.42,78.57) v11(34.38,63.49) v11(35.03,78.56) v11(35.03,74.89) v11(35.42,27.29) v11(35.48,78.33) v11(35.69,78.56) v11(35.65,63.49) v11(36.22,78.56) v11(36.22,74.89) v11(36.25,61.1) v11(36.25,60.84) v11(36.25,60.58) v11(36.25,60.33) v11(36.5,61.09) v11(36.5,60.84) v11(36.5,60.58) v11(36.5,60.33) v11(36.69,27.29) v11(36.77,61.1) v11(36.76,60.84) v11(36.76,60.58) v11(36.76,60.33) v11(36.92,63.49) v11(37.02,61.1) v11(37.02,60.84) v11(37.02,60.58) v11(37.02,60.33) v11(37.28,61.1) v11(37.28,60.84) v11(37.28,60.58) v11(37.28,60.33) v11(37.43,78.56) v11(37.43,74.89) v11(37.54,61.1) v11(37.54,60.84) v11(37.54,60.58) v11(37.53,60.33) v11(37.96,27.29) v11(38.19,63.49) v11(38.63,78.56) v11(38.63,74.89) v11(39.23,27.29) v11(39.46,63.49) v11(39.71,60.55) v11(39.83,78.56) v11(39.83,74.89) v11(40.5,27.29) v11(40.55,26.13) v11(40.55,24.86) v11(40.55,23.59) v11(40.55,22.32) v11(40.55,21.05) v11(40.55,19.78) v11(40.55,18.51) v11(40.55,17.24) v11(40.55,15.97) v11(40.55,14.7) v11(40.55,13.43) v11(40.65,57.63) v11(40.73,63.49) v11(40.91,57.63) v11(41.03,78.56) v11(41.03,74.89) v11(40.99,56.09) v11(41.82,47.14) v11(41.84,43.99) v11(41.86,28.52) v11(41.86,28.24) v11(41.86,27.96) v11(41.88,27.29) v11(41.88,27.01) v11(41.88,26.73) v11(41.89,26.05) v11(41.89,25.77) v11(41.89,25.49) v11(41.87,24.81) v11(41.87,24.53) v11(41.87,24.25) v11(42,63.49) v11(41.95,30.96) v11(41.95,30.68) v11(41.95,30.4) v11(41.96,29.73) v11(41.96,29.45) v11(41.96,29.17) v11(42.01,13.37) v11(42.07,47.14) v11(42.22,78.56) v11(42.22,74.89) v11(42.33,47.14) v11(42.58,47.14) v11(42.84,47.14) v11(43.09,47.14) v11(43.27,63.49) v11(43.29,60.79) v11(43.29,58.69) v11(43.29,56.6) v11(43.28,13.37) v11(43.34,47.14) v11(43.43,78.56) v11(43.43,74.89) v11(43.6,47.14) v11(43.85,47.14) v11(44.04,54.38) v11(44.04,54.12) v11(44.04,53.86) v11(44.11,47.14) v11(44.09,39.91) v11(44.44,44.09) v11(44.63,78.56) v11(44.63,74.89) v11(44.54,63.49) v11(44.55,13.37) v11(45.38,60.79) v11(45.38,58.69) v11(45.38,56.6) v11(45.81,63.49) v11(45.79,50.8) v11(45.82,13.37) v11(45.83,78.56) v11(45.83,74.89) v11(47.03,78.56) v11(47.03,74.89) v11(47.08,63.49) v11(47.09,13.37) v11(47.48,60.79) v11(47.48,58.69) v11(47.48,56.6) v11(48.27,74.89) v11(48.33,78.56) v11(48.35,63.49) v11(48.36,13.37) v11(48.83,54.36) v11(49.41,77.89) v11(49.4,76.69) v11(49.36,75.53) v11(49.62,63.49) v11(49.63,13.37) v11(49.94,77.22) v11(49.94,76.12) v11(50.89,63.49) v11(50.9,13.37) v11(50.97,56.88) v11(51.03,60.35) v11(51.06,59.51) v11(51.08,58.63) v11(51.05,57.77) v11(51.06,56.05) v11(51.06,55.25) v11(52.16,63.49) v11(52.17,13.37) v11(52.74,61.18) v11(52.74,59.64) v11(53.43,63.49) v11(53.44,13.37) v11(53.66,59.33) v11(53.66,58.69) v11(53.66,58.06) v11(53.85,61.49) v11(54.7,63.49) v11(54.71,13.37) v11(55.97,63.49) v11(55.98,13.37) v11(56.23,16.5) v11(56.81,58.9) v11(57.24,63.49) v11(57.25,13.37) v11(58.51,63.49) v11(58.52,13.37) v11(58.58,61.83) v11(59.78,63.49) v11(59.79,13.37) v11(61.05,63.49) v11(61.06,13.37) v11(61.15,33.17) v11(61.54,62.31) v11(62.32,63.49) v11(62.33,13.37) v11(62.72,76.89) v11(63,75.71) v11(63,74.44) v11(63,73.17) v11(63,71.9) v11(63,70.63) v11(63,69.36) v11(63,68.09) v11(63,66.82) v11(63,65.55) v11(63,64.28) v11(62.96,50.76) v11(63.6,13.37) v11(64.87,13.37) v11(64.97,72.3) v11(64.97,72.05) v11(64.97,71.79) v11(64.97,71.53) v11(64.97,71.27) v11(64.97,71.01) v11(65.01,58.49) v11(65.23,72.3) v11(65.23,72.04) v11(65.23,71.78) v11(65.23,71.53) v11(65.23,71.27) v11(65.23,71.01) v11(65.38,41.53) v11(65.38,39.01) v11(65.48,72.3) v11(65.48,72.05) v11(65.49,71.78) v11(65.49,71.53) v11(65.49,71.27) v11(65.49,71.01) v11(65.74,72.3) v11(65.74,72.04) v11(65.74,71.78) v11(65.74,71.53) v11(65.74,71.26) v11(65.74,71.01) v11(66.14,13.37) v11(66.25,14.84) v11(67.35,62.25) v11(67.35,61.04) v11(67.41,13.37) v11(67.85,55.06) v11(67.98,62.25) v11(67.98,61.04) v11(68.62,62.25) v11(68.62,61.04) v11(68.68,13.37) v11(69.25,62.25) v11(69.25,61.04) v11(69.76,33.07) v11(69.89,62.25) v11(69.89,61.04) v11(69.95,13.37) v11(70.19,71.47) v11(70.2,70.61) v11(70.2,70.21) v11(70.19,69.86) v11(70.18,69.51) v11(70.18,69.12) v11(70.18,68.71) v11(70.17,68.31) v11(70.15,67.9) v11(70.14,67.46) v11(70.48,71.48) v11(70.52,67.9) v11(70.51,67.46) v11(70.52,67.04) v11(70.56,70.61) v11(70.56,70.21) v11(70.56,69.86) v11(70.55,69.51) v11(70.55,69.12) v11(70.55,68.71) v11(70.53,68.31) v11(70.57,29.59) v11(70.77,71.47) v11(70.92,70.21) v11(70.9,69.86) v11(70.9,69.5) v11(70.9,69.11) v11(70.9,68.7) v11(70.89,68.29) v11(70.88,67.89) v11(70.86,67.44) v11(70.89,67.04) v11(70.92,66.62) v11(70.93,70.61) v11(71.22,67.44) v11(71.16,62.25) v11(71.16,29.58) v11(71.22,13.37) v11(71.28,70.61) v11(71.27,70.21) v11(71.26,69.86) v11(71.26,69.5) v11(71.26,69.11) v11(71.26,68.7) v11(71.25,68.29) v11(71.23,67.89) v11(71.25,67.02) v11(71.28,66.62) v11(71.4,71.42) v11(71.61,68.29) v11(71.6,67.89) v11(71.59,67.44) v11(71.6,67.02) v11(71.7,71.42) v11(71.65,70.61) v11(71.65,70.21) v11(71.64,69.86) v11(71.63,69.5) v11(71.63,69.11) v11(71.63,68.7) v11(71.64,66.6) v11(72.01,71.42) v11(72.01,70.61) v11(72.01,70.21) v11(72.01,69.86) v11(72.01,69.5) v11(72.11,68.99) v11(72.11,68.61) v11(72.1,68.2) v11(72.08,67.8) v11(72.07,67.35) v11(72.07,66.93) v11(72.1,66.52) v11(72.27,33.07) v11(72.35,70.61) v11(72.34,70.2) v11(72.34,69.84) v11(72.33,69.5) v11(72.41,68.2) v11(72.4,67.8) v11(72.39,67.35) v11(72.43,68.99) v11(72.43,68.61) v11(72.45,66.93) v11(72.47,66.52) v11(72.49,13.37) v11(72.69,70.2) v11(72.69,69.84) v11(72.68,69.5) v11(72.78,68.99) v11(72.78,68.61) v11(72.77,68.2) v11(72.76,67.8) v11(72.74,67.35) v11(72.77,66.93) v11(72.85,66.52) v11(73.06,69.83) v11(73.06,69.5) v11(73.06,62.25) v11(73.06,61.04) v11(73.16,68.99) v11(73.16,68.61) v11(73.15,68.2) v11(73.14,67.8) v11(73.13,67.35) v11(73.13,66.93) v11(73.16,66.52) v11(73.35,71.2) v11(73.48,69.82) v11(73.48,69.49) v11(73.51,66.93) v11(73.52,66.52) v11(73.58,68.98) v11(73.58,68.6) v11(73.57,68.19) v11(73.57,67.77) v11(73.56,67.34) v11(73.63,71.2) v11(73.7,62.25) v11(73.7,61.04) v11(73.76,13.37) v11(73.89,71.2) v11(73.9,66.52) v11(73.96,67.34) v11(73.94,66.92) v11(74.18,71.2) v11(74.33,62.25) v11(74.33,61.04) v11(74.45,71.2) v11(74.74,71.2) v11(75.07,71.2) v11(75.03,13.37) v11(75.34,71.2) v11(75.63,71.2) v11(76.3,13.37) v11(77.02,74.8) v11(77.33,75.02) v11(77.57,13.37) v11(77.7,75.04) v11(78.33,60.84) v11(78.84,13.37) v11(79.17,37.04) v11(80.11,13.37) v11(80.24,57.95) v11(80.75,63.8) v11(81.38,13.37) v11(81.76,26.49) v11(82.21,64.31) v11(82.49,54.4) v11(82.59,60.08) v11(82.65,13.37) v11(82.94,57.43) v11(83.92,13.37) v11(84.71,57.44) v11(85.19,13.37) v11(85.79,63.54) v11(86.15,53.75) v11(86.46,13.37) v11(86.89,63.97) v11(86.89,63.7) v11(87.15,63.97) v11(87.16,63.7) v11(87.41,63.97) v11(87.42,63.7) v11(87.73,13.37) v11(88.41,63.98) v11(88.42,63.71) v11(88.5,76.61) v11(88.5,75.34) v11(88.5,74.07) v11(88.5,72.8) v11(88.5,71.69) v11(88.68,63.97) v11(88.69,63.71) v11(88.94,63.97) v11(88.95,63.71) v11(89,13.37) v11(89.77,76.61) v11(89.77,75.34) v11(89.77,74.07) v11(89.77,72.8) v11(89.77,71.69) v11(89.82,54.4) v11(89.89,33.07) v11(89.95,63.98) v11(89.96,63.71) v11(90.07,14.85) v11(90.22,63.97) v11(90.22,19.03) v11(90.23,63.71) v11(90.27,13.37) v11(90.48,63.97) v11(90.49,63.71) v11(91.04,72.8) v11(91.04,71.69) v11(91.47,63.97) v11(91.47,63.7) v11(91.54,13.37) v11(91.73,63.97) v11(91.74,63.7) v11(91.99,63.97) v11(92,63.7) v11(92.31,72.8) v11(92.31,71.69) v11(92.41,33.07) v11(92.43,59.63) v11(92.81,13.37) v11(92.91,53.43) v11(93,63.96) v11(93,63.69) v11(93,59.03) v11(93.26,63.95) v11(93.27,63.69) v11(93.52,63.95) v11(93.58,72.8) v11(93.58,71.69) v11(93.53,63.69) v11(94.03,15.43) v11(94.08,13.37) v11(94.53,63.97) v11(94.54,63.7) v11(94.59,14.84) v11(94.79,63.96) v11(94.8,63.7) v11(94.85,72.8) v11(94.85,71.69) v11(94.96,30.04) v11(95.06,63.96) v11(95.06,63.7) v11(95.14,14.84) v11(95.35,13.37) v11(95.58,39.92) v11(96.12,76.6) v11(96.12,75.33) v11(96.12,74.06) v11(96.12,72.8) v11(96.12,71.69) v11(96.05,63.98) v11(96.06,63.71) v11(96.18,35.02) v11(96.18,33.17) v11(96.18,22.51) v11(96.32,63.97) v11(96.24,28.77) v11(96.33,63.71) v11(96.33,28.09) v11(96.49,37.04) v11(96.58,63.97) v11(96.59,63.7) v11(96.62,26.21) v11(96.62,13.37) v11(96.87,30.04) v11(96.87,28.72) v11(97.09,20.02) v11(97.14,57.95) v11(97.13,22.34) v11(97.29,76.6) v11(97.29,75.33) v11(97.29,74.06) v11(97.29,72.8) v11(97.29,71.69) v11(97.31,70.41) v11(97.48,59.45) v11(97.44,33.07) v11(97.81,39.92) v11(97.89,13.37) v11(97.95,61.32) v11(98.27,59.85) v11(98.27,58.69) v11(98.46,52.68) v11(98.51,18.5) v11(98.64,20.21) v11(99.11,19.07) v11(99.16,13.37) v11(99.38,51.38) v11(99.58,53.39) v11(99.54,30.04) v11(99.8,27.25) v11(100.18,30.02) v11(100.18,28.81) v11(100.29,21.35) v11(100.29,18.31) v11(100.29,16.78) v11(100.41,40.76) v11(100.43,27.2) v11(100.51,22.37) v11(100.43,13.37) v11(100.96,61.56) v11(101.07,27.2) v11(101.22,35.02) v11(101.45,30.02) v11(101.7,13.37) v11(102.02,55.05) v11(102.02,54.4) v11(102.08,30.02) v11(102.7,58.31) v11(102.77,9.18) v11(102.87,38.34) v11(103.01,49.16) v11(102.97,13.37) v11(103.66,49.16) v11(103.74,33.82) v11(103.74,33.17) v11(103.77,11.68) v11(104.24,13.37) v11(104.46,55.05) v11(104.46,54.4) v11(104.49,30.02) v11(104.48,14.81) v11(104.99,35.02) v11(105.32,30.02) v11(105.51,13.37) v11(106.02,27.5) v11(106.21,35.02) v11(106.25,33.82) v11(106.26,16.41) v11(106.44,49.43) v11(106.44,47.39) v11(106.58,59.61) v11(106.59,58.04) v11(106.53,30.02) v11(106.78,60.67) v11(106.77,51.38) v11(106.75,32.75) v11(106.78,13.37) v11(107.07,26.21) v11(107.07,25.95) v11(107.08,25.69) v11(107.07,25.01) v11(107.07,24.75) v11(107.07,24.49) v11(107.07,23.8) v11(107.07,23.54) v11(107.08,23.29) v11(107.32,24.75) v11(107.33,26.21) v11(107.33,25.95) v11(107.34,25.69) v11(107.33,25.01) v11(107.33,24.49) v11(107.33,23.8) v11(107.33,23.54) v11(107.33,23.29) v11(107.43,54.96) v11(107.74,50.37) v11(108.05,13.37) v11(108.19,36.53) v11(108.36,70.71) v11(108.37,28.75) v11(108.62,50.37) v11(108.62,42.8) v11(108.62,37.76) v11(108.58,32.75) v11(108.64,70.71) v11(108.98,62.37) v11(109.06,54.75) v11(109.06,34.03) v11(109.04,29.74) v11(109.03,29.48) v11(109.04,29.23) v11(109.05,28.51) v11(109.05,28.25) v11(109.06,27.99) v11(109.27,50.37) v11(109.27,47.84) v11(109.23,32.75) v11(109.29,29.75) v11(109.29,29.49) v11(109.3,29.23) v11(109.31,28.51) v11(109.31,28.25) v11(109.32,28) v11(109.29,18.65) v11(109.29,17.38) v11(109.29,16.11) v11(109.29,14.84) v11(109.29,13.42) v11(109.27,9.18) v11(109.37,49.11) v11(109.37,44.06) v11(109.37,39.02) v11(109.5,59.61) v11(109.69,54.92) v11(110.11,18.64) v11(110.17,74.49) v11(110.47,74.49) v11(110.78,74.49) v11(111.08,74.49) v11(111.25,74.13) v11(111.25,73.81) v11(111.39,74.49) v11(111.38,18.64) v11(111.69,74.49) v11(111.66,74.14) v11(111.65,73.82) v11(111.71,73.05) v11(111.7,72.67) v11(111.73,38.66) v11(111.73,37.45) v11(112,74.49) v11(112.01,72.67) v11(112.05,74.14) v11(112.05,73.82) v11(112.11,73.05) v11(112.3,74.49) v11(112.31,72.67) v11(112.28,47.52) v11(112.27,45.27) v11(112.27,44.59) v11(112.27,43.9) v11(112.27,43.21) v11(112.27,42.53) v11(112.27,41.84) v11(112.34,52.29) v11(112.37,37.45) v11(112.37,36.85) v11(112.45,74.14) v11(112.44,73.82) v11(112.51,73.05) v11(112.62,72.67) v11(112.65,18.64) v11(112.85,74.14) v11(112.84,73.82) v11(112.9,73.05) v11(113.35,74.14) v11(113.35,73.81) v11(113.44,41.2) v11(113.44,40.65) v11(113.65,52.29) v11(113.74,70.1) v11(113.74,53.43) v11(113.74,52.86) v11(113.92,18.64) v11(114,70.1) v11(114.27,70.1) v11(114.31,25.45) v11(114.39,54.62) v11(114.39,54.33) v11(114.4,54.04) v11(114.61,29.37) v11(114.61,29.11) v11(114.61,28.86) v11(114.61,27.9) v11(114.62,27.64) v11(115.01,70.1) v11(115.19,18.64) v11(115.27,70.1) v11(115.54,70.1) v11(116.18,27.21) v11(116.46,18.64) v11(116.68,49.25) v11(117.65,21.41) v11(117.65,19.92) v11(117.88,56.7) v11(117.99,56.34) v11(117.99,56.09) v11(118,53.65) v11(118,52.86) v11(118.16,56.7) v11(118.31,43.6) v11(119.02,57.23) v11(119.02,56.96) v11(119.01,27.64) v11(119.01,27.07) v11(119,18.64) v11(119.45,57.24) v11(119.46,56.98) v11(119.73,50.8) v11(120.28,29.77) v11(120.28,28.5) v11(120.28,27.23) v11(120.28,25.96) v11(120.28,24.69) v11(120.28,23.42) v11(120.28,22.15) v11(120.28,20.88) v11(120.28,19.61) v11(120.27,18.64) v11(121.31,29.79) v11(121.6,63.98) v11(121.89,63.98) v11(122.07,33.42) v11(122.17,63.98) v11(122.58,29.79) v11(122.66,34.59) v11(122.82,40.36) v11(122.83,63.99) v11(123.13,63.99) v11(123.2,52.65) v11(123.2,52.39) v11(123.4,63.99) v11(123.41,42.01) v11(123.46,52.65) v11(123.46,52.39) v11(123.71,52.65) v11(123.71,52.39) v11(123.74,68.73) v11(123.81,29.86) v11(123.91,69.27) v11(123.96,52.65) v11(123.96,52.39) v11(124,37.81) v11(124.1,68.74) v11(124.04,64) v11(124.33,64) v11(124.5,40.63) v11(124.62,68.74) v11(124.61,64) v11(124.81,69.27) v11(124.99,68.74) v11(125.12,29.79) v11(125.67,31.69) v11(126.39,29.79) v11(126.6,43.65) v11(127.66,29.79) v11(127.9,50.32) v11(127.86,42.49) v11(128.15,40.39) v11(128.93,29.79) v11(130.2,29.79) v11(130.72,40.09) v11(131.27,45.01) v11(131.35,26.74) v11(131.35,24.34) v11(131.35,19.54) v11(131.45,36.9) v11(131.47,29.79) v11(132.72,76.56) v11(132.72,75.29) v11(132.72,74.02) v11(132.72,72.75) v11(132.72,71.48) v11(132.72,70.21) v11(132.72,68.94) v11(132.72,67.67) v11(132.72,66.4) v11(132.72,65.13) v11(132.72,63.86) v11(132.72,62.59) v11(132.72,61.32) v11(132.72,60.05) v11(132.72,58.78) v11(132.72,57.51) v11(132.72,56.24) v11(132.72,54.97) v11(132.72,53.7) v11(132.72,52.43) v11(132.72,51.16) v11(132.72,49.89) v11(132.72,48.62) v11(132.72,47.35) v11(132.72,46.08) v11(132.72,44.81) v11(132.72,43.54) v11(132.72,42.27) v11(132.72,41) v11(132.72,39.73) v11(132.72,38.46) v11(132.72,37.19) v11(132.72,35.92) v11(132.72,34.65) v11(132.72,33.38) v11(132.72,32.11) v11(132.72,30.84) v11(132.74,29.79) v11(133.36,15.8) v11(133.75,24.04) v11(133.75,23.44) v11(134.2,15.79) v11(135.61,18.08) v11(135.96,13.64) v11(136.17,18.08) v11(138.52,18.92) v11(138.68,16.51) v11(139.9,13.64) v11(140.02,18.92) v11(148.67,19.64) v11(148.7,17.24) v11(184.51,16.22) v11(185.01,12.17) v11(185.33,18.09) v11(185.77,12.17) v11(188.89,19.87) v11(190.12,14.71) v11(190.63,20.1) v11(191.26,20.1) v11(192.21,19.2) v11(193.79,19.2) v11(194.52,19.2) v11(194.98,32.94) v11(194.98,27.34) v11(195.62,14.71) v11(196.08,19.2) v11(196.63,71.65) v11(197.27,73.44) v11(197.36,63.52) v11(197.68,73.97) v11(198.85,28.64) v11(199.11,70.03) v11(199.34,66.98) v11(199.74,70.03) v11(200.41,72.35) v11(200.38,70.03) v11(200.47,73.97) v11(200.85,73.34) v11(200.87,72.78) v11(200.89,32.7) v11(201.01,70.03) v11(201.4,42.13) v11(201.84,72.46) v11(202.03,39.65) v11(202.03,39.04) v11(202.03,38.4) v11(202.03,37.79) v11(202.21,39.34) v11(202.21,38.1) v11(202.39,39.65) v11(202.36,39.04) v11(202.39,38.4) v11(202.36,37.79) v11(202.51,33.04) v11(202.61,32.02) v11(203.64,72.46) v11(204.32,47.01) v11(204.32,46.63) v11(204.32,46.25) v11(204.32,45.87) v11(204.32,45.48) v11(204.32,45.1) v11(204.32,44.72) v11(204.32,44.34) v11(204.78,73.46) v11(205.17,74.07) v11(206.35,47.01) v11(206.35,46.63) v11(206.35,46.25) v11(206.6,70.38) v11(207.91,72.35) v11(207.96,73.97) v11(208.34,73.34) v11(208.37,72.79) v11(210.2,32.3) v11(210.2,30.8) v11(211.02,71.1) v11(211.98,72.1) v11(212.94,71.1) v11(215.3,68.47) v11(216.57,68.47) v11(217.84,68.47) v11(219.11,68.47) v11(220.38,68.47) v11(239.31,71.9) v11(240.58,71.9) v11(241.85,71.9) v11(243.12,71.9) v11(244.39,71.9) v11(245.66,71.9) v11(246.93,71.9) v11(248.2,71.9) v11(249.47,71.9) v11(250.74,71.9) v11(252.01,71.9) v11(253.28,71.9) v11(253.31,43.2) v11(253.31,41.42) v11(253.31,39.64) v11(253.31,37.87) v11(253.31,36.09) v11(253.31,34.31) v11(254.55,71.9) v11(255.09,43.2) v11(255.09,41.42) v11(255.09,37.87) v11(255.09,36.09) v11(255.09,34.31) v11(255.82,71.9) v11(256.86,43.2) v11(256.86,41.42) v11(256.86,39.64) v11(256.86,37.87) v11(256.86,36.09) v11(256.86,34.31) v11(257.09,71.9) v11(258.36,71.9) v11(258.64,43.2) v11(258.64,41.42) v11(258.64,39.64) v11(258.64,37.87) v11(258.64,36.09) v11(258.64,34.31) v11(259.63,71.9) v11(260.42,43.2) v11(260.42,41.42) v11(260.42,39.64) v11(260.42,37.87) v11(260.42,36.09) v11(260.42,34.31) v11(260.9,71.9) v11(262.17,71.9) v11(262.2,43.2) v11(262.2,41.42) v11(262.2,39.64) v11(262.2,37.87) v11(262.2,36.09) v11(263.04,71.91) v11(263.83,72.94) v11(263.98,43.2) v11(263.98,41.42) v11(263.98,39.64) v11(263.98,37.87) v11(263.98,36.09) v11(264.15,24.06) v11(265.65,24.06) v11(265.75,43.2) v11(265.75,41.42) v11(265.75,39.64) v11(265.75,37.87) v11(265.75,36.09) v11(265.75,34.31) v11(266.55,18.84) v11(267.15,24.06) v11(267.53,43.2) v11(267.53,41.42) v11(267.53,39.64) v11(267.53,37.87) v11(267.53,36.09) v11(267.53,34.31) v11(270.14,72.78) v11(271.06,71.9) v11(272.33,71.9) v11(273.6,71.9) v11(273.55,18.84) v11(274.87,71.9) v11(275.06,18.84) v11(275.15,24.06) v11(275.55,18.84) v11(275.65,24.06) v11(276.16,75.75) v11(276.14,71.9) v11(277.19,74.73) v11(277.41,71.9) v11(278.15,74.72) v11(278.68,71.9) v11(279.18,76.69) v11(279.16,75.63) v11(279.95,71.9) v11(280.12,75.62) v11(280.15,76.68) v11(281.22,71.9) v11(281.23,74.69) v11(282.49,71.9) v11(283.26,76.79) v11(283.25,75.82) v11(283.76,71.9) v11(286.63,71.45) v11(290.68,40.56) v11(290.68,40.28) v11(290.85,34.05) v11(291.02,31.64) v11(291.2,74.82) v11(291.2,74.49) v11(291.69,15.23) v11(292.05,15.24) v11(292.4,15.23) v11(293.22,45.74) v11(293.15,32.15) v11(294.49,45.74) v11(297.37,16.51) v11(298.25,15.25) v11(298.26,14.92) v11(298.27,14.55) v11(299.97,60.63) v11(300.93,59.57) v11(301.89,57.99) v11(301.89,56.47) v11(301.89,54.95) v11(301.89,53.42) v11(301.89,51.9) v11(301.89,50.37) v11(301.89,48.85) v11(301.89,44.07) v11(302.65,59.18) v11(303.41,44.07) v11(303.9,64.74) v11(303.91,64.18) v11(304.18,59.18) v11(304.94,44.07)
