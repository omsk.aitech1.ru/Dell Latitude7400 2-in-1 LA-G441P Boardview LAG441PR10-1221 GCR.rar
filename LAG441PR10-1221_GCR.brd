# Allegro board LAG441PR10-1221_GCR.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VBUS1_ECOK: length 394.8
  TOP w0.127: PR1509.1 23.3,64.17 v2(23.3,64.99) ; PR154.2 16.88,45.46 16.69,45.65 v2(16.39,45.65) ; PR134.1 41.15,62.81 40.77,63.19 v2(39.66,63.19)
  IN1 w0.061: v4(31.45,37.99) 30.88,38.56 29.91,38.56 29.18,39.29 27.51,39.29 27.01,39.79 25.39,39.79 24.99,39.4 24.12,39.4 23.56,39.95 19.23,39.95 18.53,40.65 15.5,40.65 15.19,40.96 15.19,42.92 16.38,44.11 16.38,45.63 v2(16.39,45.65) ; v4(39.36,63.98) 39.36,63.49 v2(39.66,63.19) ; v4(22.76,65.14) 22.83,65.22 23.07,65.22 v2(23.3,64.99) ; v4(264.24,51.99) v2(264.24,51.61)
  IN2 w0.061: v4(39.36,63.98) 39.36,63.66 38.7,63.01 38.36,63.01 37.23,61.88 37.23,54.82 36.39,53.98 36.39,53.39 36.12,53.11 36.12,49.02 35.85,48.76 35.85,46.27 35.41,45.83 35.41,45.25 33.13,42.98 33.13,41.15 31.12,39.15 31.12,38.32 v4(31.45,37.99) 31.45,37.27 29.05,34.87 29.05,29.66 28.76,29.37 28.76,24.31 34.59,18.47 37.62,18.47 37.9,18.75 39.3,18.75 40.57,17.48 46.42,17.48 49.48,14.43 52,14.43 52.5,14.92 53.11,14.92 53.27,15.08 57.29,15.08 58.37,14 74.77,14 75.47,14.69 80.01,14.69 80.64,14.06 89.03,14.06 89.57,14.59 97.23,14.59 97.37,14.45 99.98,14.45 101.15,15.63 103.05,15.63 104.33,14.35 109.07,14.35 113.64,18.92 122.66,18.92 123.14,19.39 126.92,19.39 128.71,18.66 132,18.66 133.65,17.01 144.25,17.01 146.96,14.3 152.76,14.3 153.02,14.04 178.82,14.04 182.49,17.71 200.58,17.71 202.06,19.18 211.54,19.18 214.9,22.55 219.76,22.55 237.93,40.72 250.83,40.72 253.85,43.74 257.09,43.74 257.36,43.47 263.2,43.47 263.77,44.05 265.65,44.05 267.49,45.89 267.49,48.03 268.39,48.93 268.39,51.3 268.9,51.81 268.9,52.56 268.51,52.94 264.86,52.94 264.24,52.32 v4(264.24,51.99) ; v4(21.35,72.68) 21.35,73.35 22.08,74.08 22.08,76.06 22.26,76.24 22.26,77.08 22.58,77.4 22.78,77.4 24.02,78.63 35.49,78.63 35.91,78.22 37.88,78.22 38.25,77.84 v4(38.25,77.35)
  IN3 w0.061: v4(21.35,72.68) 21.86,72.68 22.57,71.97 22.57,66.78 22.18,66.39 22.18,65.65 22.68,65.14 v4(22.76,65.14) ; v4(39.36,63.98) 39.36,63.98 39.36,66.34 39.02,66.68 39.02,72.47 38.73,72.75 38.73,76.87 v4(38.25,77.35)
VBUS2_ECOK: length 363.6
  TOP w0.127: UE1.M6 266.64,52.09 266.68,52.05 v2(266.68,52.02) ; v2(25.95,56.79) 26.12,56.79 26.69,56.22 PR1507.1 ; v2(24.84,62.73) 24.89,62.78 v2(26.77,62.78) 27.06,62.78 27.68,63.4 30.46,63.4 30.67,63.62 31.08,63.62 31.39,63.93 32.26,63.93 32.6,63.59 32.6,62.76 32.79,62.57 PR135.1
  IN1 w0.061: v2(24.84,62.73) 24.84,62.85 24.58,63.11 24.02,63.11 23.62,62.71 23.62,62.39 23.42,62.19 23.01,62.19 22.79,62.4 22.16,62.4 21.71,62.85 21.44,62.85 21.14,63.15 18.75,63.15 18.48,62.88 16.39,62.88 16.18,62.67 15.74,62.67 15.44,62.37 v2(15.44,61.28) 15.44,59.61 15.08,59.25 15.08,58.39 15.68,57.79 15.68,49.56 13.78,47.66 13.78,45.05 12.53,43.79 12.53,39.83 13.8,38.56 13.8,37.33 14.72,36.41 14.72,36.04 15.24,35.52 15.24,25.61 17.52,23.32 19.81,23.32 21.82,21.32 v4(25.44,21.32) ; v2(266.68,52.02) 267.87,53.22 v4(267.87,53.93) ; v2(26.77,62.78) 26.77,62.72 25.48,61.42 25.14,61.42 24.89,61.17 24.89,60.58 25.21,60.27 25.51,60.27 25.8,59.98 25.8,56.94 25.95,56.8 v2(25.95,56.79)
  IN2 w0.061: v4(267.87,53.93) 268.65,53.93 270.33,52.25 270.33,48.7 268.85,47.21 268.85,46.08 268.5,45.74 267.91,45.74 265.72,43.54 264.01,43.54 263.44,42.96 257.15,42.96 256.87,43.24 254.06,43.24 251.04,40.21 238.14,40.21 217.64,19.71 212.6,19.71 211.7,18.8 202.39,18.8 200.79,17.2 182.52,17.2 178.98,13.66 152.87,13.66 152.6,13.92 134.03,13.92 133.86,14.1 133.86,16.27 131.84,18.28 128.63,18.28 126.85,19.01 123.3,19.01 122.82,18.54 113.8,18.54 109.23,13.97 104.1,13.97 103.8,14.28 100.91,14.28 100.71,14.07 97.02,14.07 96.56,13.62 58.21,13.62 57.13,14.7 53.43,14.7 53.27,14.54 52.66,14.54 52.16,14.05 49.32,14.05 46.26,17.1 40.41,17.1 39.14,18.37 38.06,18.37 37.07,17.38 29.61,17.38 25.67,21.32 v4(25.44,21.32)
VBUSSENSE: length 2.4
  TOP w0.127: v2(103.64,52.03) 103.64,51.87 103.34,51.57 v1(102.27,51.57)
  IN1 w0.254: v2(103.64,52.03) v4(103.31,52.26)
  IN3 w0.254: v4(103.31,52.26) v5(103.08,52.03)
VCC0V9_LVR_OUT: length 2.7
  IN1 w0.203: v4(21.4,53.16) v5(21.63,52.92) ; v4(22.05,52.69) v2(22.26,52.42)
  IN1 w0.229: v4(21.4,49.91) v2(21.17,49.67) ; v4(20.75,49.91) v2(20.52,49.67)
  IN3 w0.229: v5(22.28,52.92) v4(22.05,52.69) ; v5(21.63,49.67) v4(21.4,49.91) ; v5(21.63,52.92) v4(21.4,53.16) ; v5(20.98,49.67) v4(20.75,49.91)
VCC0V9_SVR: length 8.1
  TOP w0.127: 16.76,58.88 v3(16.76,57.88)
  TOP w0.254: CT75.1 20.56,50.39 20.98,50.82 v5(20.98,50.97)
  IN1 w0.229: v4(20.75,51.21) v5(20.98,50.97) ; v4(22.05,53.81) v5(22.28,53.57) ; v4(23.35,53.81) v5(23.58,53.57) ; v4(20.75,52.51) v5(20.98,52.27) ; v4(20.1,51.86) v5(20.33,51.62) ; v4(20.1,52.51) v5(20.33,52.27) ; v4(22.7,53.81) v5(22.93,53.57) ; v4(20.75,53.16) v5(20.98,52.92)
  IN3 w0.254: v5(20.98,52.92) v4(20.75,53.16) ; v5(22.28,53.57) v4(22.05,53.81) ; v5(20.98,50.97) v4(20.75,51.21) ; v5(20.33,52.27) v4(20.1,52.51) ; v5(20.33,51.62) v4(20.1,51.86) ; v5(20.98,52.27) v4(20.75,52.51) ; v5(20.98,51.62) v4(20.75,51.86) ; v5(23.58,53.57) v4(23.35,53.81) ; v5(22.93,53.57) v4(22.7,53.81)
  vias: v2(17,60.88) v2(17,60.55) v2(17,59.68) v2(17,59.38) v2(17.03,62.05) v2(17.03,61.74) v4(17.36,61.87) v4(17.36,60.72) v4(17.36,59.58) v5(16.8,62.06) v5(16.8,60.92) v5(16.82,59.75) v5(17.06,62.05) v5(17.06,60.92) v5(17.07,59.75)
VCC3V3_ANA_PCIE: length 0.7
  IN1 w0.076: v4(22.7,50.09) v5(22.93,50.32)
  IN3 w0.076: v5(22.93,50.32) v4(22.7,50.09)
VCC3V3_ANA_USB2: length 0.7
  IN1 w0.076: v4(22.05,50.09) v2(21.82,50.32)
  IN3 w0.076: v5(22.28,50.32) v4(22.05,50.09)
VCC_1.2V_DDR: length 1.6
  BOTTOM w0.254: PC607.1 46.67,23.74 47.3,24.37 PU600.14
VCC_1.8VPRIM: length 5.9
  IN3 w0.254: v5(113.05,22.08) 113.05,22.09 113.73,22.77 113.73,25.45 v5(113.72,25.45)
  BOTTOM w0.254: PU500.8 113.71,25.44 v5(113.72,25.45) ; PR503.2 v5(113.05,22.08)
VCC_CORE1: length 2.8
  IN1 w0.254: v4(75.86,75.33) 76.11,75.33 v2(76.49,75.71)
  IN3 w0.254: v4(75.86,75.33) 75.86,75.81 v5(75.78,75.89)
  BOTTOM w0.203: PU1000.14 75.34,75.55 PC1005.1
VCC_CORE2: length 2.4
  BOTTOM w0.203: PC1020.1 109.8,69.72 110.41,70.32 PU1001.14
  BOTTOM w0.254: PC1020.1 PR1009.2
VCC_GT: length 2.5
  BOTTOM w0.203: PC1105.1 43.79,51.51 PU1100.14
  BOTTOM w0.254: PR1100.2 PC1105.1
VCC_PRIM_CORE: length 2.6
  BOTTOM w0.254: PR1423.1 124.49,50.37 PC1419.1 125.3,49.67 125.85,49.12 PU1401.10
VCC_SA: length 2.4
  IN1 w0.254: v4(130.61,66.07) 130.79,66.26 v2(130.79,66.62)
  IN3 w0.254: v5(131.12,66.03) 130.64,66.03 v4(130.61,66.07)
  BOTTOM w0.254: PU1101.12 131.09,66.06 v5(131.12,66.03)
VCC_SENSE: length 54.5
  TOP w0.203: RC150.2 RC430.2 84.07,52.03 v2(84.12,51.97)
  IN1 w0.203: v2(84.12,51.97) 84.24,52.09 84.24,53.46 84.33,53.55 84.33,55.12 83.73,55.71 83.73,56.07 v4(83.82,56.16)
  IN3 w0.203: v5(79.65,64.6) 79.65,64.57 80.08,64.13 80.08,63.98 84.96,59.1 84.96,57.8 83.7,56.55 83.7,56.28 v4(83.82,56.16) ; v5(64.5,60.52) 64.3,60.52 64.25,60.47 63.04,60.47 62.65,60.07 55.43,60.07 55.03,60.47 54.13,60.47 52.9,61.69 52.17,61.69 51.05,62.81 46.63,62.81 45.99,62.17 v5(45.99,61.92)
  BOTTOM w0.203: v5(64.5,60.52) 64.55,60.47 65.66,60.47 65.99,60.8 65.99,61.48 66.59,62.08 66.59,62.68 67.32,63.42 76.75,63.42 78.1,64.76 79.41,64.76 79.49,64.76 v5(79.65,64.6)
VCC_SENSE_R: length 0.8
  IN1 w0.254: v4(84.91,52.29) 84.91,52.19 v2(84.71,51.99)
  IN3 w0.203: v4(84.91,52.29) 84.91,52.29 84.63,52.04 v5(84.62,52.04)
VCC_VCCIO: length 3
  BOTTOM w0.254: PR1403.1 107.71,20.69 PC1409.1 105.87,19.52 PU1400.10
VCCDSW_EN: length 177.6
  IN1 w0.061: v4(136.35,18.54) 136.35,19.1 133.65,21.8 133.27,21.8 132.11,22.95 132.11,23.84 130.67,25.28 129.63,25.28 128.98,25.94 128.98,26.97 v4(129.32,27.31) ; v2(267.44,52.41) 267.17,52.14 v4(267.17,52.04)
  IN2 w0.061: v4(136.35,18.54) 136.78,18.54 137.29,19.04 142.97,19.04 147.2,14.81 152.97,14.81 153.23,14.54 178.55,14.54 183.7,19.69 211.33,19.69 214.69,23.06 219.55,23.06 237.72,41.23 250.62,41.23 253.64,44.25 255.73,44.25 256.38,44.9 260.13,44.9 260.53,44.51 263.51,44.51 263.56,44.56 265.44,44.56 266.98,46.1 266.98,48.24 267.87,49.14 267.87,51.34 v4(267.17,52.04) ; v4(129.32,27.31) 129.19,27.18 128.22,27.18 128.07,27.34 128.07,27.97 128.41,28.31 128.41,33.47 v4(128.03,33.85)
  IN3 w0.061: v5(128.55,33.61) 128.43,33.72 128.15,33.72 v4(128.03,33.85)
  BOTTOM w0.127: RC631.1 129.11,32.81 128.55,33.36 v5(128.55,33.61)
VCCDSW_EN_GPIO: length 30.3
  IN2 w0.061: v4(115.2,46.79) 115.2,46.44 118.49,43.15 119.4,43.15 120.51,42.04 121.5,42.04 128.39,35.15 v4(128.39,34.84)
  IN3 w0.061: v4(115.2,46.79) 115.28,46.72 v5(115.28,46.45) ; v5(128.62,34.6) v4(128.39,34.84)
  BOTTOM w0.127: v5(128.62,34.6) 128.84,34.38 128.84,33.43 129.17,33.1 129.82,33.1 130.3,32.62 DC1.2 130.3,31.65 RC631.2 ; v5(115.28,46.45) 115.61,46.78 115.61,49.66 116.5,50.55 QC2.2 116.68,50.55 RC540.2
VCCDSW_EN_Q: length 14.5
  BOTTOM w0.127: DC2.2 118.59,28.89 118.21,29.27 RC630.1 117.56,30.27 118.24,30.94 125.02,30.94 125.22,30.74 126.16,30.74 126.53,31.11 127.75,31.11 DC1.1
VCCGT_SENSE: length 46.2
  IN2 w0.254: v6(63.53,49.66) 64.02,50.15 64.02,51.93 58.66,57.29 53.51,57.29 52.17,58.63 52.17,59.87 v4(52.27,59.97)
  IN3 w0.254: v4(52.27,59.97) 52.22,60.02 52.22,60.38 v5(52.13,60.47) 52.03,60.57 52.03,60.6 51.81,60.83 51.13,60.83 51.03,60.73 50.09,60.73 49.33,61.49 48.53,61.49 v5(48.43,61.38)
  BOTTOM w0.203: v5(48.43,61.38) 48.33,61.28 47.71,61.28 47.59,61.41 PU900.12
  BOTTOM w0.254: v5(52.13,60.47) 52.08,60.42 52.08,58.19 52.59,57.69 52.63,57.69 53.05,57.27 57.12,57.27 58.43,55.96 v1(61.33,55.96) 62.61,55.96 63.17,56.52 63.17,58.78 63.92,59.53 66.5,59.53 66.75,59.28 RC432.2 ; v6(63.53,49.66) 63.38,49.52 RC160.2
VCCGT_SENSE_R: length 5.6
  BOTTOM w0.102: UCPU1.E3 67.29,54.28 67.73,54.72 67.99,54.72 68.15,54.88 68.15,55.4 68.06,55.49
  BOTTOM w0.254: RC432.1 66.67,58.43 66.67,57.22 68.06,55.83 68.06,55.49
VCCIO_SENSE: length 36
  TOP w0.102: v2(93.61,38.7) 93.61,38.7 93.93,38.39 v1(94.11,38.39)
  TOP w0.203: RC163.2 92.98,39.48 93.61,38.84 v2(93.61,38.7)
  IN1 w0.203: v2(93.61,38.7) 93.59,38.7 93.59,38.68 94.08,38.19 96.18,38.19 96.74,37.64 97.34,37.64 97.63,37.93 v4(97.63,38.11)
  IN2 w0.203: v4(108.19,19.47) 108.08,19.58 108.08,19.98 108.37,20.28 108.37,21.89 107.69,22.57 107.69,23.89 106.02,25.56 102.22,25.56 99.92,27.86 99.54,27.86 99.32,28.08 99.32,28.83 98.92,29.23 98.02,29.23 97.02,30.23 97.02,36.21 97.4,36.59 97.4,37.88 v4(97.63,38.11)
  IN3 w0.203: v4(108.19,19.47) 108.31,19.35 108.31,17.88 v5(108,17.57)
  IN3 w0.254: v5(97.4,38.34) v4(97.63,38.11)
VCCPLL_EN: length 1.3
  BOTTOM w0.127: RZ2.2 100.37,15.41 UZ5.4
VCCSA_SENSE: length 51
  TOP w0.102: RC166.2 94.37,52.23 v1(94.55,52.41)
  TOP w0.203: v2(93.05,52.23) RC166.2
  IN1 w0.203: v4(86.26,54.63) 86.46,54.43 86.84,54.43 87.05,54.63 88.2,54.63 88.41,54.42 90.59,54.42 92.21,52.8 92.48,52.8 v2(93.05,52.23) ; v4(51.52,58.01) 51.38,58.01 49.86,59.53 49.36,59.53 49.34,59.55 49.3,59.55 v4(49.22,59.63)
  IN3 w0.203: v4(51.52,58.01) 51.62,57.91 54.61,57.91 54.94,58.24 58.4,58.24 60.68,55.95 62.59,55.95 63.72,57.07 70.84,57.07 71.12,57.35 76.34,57.35 76.47,57.3 76.52,57.25 80.09,57.25 82.53,54.8 86.09,54.8 v4(86.26,54.63) ; v5(48.44,59.69) 48.49,59.63 48.73,59.63 48.83,59.53 49.12,59.53 v4(49.22,59.63)
VCCSA_SENSE_CPU: length 1.8
  TOP w0.127: v1(93.51,50.84) 93.05,51.3 RC426.1 93.01,51.69 v2(93.01,51.7)
  IN1 w0.254: v2(93.01,51.7) 93.08,51.7 v4(93.29,51.49)
  IN3 w0.254: v5(92.92,51.38) 93.02,51.49 v4(93.29,51.49)
VCCST_EN: length 3.7
  BOTTOM w0.127: UZ3.4 101.14,64.08 R248.2 R247.2 102.55,64.67 R280.2 102.56,64.71 v1(103.53,65.68)
VCCST_PWRGD: length 43.6
  TOP w0.127: RC371.1 62.62,66.43 63.23,67.04 U7.4 63.79,67.5 63.32,67.96 v2(62.83,67.96)
  IN1 w0.061: v2(62.83,67.96) 62.64,68.15 v4(62.64,68.26)
  IN3 w0.061: v4(62.64,68.26) 62.78,68.4 62.78,68.68 64.62,70.52 68.06,70.52 73.38,65.2 75.53,65.2 81.07,59.66 v5(81.07,59.15)
  BOTTOM w0.127: v5(81.07,59.15) 81.12,59.1 83.06,59.1 v1(84.33,60.37) 84.62,60.66 93.61,60.66 93.74,60.53 RC79.2 93.59,60.05 CC200.1 93.6,59.02 RC86.1
VCCST_PWRGD_CPU: length 3.8
  BOTTOM w0.076: RC86.2 93.6,57.7 92.98,57.08 92.98,56.2 93.51,55.67 93.51,55.26 UCPU1.BJ2
VCCSTG_EN: length 136.7
  TOP w0.127: v2(120.09,63.57) 119.98,63.68 v1(119.72,63.68) ; v2(131.16,35.43) 131.16,34.99 129.44,33.27 127.52,33.27 126.16,34.63 126.16,35.29 125.79,35.65 125.17,35.65 124.36,34.84 124.36,34.36 123.25,33.25 122.42,33.25 121.42,32.25 118.13,32.25 116.37,30.49 116.37,23.54 117.19,22.72 117.19,19.65 118.13,18.71 118.13,17.01 v2(118.04,16.92)
  IN1 w0.061: v4(120.43,63.17) 120.09,63.51 v2(120.09,63.57) ; v4(101.4,15.3) 101.99,15.89 104.23,15.89 106.12,14 111.06,14 111.66,13.4 111.96,13.4 112.47,13.91 112.47,14.93 114.91,17.38 117.59,17.38 v2(118.04,16.92) ; v2(131.16,35.43) v4(131.16,35.87)
  IN2 w0.061: v4(131.16,35.87) 131.16,36.96 130.15,37.98 129.86,37.98 128.9,38.93 128.9,40.03 127.36,41.58 125.8,41.58 123.37,44.01 121.28,44.01 120.32,44.97 120.32,47.95 119.45,48.81 118.74,48.81 118.2,49.34 118.2,50.19 117.82,50.57 117.82,61.63 119.34,63.15 120.42,63.15 v4(120.43,63.17)
  IN3 w0.061: v5(101.04,15.32) 101.38,15.32 v4(101.4,15.3) ; v5(87.91,63.35) 87.46,62.91 84.87,62.91 v5(84.44,63.34) ; v5(120.05,64.08) 120.39,63.74 120.39,63.21 v4(120.43,63.17)
  BOTTOM w0.127: UZ4.4 82.59,63.16 82.21,63.54 R240.1 82.77,63.73 82.97,63.54 U5.4 84.25,63.54 v5(84.44,63.34) ; v5(120.05,64.08) 119.87,64.27 119.2,64.27 117.57,65.9 111.77,65.9 111.31,66.35 103.36,66.35 102.63,65.61 101.6,65.61 101.36,65.37 98.08,65.37 97.27,64.56 97.27,63.72 96.85,63.3 87.96,63.3 v5(87.91,63.35)
VDD: length 29.4
  TOP w0.102: v6(34.54,21.83) 34.54,22.03 34.35,22.22 v1(34.35,22.65)
  TOP w0.203: v2(24.56,19.58) 24.79,19.35 25.36,19.35 26,18.71 PU200.18
  TOP w0.508: PR219.1 21.84,15.36 21.84,17.92 22.75,18.83 v2(23.54,18.83) ; v6(34.54,21.83) 35.04,21.34 PR207.2
  IN1 w0.508: v4(23.01,19.04) 23.23,18.83 v2(23.54,18.83) 24.29,19.58 v2(24.56,19.58)
  IN3 w0.508: v6(34.54,21.83) 35.04,21.34 35.04,18.47 32.32,15.75 26.3,15.75 v4(23.01,19.04)
VDD18_CORE: length 1.9
  BOTTOM w0.127: v1(45.35,52.75) 45.76,53.16 PR901.2
  BOTTOM w0.203: PR901.2 PR931.1
VIN_PRIM_CORE: length 0.9
  TOP w0.127: v6(131.3,48.19) v3(130.42,48.19)
VSS_SENSE: length 52
  TOP w0.254: v2(83.96,53.7) RC151.1 84.52,53.23 RC429.2
  IN1 w0.203: v2(83.96,53.7) 83.96,55.02 83.4,55.58 83.4,56.04 v4(83.29,56.16)
  IN3 w0.203: v4(83.29,56.16) 83.37,56.24 83.37,56.68 84.63,57.94 84.63,58.97 79.75,63.84 79.75,64 79.41,64.33 v5(79.38,64.33) ; v5(46.39,61.93) 46.39,62.11 46.77,62.48 50.91,62.48 52.04,61.36 52.76,61.36 53.99,60.14 54.9,60.14 55.29,59.74 62.79,59.74 63.18,60.14 64.48,60.14 v5(64.5,60.11)
  BOTTOM w0.203: v5(64.5,60.11) 64.53,60.14 65.8,60.14 66.32,60.66 66.32,61.34 66.92,61.94 66.92,62.54 67.46,63.09 76.89,63.09 78.24,64.43 79.28,64.43 v5(79.38,64.33)
VSS_SENSE_R: length 0.8
  IN1 w0.254: v2(84.59,52.63) 84.88,52.92 v4(84.89,52.92)
  IN3 w0.076: v4(84.89,52.92) 84.84,52.92 84.6,52.68 v5(84.6,52.68)
VSSGT_SENSE: length 43.3
  IN2 w0.254: v6(63.53,50.36) 63.64,50.47 63.64,51.77 58.5,56.91 53.35,56.91 51.79,58.48 51.79,59.8 v4(51.67,59.92)
  IN3 w0.254: v4(51.67,59.92) 51.76,60.01 51.76,60.33 v5(51.65,60.45) 51.29,60.45 51.19,60.35 49.93,60.35 49.17,61.11 v5(49.06,61.11)
  BOTTOM w0.203: v5(49.06,61.11) 49.03,61.11 48.82,60.89 PU900.13
  BOTTOM w0.254: RC161.1 63.34,50.17 v6(63.53,50.36) ; RC431.2 66.11,59.15 64.08,59.15 63.55,58.62 63.55,56.36 62.76,55.58 61.6,55.58 61.58,55.55 61.09,55.55 61.06,55.58 58.27,55.58 56.96,56.89 52.85,56.89 v1(52.46,57.28) 51.7,58.03 51.7,60.39 v5(51.65,60.45)
VSSGT_SENSE_R: length 5.3
  BOTTOM w0.102: 67.68,55.47 67.68,55.31 67.44,55.07 67.44,54.79 67.16,54.51 66.98,54.51 UCPU1.D2
  BOTTOM w0.152: 67.68,55.49 67.68,55.47
  BOTTOM w0.254: 67.68,55.49 67.68,55.67 66.29,57.06 66.29,58.39 RC431.1
VSSIO_SENSE: length 33
  TOP w0.203: v2(93.23,38.68) v1(92.95,38.95) 92.39,39.51 RC165.1
  IN1 w0.203: v4(96.94,36.92) 96.94,36.97 96.04,37.86 93.94,37.86 93.25,38.55 93.25,38.65 v2(93.23,38.68)
  IN2 w0.203: v4(96.94,36.92) 96.96,36.9 96.96,36.62 96.69,36.34 96.69,30.06 97.85,28.9 98.78,28.9 98.99,28.69 98.99,27.95 99.4,27.53 99.78,27.53 102.08,25.23 105.88,25.23 107.36,23.75 107.36,22.44 108.04,21.75 108.04,20.42 107.75,20.12 107.75,19.57 v4(107.63,19.46)
  IN3 w0.203: v4(107.63,19.46) 107.84,18.96 v5(107.89,18.94) ; v4(96.94,36.92) 97.4,37.39 v5(97.4,37.69)
VSSSA_SENSE: length 49.4
  TOP w0.203: v2(92.49,52.23) RC425.2
  IN1 w0.203: v4(85.81,54.28) 85.96,54.12 86.3,54.12 86.33,54.1 86.98,54.1 87.18,54.3 88.06,54.3 88.27,54.09 90.45,54.09 92.07,52.47 92.25,52.47 v2(92.49,52.23) ; v4(51.5,57.47) 51.39,57.57 51.34,57.57 49.72,59.19 49.36,59.19 v4(49.24,59.07)
  IN3 w0.203: v4(85.81,54.28) 85.61,54.47 82.4,54.47 79.95,56.92 76.38,56.92 76.28,57.02 71.26,57.02 70.98,56.74 63.85,56.74 62.73,55.62 60.54,55.62 58.26,57.91 55.07,57.91 54.74,57.57 51.61,57.57 v4(51.5,57.47) ; v4(49.24,59.07) 49.11,59.2 48.69,59.2 48.59,59.3 48.4,59.3 v5(48.39,59.29)
VSSSA_SENSE_CPU: length 1.6
  TOP w0.127: v2(91.93,51.64) 91.93,51.11 v1(92.23,50.82)
  IN1 w0.061: v4(92.28,51.6) 92.12,51.62 v2(91.93,51.64)
  IN3 w0.061: v4(92.28,51.6) v5(91.99,51.38)
2.7MM_CAM_DET#: length 39.4
  TOP w0.127: v3(115.05,28.01) 115.05,27.56 v2(115.23,27.39)
  IN1 w0.061: v2(115.23,27.39) 115.23,27.51 v4(115.05,27.69)
  IN2 w0.061: v4(101.47,35.97) 101.15,35.65 101.15,34.52 101.24,34.42 101.24,33.47 102.33,32.39 106.83,32.39 108.44,30.78 111.47,30.78 114.56,27.69 v4(115.05,27.69)
  IN3 w0.061: v5(123.12,25.11) 122.22,25.11 120.7,26.62 120.17,26.62 120.17,26.62 116.72,26.62 v5(115.56,27.78) 115.49,27.78 115.4,27.69 v4(115.05,27.69) ; v5(101.05,36.39) v4(101.47,35.97)
  BOTTOM w0.127: RC618.1 115.7,27.92 v5(115.56,27.78) ; JCAM1.13 130.81,23.74 129.45,25.11 v5(123.12,25.11)
3MM_CAM_DET#: length 46.6
  TOP w0.127: v3(110.43,48.03) 109.97,48.03 v2(109.75,48.26)
  IN1 w0.061: v4(109.53,48.68) 109.53,48.47 v2(109.75,48.26)
  IN2 w0.061: v4(109.53,48.68) 110.01,49.15 113.57,49.15 116.92,45.81 116.92,45.08 118.6,43.4 119.5,43.4 120.62,42.29 121.61,42.29 128.93,34.96 v4(128.93,27.64)
  IN3 w0.061: v4(128.93,27.64) 128.71,27.42 v5(128.71,27.2) ; v5(109.53,48.14) 109.53,48.67 v4(109.53,48.68)
  BOTTOM w0.127: v5(109.53,48.14) 109.53,48.29 UCPU1.CR12 110.16,48.46 111.34,49.64 RC619.2 ; JCAM1.16 134.15,24.64 134.26,24.76 134.26,26.35 133.41,27.2 v5(128.71,27.2)
32KHZ_OUT: length 4.7
  TOP w0.127: UE1.F3 263.77,57.67 263.77,58.15 263.51,58.41 260.59,58.41 CE21.1
+BATT:
  vias: v3(41.67,14.57) v3(43.76,15.74) v3(44.32,13.8) v4(37.88,14.47) v4(37.88,13.84) v4(38.31,14.76) v4(38.33,14.28) v4(38.34,13.76) v5(37.45,15.39) v5(37.44,14.79) v5(37.44,14.14) v5(37.72,15.39) v5(37.72,14.79) v5(37.74,14.15) v5(37.99,15.38) v5(37.98,14.79) v5(38.01,14.15) v6(38.85,14.66) v6(38.85,14.09) v6(38.86,13.51) v6(38.86,12.93) v6(39.41,14.55) v6(39.42,13.96) v6(39.42,13.38) v6(39.42,12.82) v6(41.76,15.38) v6(42.31,15.38) v6(42.47,14.64) v6(42.82,15.13) v6(43.11,14.64) v6(43.42,15.12) v6(43.71,14.63) v6(43.99,15.12) v6(44.28,14.64)
+CHG_SRC_20V: length 1
  TOP w0.102: 18.25,39.36 v1(19.21,39.36)
  vias: v2(18.08,40.25) v2(18.07,40) v2(18.08,39.74) v2(18.06,39.06) v2(18.07,38.8) v2(18.07,38.55) v2(20.81,37.01) v2(20.81,36.72) v4(21.11,36.87) v5(18.08,40.25) v5(18.07,40) v5(18.08,39.74) v5(18.06,39.11) v5(18.06,38.85) v5(18.06,38.6) v5(20.81,37.01) v5(20.81,36.72) v6(17.34,40.09) v6(17.35,38.88)
+CHG_VIN_20V: length 11.8
  TOP w0.102: v2(24.48,25.55) v3(25.55,25.55)
  TOP w0.127: 24.43,24.47 26.68,24.47 v3(27.09,24.88)
  TOP w0.254: PR101.1 14.72,63.68 PQ103.3
  TOP w0.508: PR105.1 PC111.1 11.5,63.36 14.17,63.36 PQ103.3
  IN1 w0.254: v2(13.69,62.63) v2(14.33,62.63)
  IN3 w0.508: v5(16.92,65.94) 16.92,65.09 v4(16.99,65.02)
  BOTTOM w0.508: DT49.2 15.93,64.95 v5(16.92,65.94)
  vias: v2(11.02,42.31) v2(11.02,42.06) v2(11.28,42.31) v2(11.28,42.06) v2(11.53,42.31) v2(11.53,42.06) v2(21.89,24.61) v2(21.89,24.25) v2(22.16,24.43) v2(22.43,24.61) v2(22.43,24.25) v2(23.09,25.55) v2(23.14,24.84) v2(23.79,25.21) v2(24.48,24.91) v3(11.23,41.43) v4(9.79,46.15) v4(9.78,45.24) v4(9.79,44.78) v4(9.79,44) v4(10.12,44.32) v4(10.12,43.67) v4(10.58,46.15) v4(10.58,44.78) v4(10.58,44) v4(10.58,43.21) v4(11.06,43.64) v4(11.16,44.38) v4(11.36,46.15) v4(11.36,44.78) v4(11.36,44) v4(11.36,43.21) v4(12.2,59.43) v4(12.29,58.96) v4(12.29,58.51) v4(12.29,58.11) v4(12.41,59.92) v4(12.66,59.47) v4(12.86,59.9) v4(12.83,57.65) v4(13.08,58.02) v4(13.08,57.32) v4(13.09,56.89) v4(13.14,59.47) v4(13.31,59.91) v4(13.32,59.05) v4(13.33,57.65) v4(23.64,25.86) v4(23.89,26.24) v4(24.13,25.86) v4(24.4,26.22) v4(24.68,25.88) v4(25.55,39.4) v4(25.68,38.98) v4(25.68,38.54) v4(26.14,38.98) v4(26.14,38.54) v4(26.59,38.98) v4(26.59,38.54) v4(26.82,39.43) v4(27.05,38.98) v4(27.05,38.54) v5(9.44,45.38) v5(9.44,45.08) v5(9.44,44.76) v5(9.45,44.38) v5(9.44,43.97) v5(9.46,43.59) v5(9.78,44.38) v5(9.78,43.58) v5(10.25,44.65) v5(10.25,44) v5(10.25,43.34) v5(10.91,44.65) v5(10.91,44) v5(10.91,43.34) v5(12.71,58.35) v5(12.8,58.95) v5(12.74,58.67) v5(12.75,57.98) v5(12.75,57.32) v5(12.84,56.66) v5(13.02,58.72) v5(13.09,58.45) v5(13.32,58.69) v5(13.41,58.45) v5(13.41,57.98) v5(13.41,57.32) v5(13.46,56.66) v5(25.86,39.98) v5(25.91,39.71) v5(25.9,39.44) v5(26.16,39.98) v5(26.17,39.71) v5(26.17,39.43) v5(26.49,39.96) v5(26.44,39.7) v5(26.44,39.42) v5(26.84,39.99)
+CPVDD: length 3.8
  TOP w0.203: RA13.1 284.38,17.76 CA25.1 284.71,18.76 CA24.1 284.71,19.28 284.1,19.89 UA1.20
+DMIC_DVDD: length 11.7
  BOTTOM w0.305: 134.86,21.1 134.32,21.64 JCAM1.6
  BOTTOM w0.508: 134.86,21.1 135.55,21.1 138.24,23.79 v3(140.04,23.79) 141.16,23.79 RV68.2 142.45,24.11 RV35.2 142.68,25.53 RV69.2
+EC_DEBUG_VCC: length 5.9
  TOP w0.102: RE90.2 241.24,68.79 v1(241.29,68.74)
  BOTTOM w0.305: JDEG1.1 237.13,71.64 239.02,69.75 v6(239.02,68.68)
+INV_PWR_SRC: length 1.9
  TOP w0.127: CV25.1 33.5,77.73 33.6,77.83 v3(34.78,77.83)
  vias: v2(33.95,77.29) v2(33.95,76.97) v2(33.95,76.68) v2(33.93,76.35) v2(49.29,67.84) v2(49.29,67.57) v2(49.55,67.83) v2(49.55,67.56) v3(49.1,66.64) v3(49.53,68.31) v4(33.3,77.15) v4(33.3,76.7) v4(49.25,67.21) v4(49.71,67.21) v5(32.57,76.79) v5(32.57,76.51) v5(32.87,76.79) v5(32.87,76.51)
+INV_PWR_SRC_D: length 5.3
  TOP w0.127: v1(50.86,61.16) 50.86,61.47 51.83,62.44 51.83,62.6 DV13.1 51.62,62.88 RV43.1 51.62,63.77 CV38.1 52.83,64.98 RV39.2
+INV_PWR_SRC_L:
  vias: v3(30.97,73.69)
+INV_PWR_SRC_Q: length 11.4
  TOP w0.127: RV93.2 34.53,73.51 35.96,72.08 v2(36.09,72.08) ; v2(32.6,68.43) 32.21,68.43 31.94,68.17 31.94,67.06 32.61,66.39 QV11.6
  IN1 w0.061: v2(32.6,68.43) 32.6,69.72 33.6,70.72 34.2,70.72 35.03,71.55 35.57,71.55 v2(36.09,72.08)
+IR_B+: length 4.2
  TOP w0.102: v6(127.72,26.31) 126.7,25.28 v3(126.46,25.28)
  TOP w0.508: RV75.2 129.23,27.82 v6(127.72,26.31)
+LCDVDD: length 46.4
  TOP w0.381: v2(58.69,63.73) 58.69,64.02 59.09,64.42 59.79,64.42 60.49,63.72 CV40.1
  TOP w0.508: CV40.1 60.49,61.89 DV14.2 60.4,60.66 60.84,60.22 v3(61.59,60.22) v3(63.55,60.22) v3(65.56,60.22) 68.68,60.22 69.47,61 RV40.1
  IN1 w0.305: v2(58.69,63.73) v4(58.2,63.89)
  IN2 w0.508: v6(36.56,77.08) 36.56,76.38 37.44,75.51 37.44,73.93 38.89,72.48 42.26,72.48 42.96,71.79 44.25,71.79 v4(44.92,72.46)
  VCC w0.508: v4(44.92,72.46) 46.6,72.46 47.34,73.21 48.08,73.21 50.62,70.67 51.12,70.67 56.16,65.63 57.64,65.63 58.2,65.07 v4(58.2,63.89)
+LCDVDD_D: length 3.5
  TOP w0.254: DV14.1 62.1,62.31 62.04,62.37 62.04,62.82 RV48.1 61.85,62.85 61.25,63.44 CV41.1 62.1,64.37 RV46.2
+LDO_BMC_PD_A: length 2.1
  TOP w0.127: v2(28.32,68.18) 28.36,68.22 CT96.1
  IN1 w0.061: v4(28.81,67.9) 28.49,67.9 28.32,68.08 v2(28.32,68.18)
  IN3 w0.061: v4(28.81,67.9) 28.8,67.92 v5(28.23,67.92)
  BOTTOM w0.127: v5(28.23,67.92) 28.23,67.91 28.23,67.91 UT1.E1
+LDO_BMC_PD_B: length 1.7
  IN1 w0.061: v4(28.87,75.74) 29.08,75.53 v2(29.08,75.46)
  IN3 w0.061: v5(28.53,75.72) 28.55,75.74 v4(28.87,75.74)
  BOTTOM w0.127: UT5.E1 28.25,74.93 28.56,75.24 28.56,75.69 v5(28.53,75.72)
+LED1: length 2.4
  BOTTOM w0.127: R102.2 201.01,61.79 201.18,61.96 v1(201.46,61.96)
  BOTTOM w0.508: LED1.2 200.19,61.79 R102.2
+LED_PRI: length 4.4
  BOTTOM w0.127: v1(118.24,50.42) 118.24,50.86 116.8,52.29 LED_PRI.2 116.04,53.68 R101.2
+LED_RST: length 2.5
  BOTTOM w0.127: v1(201.43,60.28) 200.86,60.85 R140.2
  BOTTOM w0.508: R140.2 200.08,60.85 LED_RST.2
+LED_RUN: length 3.2
  BOTTOM w0.127: LED_RUN.2 198.64,58.21 v1(198.64,57.38)
  BOTTOM w0.508: LED_RUN.2 200.11,58.29 R139.2
+PECI_VREF: length 5.5
  TOP w0.254: v2(270.89,54.55) UE1.J11
  IN1 w0.508: v2(275.59,55.01) 275.49,54.91 274.65,54.91 v2(274.36,55.2) 273.71,55.2 273.51,55 271.59,55 271.14,54.55 v2(270.89,54.55)
+RTC_CELL_VBAT: length 8.2
  TOP w0.127: v6(259.47,64.27) v1(258.81,64.27)
  TOP w0.254: v2(263.19,62.71) 263.19,61.45 UE1.A2
  TOP w0.356: CE1.1 260.43,63.79 RE103.2
  TOP w0.508: v6(259.47,64.27) 259.66,64.08 RE103.2
  IN1 w0.381: v2(263.19,62.71) v4(262.69,62.71)
  IN3 w0.508: v6(259.47,64.27) 261.03,62.71 v4(262.69,62.71)
+RTCBATT: length 11.1
  TOP w0.102: v6(308.71,9.31) v3(307.36,9.31)
  TOP w0.508: v6(308.71,9.31) 308.76,9.26 RB21.1
  BOTTOM w0.508: JRTC1.1 307.05,4.37 309.35,6.67 309.35,8.68 v6(308.71,9.31)
+RTCVCC: length 255.8
  TOP w0.254: CC72.1 CC73.1
  TOP w0.508: v6(209.36,12.46) 207.78,10.89 202.35,10.89 201.23,12.01 v3(196.39,12.01) 186.52,12.01 185.36,10.84 153.69,10.84 153.6,10.85 150.32,10.85 149.8,10.98 144.48,12.29 132.38,12.29 v2(131.66,11.56) ; QB5.1 310.3,6.18 v6(309.98,5.86) 310.23,5.61 CB15.1 310.23,3.64 RB22.1
  IN1 w0.254: v2(97.68,42.33) v4(98.02,41.9)
  IN1 w0.381: 96.61,28.43 96.65,28.39 v4(98.35,28.39) ; 96.61,28.43 96.61,26.71 97.6,25.72 100.27,25.72 100.42,25.57 100.43,25.57 100.76,25.25 ; 96.61,28.43 96.61,30.28 97.96,31.63 v4(97.96,32.08) 96.91,33.13 96.91,36.13 97.85,37.07 v4(97.85,37.28)
  IN1 w0.508: 100.76,25.25 101.58,24.43 106.07,24.43 106.93,23.58 106.93,22.3 108.02,21.21 113.08,21.21 113.86,21.99 118.23,21.99 118.84,21.38 119.34,21.38 120.98,19.74 122.15,19.74 124.72,17.17 128.29,17.17 131.66,13.81 v2(131.66,11.56)
  IN2 w0.076: 97.73,41.14 97.73,40.81
  IN2 w0.381: 98.16,40.4 98.16,37.59 v4(97.85,37.28)
  IN2 w0.508: v6(309.98,5.86) 309.85,5.73 306.87,5.73 303.21,9.39 300.47,10.89 258.49,10.89 256.16,13.23 244.68,13.23 242.39,10.94 225.75,10.94 224.36,12.34 209.48,12.34 v6(209.36,12.46)
  IN3 w0.254: v5(97.81,41.6) v4(98.02,41.9)
  IN3 w0.381: v4(97.96,32.08) 98.27,31.77 v5(98.27,30.04) ; v5(98.78,28.39) v4(98.35,28.39)
  BOTTOM w0.356: RC71.2 98.13,28.39 v5(98.78,28.39) 98.91,28.52 RC68.2
+RTCVCC_R: length 340.5
  TOP w0.381: 258.41,61.37 258.09,61.04 258.09,60.29 258.41,59.96 RE515.2 RE136.2 ; 258.41,61.37 258.48,61.44 259.35,61.44 259.59,61.68 RE149.1 ; 258.41,61.37 258.36,61.37 257.06,62.67 ; v2(265.47,65.27) 265.47,65.3 264.58,66.19 260.63,66.19 v6(260.04,65.6) ; RA10.2 293.53,17.26
  TOP w0.508: v6(125.49,35.16) 125.31,35.16 124.8,34.66 124.8,34.18 123.44,32.81 122.61,32.81 121.59,31.79 121.21,31.79 120.35,30.93 119.73,30.93 v3(119.1,30.3) 118.58,29.77 118.58,27.63 118.21,27.26 118.21,24.28 118.68,23.81 118.68,22.49 v2(118.66,22.46) ; v6(260.04,65.6) 260.13,65.51 RE103.1 258.3,64.99 257.06,63.75 257.06,62.67 ; DB3.1 308.42,5.45 CB16.1 RTCD3.1 ; 293.53,17.26 292.98,16.71 290.93,16.71 288.3,14.08 v6(288.3,13.02)
  IN1 w0.381: v2(265.47,64.06) v2(265.47,65.27)
  IN1 w0.508: v2(102.7,25.01) 106.3,25.01 107.49,23.81 107.49,22.54 108.26,21.78 112.84,21.78 113.65,22.59 118.53,22.59 v2(118.66,22.46) 119.17,21.95 119.65,21.95 121.23,20.37 122.38,20.37 125.02,17.74 128.53,17.74 132.23,14.04 132.23,12.83 134.2,10.85 145.13,10.85 145.73,10.7 146.47,10.36 146.83,10 v4(147.02,9.81)
  IN3 w0.508: v4(147.02,9.81) v5(147.47,9.81)
  BOTTOM w0.508: v6(125.49,35.16) 126,35.67 PR1511.2 126.41,35.67 127.06,36.32 127.96,36.32 129.43,34.84 PQ1506.3 ; v5(147.47,9.81) 147.76,10.09 183.12,10.09 184.02,10.99 219.42,10.99 220.76,10.69 221.4,10.3 221.7,10 252.13,10 254.06,11.93 258.48,11.93 260.66,14.1 ; 260.66,14.1 253.8,20.96 253.8,26.05 252.47,27.38 252.47,28.4 250.15,30.73 250.15,32.98 248.37,34.76 248.37,34.95 248.27,35.05 248.27,43.35 247.75,43.87 247.75,51.11 251.38,54.74 251.38,63.82 253.14,65.58 260.02,65.58 v6(260.04,65.6) ; 260.66,14.1 263.83,10.93 286.21,10.93 v6(288.3,13.02) 288.53,13.02 288.78,12.77 297.32,12.77 298.39,11.7 301.05,11.7 301.95,10.81 302.39,10.64 305.88,10.64 308.14,8.38 v6(308.14,6.75)
+SD_VDD1:
  vias: v1(299.34,32.57) v2(292.65,32.45) v2(292.81,32.66) v6(298.18,32.49) v6(298.78,32.49)
+SD_VDD2: length 1.6
  TOP w0.102: v3(297.45,39.35) 297.87,38.93 v6(297.87,37.95)
  vias: v2(293.12,32.4) v2(293.23,32.64) v6(297.86,37.37)
+SIM_PWR: length 34.5
  TOP w0.102: v6(282.19,33.07) v1(281.2,33.07)
  TOP w0.508: v6(289.32,32.66) 289.29,32.69 288.26,32.69 287.88,33.07 v6(282.19,33.07)
  IN1 w0.508: v6(290.63,37.77) 290.5,37.77 289.23,36.5 289.23,32.75 v6(289.32,32.66)
  IN3 w0.508: v5(290.42,32.24) 290,32.66 v6(289.32,32.66)
  BOTTOM w0.305: 266.78,30.38 266.4,30.76 JNGFF1.36
  BOTTOM w0.508: v6(282.19,33.07) 277.48,33.07 276.78,32.38 276.78,31.11 275.49,29.81 267.35,29.81 266.78,30.38
+TBT_VBUS1: length 1.7
  IN1 w0.254: v4(6.38,55.6) 6.06,55.6 v2(6.05,55.62)
  BOTTOM w0.254: v5(6.05,52.78) 5.74,52.78 v5(5.49,52.53) ; v5(5.49,56.06) 5.75,55.8 v5(6.09,55.8)
  vias: v2(6.03,53.11) v2(6.81,52.87) v2(6.81,52.23) v2(7.65,55.36) v2(7.67,52.87) v2(7.9,55.36) v2(7.92,52.87) v2(8.27,55.36) v2(8.27,52.87) v2(8.53,55.36) v2(8.53,52.87) v2(8.78,55.36) v2(8.78,52.87) v4(6.36,53.04) v4(7.67,53.61) v4(7.72,53.2) v4(7.85,55.82) v4(7.85,55.03) v4(8.12,53.2) v4(8.25,55.82) v4(8.25,55.03) v4(8.53,53.2) v4(8.66,55.82) v4(8.66,55.03) v5(7.57,55.36) v5(7.82,55.36) v5(8.58,55.36) v5(8.53,54.6) v5(8.53,53.97) v5(8.79,54.6) v5(8.79,53.97) v5(8.84,55.36)
+TBT_VBUS2: length 3
  IN1 w0.254: v4(6.38,70.81) 6.06,70.82 v2(6.05,70.84)
  IN3 w0.508: v5(4.28,70.17) v4(4.28,70.64)
  BOTTOM w0.254: v5(5.93,68.01) v5(5.49,67.75) ; v5(6.02,71.01) v5(5.49,71.28)
  BOTTOM w0.508: v5(4.27,70.17) 4.28,70.17 CT102.1 4.36,69.61 CT109.2
  vias: v2(6.05,68.33) v2(6.81,68.08) v2(6.81,67.45) v2(7.65,70.58) v2(7.67,68.08) v2(7.9,70.58) v2(7.92,68.08) v2(8.27,70.58) v2(8.27,68.08) v2(8.53,70.58) v2(8.53,68.08) v2(8.78,70.58) v2(8.78,68.08) v4(6.38,68.23) v4(7.69,68.82) v4(7.72,68.42) v4(7.85,71.04) v4(7.85,70.25) v4(8.12,68.42) v4(8.25,71.04) v4(8.25,70.25) v4(8.53,68.42) v4(8.66,71.04) v4(8.66,70.25) v5(7.57,70.58) v5(7.82,70.58) v5(8.58,70.58) v5(8.53,69.82) v5(8.53,69.19) v5(8.79,69.82) v5(8.79,69.19) v5(8.84,70.58) v5(9.42,69.59) v5(9.42,69.34)
+V_DDR_REF_CA: length 16.2
  TOP w0.127: v1(56.17,29.15) 57.19,30.17 v2(58.1,30.17)
  TOP w0.356: RD10.1 CD46.1 57.87,29.34 57.87,29.94 v2(58.1,30.17)
  IN1 w0.508: v4(58.31,31.06) 58.1,30.85 v2(58.1,30.17)
  IN2 w0.508: v4(67.11,33.45) 67.11,32.7 66.19,31.78 59.03,31.78 v4(58.31,31.06)
  IN3 w0.508: v5(67.9,33.45) v4(67.11,33.45)
+V_DDR_REFB_R:
  vias: v1(70.33,30.6)
+VDISPLAY_VCC: length 14.1
  IN1 w0.508: v4(16.29,34.27) 15.92,34.27 v2(15.72,34.47)
  IN3 w0.508: v4(16.29,34.27) v5(16.29,23.45) v5(16.29,21.94)
  BOTTOM w0.254: RM95.1 v5(16.29,23.45) ; v5(16.29,21.94) 16.02,21.67 RM94.1
  vias: v3(17.26,34.36)
+VR_CAP: length 20.1
  TOP w0.254: UE1.C10 270.05,59.61 v2(270.18,59.73) ; UE1.J1 262.58,54.75 262.2,54.75
  TOP w0.356: CE25.1 260.92,54.06 v2(261.39,54.53) 261.62,54.75 262.2,54.75
  IN1 w0.254: v4(269.91,59.98) 270.15,59.73 v2(270.18,59.73)
  IN1 w0.381: v2(261.39,54.53) 261.39,55.31 v4(261.41,55.33)
  IN3 w0.508: v4(261.41,55.33) 261.39,55.34 261.39,57.6 262.76,58.97 264.02,58.97 264.53,58.46 264.53,57.04 265.49,56.08 267.06,56.08 268.21,57.23 268.21,57.85 268.9,58.54 268.9,59.64 269.24,59.98 v4(269.91,59.98)
+VREFCA: length 49.4
  TOP w0.381: RD10.2 RD11.1 57.63,26.64 RD12.2
  TOP w0.508: v2(57.5,18.33) 56.81,18.33 56.79,18.35 56.77,18.35 56.43,18.69 56.43,18.71 56.4,18.74 v1(56.4,25.15) 56.4,26.13 56.83,26.56 RD12.2 ; v2(72.16,15.16) 72.95,15.16 73.95,16.16 80.33,16.16 v2(80.71,16.55)
  IN1 w0.254: v4(89.9,20.12) v2(90.21,20.24)
  IN1 w0.508: v2(80.71,16.55) 81.89,15.37 87.56,15.37 87.56,15.37 88.01,15.37 v2(88.13,15.37) 88.14,15.36 88.87,15.36 88.89,15.37 89.33,15.37 89.34,15.36 90.4,15.36 v4(90.47,15.28) ; v2(72.16,15.16) 72.09,15.23 72.09,15.25 71.71,15.63 67.77,15.63 67.03,14.89 v4(66.2,14.89) 65.67,15.43 v2(63.95,15.43) 62.71,15.43 62.08,16.06 60.01,16.06 57.73,18.33 v2(57.5,18.33)
  IN3 w0.254: v4(89.9,20.12) 89.89,20.11 v5(89.31,20.11)
  IN3 w0.381: v4(90.47,15.28) 90.47,15.32 90.36,15.44 v5(90.07,15.44) ; v4(66.2,14.89) 66.25,14.94 v5(66.25,15.43)
+VREFDQ_A: length 5.7
  TOP w0.127: 65.09,26.71 65.09,25.76 v5(65.42,25.43)
  TOP w0.381: 65.09,26.71 64.95,26.85 64.95,29.02 v2(65,29.06) 65.04,29.1 CD71.1
  IN1 w0.254: v4(65.67,25.8) 65.67,25.69 v5(65.42,25.43) ; v4(64.95,28.6) 65,28.65 v2(65,29.06)
  IN3 w0.203: v4(65.67,25.8) 65.68,25.75 v5(65.42,25.43)
  IN3 w0.305: v5(64.92,28.94) 64.95,28.91 v4(64.95,28.6)
+VREFDQ_B: length 51.1
  TOP w0.381: v2(58.18,19.58) RD4.1 58.18,18.37 RD6.2
  TOP w0.508: 89.38,27.2 89.12,27.46 89.12,29.4 88.36,30.17 84.43,30.17 83.09,28.83 v3(81.3,28.83) 80.47,28.83 79.13,30.17 v2(69.74,30.17) 59.39,30.17 59.09,29.86 59.09,28.72 v2(58.72,28.35)
  IN1 w0.203: v5(88.92,25.43) v4(88.6,25.83)
  IN1 w0.381: v2(69.74,30.17) 69.74,30.57 v4(69.73,30.58)
  IN1 w0.508: v2(58.72,28.35) 58.72,27.86 57.58,26.72 57.58,24.91 57.61,24.89 57.61,24.01 58.74,22.88 58.74,21.76 58.18,21.2 v2(58.18,19.58)
  IN3 w0.203: v5(88.92,25.43) v4(88.6,25.83)
  IN3 w0.381: v4(69.73,30.58) 69.37,30.22 v5(69.37,30.16)
  BOTTOM w0.254: 89.15,26.71 CD70.1
AC1_DISC#: length 82.5
  TOP w0.127: v2(9.3,42.36) PR167.1 ; PR140.1 38.69,65.63 v2(38.67,65.63)
  IN1 w0.061: v2(38.67,65.63) 38.48,65.82 v4(38.38,65.82) ; v4(23.95,38.79) 23.57,39.17 v2(23.57,39.24) ; v2(9.3,42.36) 9.3,42.11 v4(9.49,41.93) 9.49,41.88 9.8,41.56 11.85,41.56 12.4,42.12 12.4,43.84 13.66,45.1 13.66,47.71 15.56,49.61 15.56,57.74 14.96,58.34 14.96,59.3 15,59.34 15,62.1 15.69,62.79 16.13,62.79 16.34,63 18.43,63 18.7,63.27 21.2,63.27 21.49,62.98 22.25,62.98 v4(22.46,62.76) 22.68,62.98 23.57,62.98 23.82,63.23 24.9,63.23 v4(24.93,63.19)
  IN2 w0.061: v4(9.49,41.93) 13.14,41.93 15.32,39.76 15.32,36.02 v4(16.27,35.07)
  IN3 w0.061: v5(29.15,64.98) 29.15,63.52 28.5,62.86 28.11,62.86 27.82,62.58 27.52,62.58 26.99,63.1 25.02,63.1 v4(24.93,63.19) ; v4(38.38,65.82) 38.16,65.6 v5(38.12,65.6) ; v4(22.46,62.76) 22.46,63.41 21.46,64.42 21.46,65.86 21.91,66.3 21.91,66.58 22.22,66.9 v5(22.33,66.9) ; v4(23.95,38.79) 23.56,39.18 22.23,39.18 20.97,37.92 20.5,37.92 19.12,36.54 18.09,36.54 17.11,35.56 16.44,35.56 16.27,35.39 v4(16.27,35.07)
  BOTTOM w0.127: v5(29.15,64.98) 30.09,64.98 30.89,65.78 37.94,65.78 v5(38.12,65.6) ; v5(22.33,66.9) 22.33,66.9 22.34,66.92 UT1.G11
AC1_OVP: length 61.7
  TOP w0.127: PR131.1 12.12,72.12 11.74,71.74 11.74,67.98 10.11,66.34 v1(10.11,64.52) 10.11,61.14 11.68,59.57 11.68,57.64 11.38,57.33 11.38,55.09 11.68,54.78 11.68,54.01 v2(12.6,53.09) ; v2(25.32,42.7) 25.83,42.7 PC143.1 25.96,43.1 PR191.1
  IN1 w0.061: v4(25.01,42.9) 25.21,42.9 25.32,42.79 v2(25.32,42.7) ; v2(12.6,53.09) 12.26,52.75 12.07,52.75 10.38,51.06 10.38,50.35 10.58,50.16 11.13,50.16 11.64,49.64 11.64,48.96 11,48.32 8.01,48.32 6.96,47.28 6.96,42.33 7.24,42.06 8.34,42.06 v4(8.58,42.3)
  IN3 w0.061: v4(8.58,42.3) 9.67,42.3 11.64,40.32 13.12,40.32 15.37,42.57 15.84,42.57 16,42.41 16,41.94 16.18,41.76 18.83,41.76 19.1,42.03 20.53,42.03 22.39,43.88 24.02,43.88 v4(25.01,42.9)
AC2_DISC#: length 85.7
  TOP w0.127: PR127.1 19.95,63.54 19.95,64.1 20.53,64.69 v2(21.42,64.69) ; v2(24.64,58.55) 24.64,58.36 25.08,57.93 30.22,57.93 30.34,58.06 30.34,59.79 30.82,60.27 32.08,60.27 33.9,58.44 PR141.1
  IN1 w0.061: v4(23.44,38.78) 23.6,38.63 v2(23.6,38) ; v2(21.42,64.69) 21.64,64.69 v4(21.8,64.52) ; v2(24.64,58.55) v4(24.64,58.9)
  IN2 w0.061: v4(22.5,73.38) 22.7,73.18 22.7,71.83 23,71.53 23,70.68 22.07,69.76 22.07,68.96 22.72,68.31 22.72,67.21 21.8,66.29 v4(21.8,64.52) 21.8,64.06 22.06,63.8 22.65,63.8 23.62,62.83 23.62,62.37 23.45,62.19 23.15,62.19 22.88,62.45 21.37,62.45 20.93,62.01 20.93,60.13 21.06,60 23.32,60 23.63,59.68 23.63,59.39 23.87,59.15 24.4,59.15 v4(24.64,58.9) 24.69,58.86 24.69,58.2 24.43,57.94 22.06,57.94 21.33,57.22 21.33,56.32 21.64,56.01 21.64,55.61 21.75,55.5 22.24,55.5 22.3,55.44 23.53,55.44 23.66,55.31 23.66,54.35 23.86,54.15 23.86,53.05 23.68,52.87 23.68,52.55 23.49,52.36 21.92,52.36 21.72,52.16 21.72,51.01 21.59,50.88 21.21,50.88 21.08,50.76 21.08,50.39 20.92,50.22 18.67,50.22 18.57,50.32 17.78,50.32 17.26,49.81 17.26,48.55 15.54,46.83 15.54,45.01 15.04,44.5 15.04,40.5 15.56,39.99 15.56,36.31 v4(16.79,35.07)
  IN3 w0.061: v4(23.44,38.78) 23.18,39.05 22.27,39.05 21.03,37.8 20.6,37.8 19.22,36.42 18.14,36.42 v4(16.79,35.07) ; v5(22.56,73.9) 22.56,73.44 v4(22.5,73.38)
  BOTTOM w0.127: v5(22.56,73.9) 22.6,73.9 22.64,73.93 UT5.G11
AC2_OVP: length 16.8
  TOP w0.127: PR170.1 8.13,46.62 8.13,46.22 7.59,45.69 7.59,42.5 8.79,41.31 9.78,41.31 10.28,40.81 11.7,40.81 13.2,39.31 v1(14.53,39.31) 15.05,39.31 15.72,39.98 PR189.1 15.72,40.46 16.03,40.77 PR186.2 15.3,40.96 PC139.1
AC_DIS: length 292.4
  TOP w0.127: PR223.1 26.84,9.83 27.37,9.3 29.11,9.3 29.8,9.98 29.8,11.14 30.58,11.93 35.73,11.93 36.44,11.22 v1(38.09,11.22) 39.9,11.22 40.75,12.07 40.75,15.06 39.43,16.38 38.5,16.38 37.54,17.33 37.54,19.28 v2(37.61,19.36) ; RE116.1 v2(273.98,54.63) 273.43,55.17 271.87,55.17 UE1.H12
  IN1 w0.061: v4(266.59,46.73) 267.1,47.24 269.15,47.24 269.84,47.93 269.84,49.09 272.45,51.7 272.45,52.83 273.98,54.35 v2(273.98,54.63) ; v2(37.61,19.36) v4(37.61,19.99)
  IN2 w0.061: v4(266.59,46.73) 266.59,46.08 265.22,44.71 261.5,44.71 261.05,45.16 256.23,45.16 255.6,44.53 253.54,44.53 252.98,43.98 252.14,43.98 251.66,43.5 251.66,43.11 250.2,41.64 237.6,41.64 219.4,23.45 214.54,23.45 211.16,20.07 183.54,20.07 178.39,14.93 153.39,14.93 153.13,15.19 147.36,15.19 143.13,19.42 128.86,19.42 127.07,20.15 122.82,20.15 122.35,19.68 113.31,19.68 108.75,15.12 105.42,15.12 104.27,16.27 100.89,16.27 100.33,15.71 97.75,15.71 97.3,15.26 91.45,15.26 90.98,15.72 53.01,15.72 52.94,15.65 49.16,15.65 46.69,18.12 40.83,18.12 39.38,19.57 38.03,19.57 v4(37.61,19.99)
AC_DIS#: length 9.6
  TOP w0.127: PC112.1 37.31,60.94 PR129.2 37.29,60.14 v1(37.59,59.84) ; PC112.1 36.85,61.8 36.64,62.01 PQ106.6 ; PC112.1 37.26,61.85 PR107.2 37.26,63.29 PR109.1 37.24,63.39 34.19,63.39 PR130.2 33.83,63.52 33.58,63.77 33.58,64.21 33.36,64.43 PR108.2
AC_DISC#: length 339.9
  TOP w0.127: v2(271.85,57.87) 271.99,58.01 UE1.E13 ; v2(36.28,63.09) 36.26,63.06 33.57,63.06 PR108.1
  IN1 w0.061: v4(271.99,56.71) 271.82,56.89 271.82,57.84 v2(271.85,57.87) ; v4(35.58,63.02) 36.22,63.02 v2(36.28,63.09)
  IN2 w0.061: v4(271.99,56.71) 271.97,56.69 271.97,55.8 273.49,54.29 273.49,47.82 268.9,43.24 267.75,43.24 266.03,41.52 265.7,41.52 263.82,39.64 257.71,39.64 254.88,36.81 236.71,36.81 217.63,17.73 212.59,17.73 212.27,17.41 202.97,17.41 201.37,15.81 183.1,15.81 179.56,12.26 152.29,12.26 152.03,12.52 133.44,12.52 132.46,13.5 132.46,15.7 131.27,16.89 128.35,16.89 126.69,17.57 123.83,17.57 123.4,17.14 114.37,17.14 109.81,12.58 103.53,12.58 103.22,12.88 101.54,12.88 101.34,12.68 97.6,12.68 97.14,12.22 57.63,12.22 56.58,13.27 53.97,13.27 53.85,13.15 53.23,13.15 52.74,12.66 48.29,12.66 48.03,12.92 44.47,12.92 43.61,12.05 38.54,12.05 35.22,15.37 27.41,15.37 23.51,19.27 23.51,22.65 24.18,23.31 24.7,23.31 24.96,23.31 27.3,25.66 27.3,29.97 27.59,30.27 27.59,35.8 27.98,36.19 27.98,36.83 29.66,38.51 29.66,39.75 31.67,41.76 31.67,43.88 31.76,43.97 31.76,45.67 32.57,46.48 33.46,46.48 33.81,46.82 33.81,48.78 34.35,49.32 34.35,54.12 35.77,55.54 35.77,62.83 v4(35.58,63.02)
AC_DISC_OUT#: length 72.7
  TOP w0.127: v2(32.26,67.25) 32.26,67.69 32.65,68.08 33.73,68.08 34.57,67.24 34.57,66.29 34.9,65.96 35.76,65.96 PR106.2
  IN1 w0.061: v2(25.23,13.38) 25.09,13.52 v4(25.09,13.7) ; v4(31.6,67.01) 31.84,67.25 v2(32.26,67.25)
  IN2 w0.061: v4(31.6,67.01) 31.28,66.69 31.28,65.38 30.8,64.9 30.8,64.26 30.13,63.59 30.13,59.68 28.47,58.02 28.47,47.09 28.86,46.71 28.86,45.73 26.4,43.27 22.68,43.27 22.07,42.67 22.06,42.67 21.34,41.95 21.34,41.85 21.34,41.84 21.34,41.74 21.34,41.74 21.34,41.07 21.92,40.49 21.92,35.69 19.45,33.23 19.45,32.29 17.89,30.72 17.89,24.92 18.14,24.67 18.14,24.66 18.49,24.31 18.49,20.46 20.88,18.07 20.88,16.78 23.97,13.7 v4(25.09,13.7)
AC_PRESENT: length 197.9
  TOP w0.102: UE1.K8 268.24,53.68 v2(268.27,53.64)
  IN1 w0.061: v2(268.27,53.64) 268.27,53.13 267.87,52.72 267.87,51.72 267.56,51.41 v4(267.25,51.41)
  IN2 w0.061: v4(267.25,51.41) 265.84,50.01 265.84,48.07 263.29,45.52 261.59,45.52 261.28,45.83 247.67,45.83 246.95,45.12 237.21,45.12 231.38,39.29 228.69,39.29 220.84,31.44 220.18,31.44 217.11,28.36 197.97,28.36 197.61,28.72 189.76,28.72 177.68,16.64 154.11,16.64 153.84,16.91 148.08,16.91 143.81,21.17 141.26,21.17 139.58,22.85 134.52,22.85 133.41,21.74 131.58,21.74 131.25,21.4 130.12,21.4 129.11,22.4 126.26,22.4 125.82,21.96 122.57,21.96 121.98,21.37 118.99,21.37 116.05,24.31 115.58,24.31 110.69,29.2 106.24,29.2 105.3,30.14 101.04,30.14 v4(100.91,30.27)
  IN3 w0.061: v4(100.91,30.27) 100.91,30.52 v5(100.81,30.63)
  BOTTOM w0.102: v5(100.81,30.63) 100.81,31.13 100.28,31.67 100.28,33.2 100.07,33.4 99.83,33.4 99.66,33.57 99.66,33.7 UCPU1.BU35
ACAV_IN: length 347
  TOP w0.127: v6(24.05,10.39) 23.42,10.39 v1(22.85,9.83) ; v6(29.87,37.5) 30.57,36.8 PRB45.2 PRB42.2 PRB40.1 33.03,36.4 33.4,36.04 35.41,36.04 35.99,35.46 35.99,33.44 36.41,33.03 36.41,31.83 35.72,31.15 35.72,29.98 PR1518.2
  IN1 w0.061: v2(267.44,59.61) 267.85,59.19 267.85,57.07 267.68,56.89 v4(267.68,55.82) ; v4(18.73,39.53) 18.99,39.79 21.87,39.79 23.19,38.47 23.19,37.79 23.48,37.5 v6(29.87,37.5)
  IN2 w0.061: v4(267.68,55.82) 267.2,56.3 265.46,56.3 264.66,57.1 263.08,57.1 262.65,57.54 262.65,57.97 262.55,58.07 262.13,58.07 259.96,55.9 258.28,55.9 257.48,55.1 257.48,54.17 256.97,53.66 255.56,53.66 254.7,54.53 250.87,54.53 245.62,49.27 231.01,49.27 227.38,45.64 221.78,45.64 219.16,43.02 215.46,43.02 213.84,41.4 207.86,41.4 206.55,40.1 206.55,39.01 206.55,38.9 205.09,37.45 197.18,37.45 v6(194.92,35.18) ; v4(18.73,39.53) 18.37,39.17 18.37,32.65 16.75,31.03 16.75,28.48 16.1,27.83 16.1,12.36 19.56,8.91 22.56,8.91 v6(24.05,10.39)
  BOTTOM w0.127: v6(24.05,10.39) 24.05,8.73 24.47,8.31 28.08,8.31 29.42,9.65 38.09,9.65 38.3,9.86 113.94,9.86 114.35,10.27 114.35,15.79 114.95,16.39 115.49,16.39 115.77,16.11 121.81,16.11 123.49,17.08 123.52,17.15 123.86,17.29 123.88,17.3 124.57,17.58 124.93,17.73 125.64,17.82 132.27,17.82 133.09,18.64 134.66,18.64 134.99,18.97 135.69,18.97 138.84,22.12 145.98,22.12 D481.1 147.21,20.88 149.91,20.88 149.92,20.87 149.93,20.87 150.46,20.33 151.74,20.33 152.54,19.53 153.48,19.53 154.85,18.17 174.94,18.17 185.7,28.92 189.66,28.92 193.13,32.39 193.13,34.6 193.71,35.18 v6(194.92,35.18)
ACAV_IN1: length 74.8
  TOP w0.127: v1(29.35,41.24) 29.77,40.82 PRB39.1 29.77,39.27 29.4,38.91 v6(29.4,37.04) 29.65,36.78 PRB45.1 30.28,35.78 35.31,35.78 35.74,35.35 35.74,33.34 36.16,32.92 36.16,31.97 35.47,31.29 35.47,29.44 PR1517.2 ; v2(22.26,11.83) 22.26,12.15 23.01,12.9 23.01,14.34 PR225.1 PR219.2 PR220.1
  IN1 w0.061: v4(22.68,12.02) 22.49,11.83 v2(22.26,11.83) ; v4(18.73,39.01) 19.39,39.67 21.82,39.67 23.07,38.42 23.07,37.74 23.44,37.37 29.07,37.37 v6(29.4,37.04)
  IN2 w0.061: v4(18.73,39.01) 18.5,38.77 18.5,32.6 16.88,30.98 16.88,28.43 16.23,27.78 16.23,12.41 19.61,9.04 22.43,9.04 22.68,9.29 v4(22.68,12.02)
ACC2_ADD_SEL: length 1.9
  TOP w0.127: RV50.2 RV51.2 246.61,41.17 246.36,40.92 UV5.3
ALLSYS_PWRGD: length 2.5
  TOP w0.127: RE508.1 RE1.1 256.3,56.75 RE478.2 256.3,55.82 256.31,55.81 RE477.1 RE457.1
ALW_PWRGD_3V_5V: length 415.6
  TOP w0.127: v2(120.92,28.67) 120.18,28.67 119.91,28.4 119.91,24.51 120.01,24.41 120.01,20.06 119.07,19.11 119.07,15.43 v2(118.97,15.33) ; v2(42.88,38.67) 42.8,38.75 RE511.2
  IN1 w0.061: v4(120.15,28.59) 120.23,28.67 v2(120.92,28.67) ; v4(20.42,42.54) 20.63,42.33 25.68,42.33 25.71,42.36 27.1,42.36 27.41,42.06 27.41,41.51 27.7,41.22 27.7,40.89 28,40.59 28.74,40.59 32.67,44.52 36.5,44.52 37.27,45.29 37.79,45.29 38.41,44.68 41.38,44.68 42.24,43.82 42.24,42.43 41.8,41.99 41.8,38.79 41.92,38.67 v2(42.88,38.67) 42.88,38.45 43.45,37.88 44.02,37.88 44.89,37.02 45.99,37.02 51.36,31.65 51.36,30.47 51.64,30.19 51.64,28.34 53.9,26.08 53.9,12.94 56.24,10.61 110.98,10.61 111.21,10.84 111.21,11.23 111.59,11.61 111.59,12.67 112.64,13.71 112.64,14.84 113.13,15.33 v2(118.97,15.33) 122.83,15.33 124.2,16.7 128.04,16.7 130.44,14.31 130.44,13.47 130.83,13.07 v4(131.05,13.07)
  IN2 w0.061: v6(291.79,58.92) 291.39,59.32 290.8,59.32 290.28,58.8 282.1,58.8 275.56,52.27 275.56,48.68 270.76,43.88 270.76,42.03 267.21,38.48 259.14,38.48 256.64,35.98 237.12,35.98 216.24,15.09 203.36,15.09 201.87,13.61 200.49,13.61 199.99,14.1 182.12,14.1 179.77,11.76 152.08,11.76 151.82,12.01 132.55,12.01 131.48,13.07 v4(131.05,13.07)
  IN3 w0.061: v4(20.42,42.54) 17.56,42.54 17.03,43.07 15.52,43.07 13.02,40.57 11.74,40.57 9.5,42.81 9.35,42.81 8.63,43.53 8.63,45.47 7.77,46.34 7.77,47.73 6.91,48.59 4.91,48.59 3.9,49.61 3.9,67.11 3,68.01 3,72.12 5.84,74.96 8.47,74.96 v5(9.57,73.86) ; v5(119.25,28.59) v4(120.15,28.59)
  BOTTOM w0.127: DC2.1 118.59,29.95 119.25,29.29 v5(119.25,28.59) ; RE512.2 292.48,58.12 RE509.2 292.16,58.15 291.79,58.51 v6(291.79,58.92) 291.79,59.12 v1(291.43,59.49)
  BOTTOM w0.254: RT302.1 16.03,74.95 15.14,74.06 13.71,74.06 13.13,73.48 11.89,73.48 QT1.2 10.06,73.38 v5(9.57,73.86)
ALWON: length 3.2
  TOP w0.127: UE1.A5 265.85,61.22 265.85,63.29 RE472.1 266.1,63.48 266.58,63.96 RE469.1
ANT1_CS0: length 5.3
  BOTTOM w0.127: JANT1.1 210.47,70.12 209.66,70.92 CS13.1 208.86,70.92 208.67,70.73 LS4.1 v1(208.27,69.52)
ANT1_CS0_R: length 5.5
  BOTTOM w0.127: LS4.2 207.32,70.03 206.53,69.23 v1(205.82,69.23) RS9.1
ANT1_CS1: length 4.1
  TOP w0.127: RS14.2 202.07,68.78 LS5.1 CS14.1 203.3,68.27 204.05,69.02 v1(204.05,69.94)
ANT1_CS1_R: length 5.6
  TOP w0.127: v1(201.42,70.1) 201.42,69.92 200.77,69.27 200.77,68.65 201.12,68.3 v2(201.12,68.27)
  IN1 w0.061: v2(201.12,68.27) 200.77,68.62 v4(200.77,69.08)
  IN3 w0.061: v5(201.55,69.08) v4(200.77,69.08)
  BOTTOM w0.127: v5(201.55,69.08) 201.55,69.26 201.4,69.41 200.62,69.41 200.43,69.22 U16.B4
ANT2_SP4T: length 15.2
  TOP w0.127: CN60.1 197.3,73.87 v2(196.98,73.55) ; v1(202.73,69.97) 201.99,69.97 201.22,69.2 v2(201.22,69.06)
  IN1 w0.061: v6(193,71.85) 194.16,71.85 195.85,73.55 v2(196.98,73.55) 198.66,73.55 201.22,70.99 v2(201.22,69.06)
  BOTTOM w0.127: JANT2.1 193.43,71.85 v6(193,71.85)
ANT_RF1: length 2.9
  TOP w0.127: UN3.1 v1(196.52,73.17) v6(195.95,73.17)
  BOTTOM w0.127: v6(195.95,73.17) 196.2,72.92 LN13.1 196.63,72.92 LN15.1
ANT_RF2: length 5.8
  TOP w0.127: UN3.2 196.64,72.77 196.46,72.59 v1(196.46,71.68) 196.46,71.62 196.59,71.48 v6(197.28,71.48)
  BOTTOM w0.127: CN44.1 CN45.1 199.11,70.85 198.47,71.48 v6(197.28,71.48)
ANT_RF3: length 5.8
  TOP w0.127: UN3.9 198.93,73.17 200.14,71.96 v1(200.84,71.96) v6(201.98,71.96)
  BOTTOM w0.127: LN14.1 203.08,72.46 LN12.1 202.39,72.28 202.08,71.96 v6(201.98,71.96)
ANT_RF4: length 4.5
  TOP w0.127: UN3.8 198.68,72.77 199.17,72.28 v1(199.17,72.04) v6(199.17,71.46)
  BOTTOM w0.127: CN43.1 CN42.1 200.38,71.1 200.02,71.46 v6(199.17,71.46)
ANTCTL0: length 144.4
  TOP w0.127: LN9.1 198.44,69.77 v6(198.03,69.36) ; v6(258.36,68.52) v1(258.36,69.16)
  IN2 w0.061: v6(275.01,66.78) 275.01,64.46 273.6,63.04 261.29,63.04 258.73,65.61 258.73,65.69 258.36,66.05 v6(258.36,68.52)
  IN3 w0.061: v5(275.73,21.95) 275.99,22.21 275.99,22.62 277.55,24.18 277.55,27.87 278.33,28.66 278.33,33.63 278.66,33.95 278.66,51.58 277.51,52.72 277.51,63.65 275.01,66.14 v6(275.01,66.78) ; v6(258.36,68.52) 258.36,67.82 257.7,67.17 254.84,67.17 251.98,70.03 243.06,70.03 238.96,74.13 225.12,74.13 224.51,73.51 221.36,73.51 219.74,71.9 219.74,71.43 218.62,70.31 208.07,70.31 207.1,69.34 202.91,69.34 202.68,69.58 198.25,69.58 v6(198.03,69.36)
  BOTTOM w0.127: JNGFF1.59 272.15,23.37 273.49,22.03 275.65,22.03 v5(275.73,21.95)
ANTCTL1: length 139.8
  TOP w0.127: v6(199.83,69.19) 200.17,69.19 200.38,69.4 LN10.1 ; v1(259.8,68.57) 259.39,68.57 v6(258.85,68.04)
  IN2 w0.061: v6(258.85,68.04) 258.85,65.66 261.34,63.17 273.55,63.17 274.6,64.23 v6(274.6,66.38)
  IN3 w0.061: v6(199.83,69.19) 200.06,69.42 202.61,69.42 202.82,69.22 207.17,69.22 208.13,70.18 218.66,70.18 219.86,71.38 219.86,71.85 221.41,73.39 224.56,73.39 225.18,74 238.91,74 243.01,69.91 251.93,69.91 254.81,67.03 257.85,67.03 v6(258.85,68.04) ; v5(275.75,22.31) 275.75,22.55 277.43,24.23 277.43,27.93 278.21,28.71 278.21,33.68 278.53,34 278.53,51.51 277.37,52.67 277.37,63.61 v6(274.6,66.38)
  BOTTOM w0.127: JNGFF1.61 272.65,23.4 273.74,22.31 v5(275.75,22.31)
ANTCTL2: length 148.5
  TOP w0.127: v1(258.9,67.21) 258.09,68.02 v6(258.01,68.02) ; v6(192.56,69.97) 192.77,69.97 LN11.1
  IN2 w0.061: v6(258.01,68.02) 258.01,64.58 260.78,61.82 269.74,61.82 270.82,62.9 273.64,62.9 275.39,64.66 v6(275.39,66.32)
  IN3 w0.061: v6(258.01,68.02) 257.28,67.29 254.89,67.29 252.03,70.15 243.11,70.15 239.01,74.25 225.07,74.25 224.46,73.63 221.31,73.63 219.62,71.95 219.62,71.48 218.59,70.45 208.03,70.45 207.05,69.46 202.96,69.46 202.71,69.72 192.81,69.72 v6(192.56,69.97) ; v6(275.39,66.32) 277.63,64.08 277.63,52.77 278.78,51.63 278.78,33.9 278.46,33.57 278.46,28.61 277.67,27.82 277.67,24.13 276.36,22.82 v5(276.36,22.61)
  BOTTOM w0.127: JNGFF1.63 273.15,23.26 273.8,22.61 v5(276.36,22.61)
AUD_PWR_EN: length 185.6
  TOP w0.127: RA122.1 266.31,42.97 v1(266.31,45.6) 266.31,46.41 v2(266.04,46.68)
  IN1 w0.061: v2(266.04,46.68) 264.53,46.68 264.25,46.4 262.88,46.4 v4(262.74,46.26)
  IN2 w0.061: v4(107.59,30.02) 110.77,30.02 115.81,24.98 116.28,24.98 118.53,22.73 125.51,22.73 125.97,23.19 127.94,23.19 128.46,23.71 139.83,23.71 141.61,21.93 144.13,21.93 148.39,17.67 154.16,17.67 154.42,17.4 177.36,17.4 189.44,29.48 197.93,29.48 198.29,29.13 213,29.13 213.65,29.78 213.88,29.78 215.8,29.78 216.18,29.4 217.21,29.4 219.89,32.07 220.58,32.07 234.13,45.62 246.7,45.62 247.41,46.34 262.66,46.34 v4(262.74,46.26)
  IN3 w0.061: v4(107.59,30.02) 107.59,30.6 v5(107.2,30.98)
  BOTTOM w0.076: UCPU1.CK36 106.56,33.18 106.56,32.99 106.45,32.87 106.45,32.43 106.54,32.33
  BOTTOM w0.127: 106.54,32.33 107.1,31.78 107.1,31.21 107.19,30.98 v5(107.2,30.98)
