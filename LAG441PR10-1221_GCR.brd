# Allegro board LAG441PR10-1221_GCR.brd (continued)
## Nets (continued)
N17095689: PQ108.2 PQ110.1 PR122.2 PR124.1
N17095691: PC1425.1 PQ110.2 PR133.2
N17096830: PQ107.2 PR118.1 PR121.2
N17207943: PC314.1 PR309.2
N17207958: PC305.2 PR300.2
N17829734: PR501.2 PR502.2 PR504.1 PU500.10
N17837552: PC500.1 PR507.2
N18204399: PQ109.5 PR127.2 PR132.1 PR1431.2
N18206236: PQ123.5 PR167.2 PR172.1 PR1432.2
N18468637: PDB4.1 PDB5.1 PRB41.1 PUB2.2
N18468639: PRB39.2 PUB2.1
N18468715: PRB42.1 PUB2.4
N18468749: PDB4.2 PRB36.2 PRB46.2
N18468757: PDB5.2 PRB37.2 PRB47.2
N18718370: PQ1501.2 PR1507.2
N18718373: PQ1501.1 PR1508.1
N18719563: PQ1502.2 PR1509.2
N18719565: PQ1502.1 PR1510.1
N18759659: PQ1506.1 PR701.1 PR702.1 PR703.1 PR1511.1 PU700.8
N18767948: PC1503.1 PR1504.2 PR1512.2 PU1500.4
N18767950: PC1502.1 PD1503.1 PR1513.2 PR1514.1 PU1500.3
N18767961: PC1501.1 PR1500.2 PR1504.1 PU1500.6
N18768069: PC1505.1 PD1502.1 PR1516.1 PR1517.1 PR1518.1 PU1501.3
N18768083: PC1504.1 PR1505.1 PR1515.2 PU1501.4
N18768087: PC1500.1 PR1502.2 PU1501.6
N19584540: RT51.1 RT52.1 RT56.1 UT1.F10
N19588867: RT57.1 RT58.1 RT62.1 UT5.F10
N20151644: PR200.2 PR202.1
N20151664: PR200.3 PR203.1
N27076067: PC243.1 PR231.2
N29202294: PC1410.2 PR1416.2
N29724347: CC238.1 RC538.2
N29724438: QC2.1 RC539.2
N30248348: PR211.2 PR221.1
N30249106: PR211.3 PR222.1
N30252391: PC230.2 PR210.2
N30253802: PC244.1 PR230.2 PR233.2 PR234.2
N30258320: PC225.1 PR205.1
N30277718: PD201.1 PD202.1 PR208.1
N35113641: PC110.2 PQ100.4 PQ102.1 PR104.2 PR115.1
N35119332: PC111.2 PQ101.4 PQ103.1 PR105.2 PR112.1
N35124847: PQ107.1 PR112.2
N35126885: PQ109.6 PR113.2
N35129437: PQ109.2 PQ109.3 PR119.2
N35130312: PQ103.2 PR101.2 PR113.1
N35131434: PC123.2 PQ115.4 PQ117.1 PR147.2 PR152.1
N35132002: PC124.2 PQ116.4 PQ118.1 PR148.2 PR150.1
N35132051: PQ118.2 PR144.2 PR151.1
N35132981: PQ120.1 PR150.2
N35133273: PQ123.2 PQ123.3 PR155.2
N35133295: PQ123.6 PR151.2
N36145369: PQ102.2 PR100.2 PR110.1
N36146502: PQ105.2 PQ105.3 PR116.2
N36147287: PQ105.5 PR120.2 PR123.1
N36148115: PQ117.2 PR146.2 PR149.1
N36148155: PQ119.2 PQ119.3 PR153.2
N36148188: PQ119.5 PR157.2 PR161.1
N36161939: PQ122.1 PR152.2
N40373298: CD67.2 RD17.1
N40373501: CD20.2 RD3.1
N40376778: CD46.2 RD9.1
N40928090: PQ108.1 PR115.2
N43237751: PQ111.1 PR125.1
N43238317: PQ111.2 PR131.2
N43294004: PQ126.1 PR165.1
N43294007: PQ126.2 PR170.2
N46621397: PC906.1 PR933.2
N46621964: PC908.1 PR940.2
N46635193: PC914.1 PR945.2
N49105313: PQ110.3 PR126.2 PR128.2
N49107876: PQ124.3 PR166.2 PR169.2
N49135368: PQ104.5 PR111.1 PR117.2
N49135372: PQ104.6 PR102.2 PR106.1 PR111.2
N49135382: PQ114.2 PQ114.3 PR139.2
N49135384: PQ106.4 PQ114.6 PR137.2 PR143.2
N49135442: PQ104.3 PR114.1
N49135489: PQ114.5 PR141.2 PR143.1
N49135666: PQ113.2 PQ113.3 PR138.2
N49135672: PQ113.5 PR140.2 PR142.1
N49135678: PQ112.1 PQ113.6 PR136.2 PR142.2
N49135704: PQ112.6 PR129.1
N49135720: PQ112.2 PR134.2
N49135818: PQ106.3 PR130.1
N49135824: PQ104.2 PR109.2
N49135828: PQ106.2 PR117.1
N49135838: PQ106.5 PR135.2
N52199990: PC412.1 PR402.2
N52199996: PC425.1 PR410.2
N52200555: PC413.2 PR409.2
N52348207: PC400.2 PR401.2
N52995153: PQ700.1 PR702.2 PU700.3
N52995185: PR703.2 PU700.2
N52995203: PQ700.2 PR704.2 PR706.1
N53169467: PC700.2 PR701.2 PU700.7
N53310942: RB21.2 RB40.2
N53311038: CB18.1 DB5.1 QB5.2 RB23.1 RB24.1 RB25.1
N53311178: QB6.6 RB22.2
N56822254: CT182.1 UT1.H7
N56822270: RT113.1 UT1.G2
N56822627: TC1.1(TP-1) UT1.G4
N56822629: TC2.1(TP-1) UT1.F4
N56856077: RT55.1 UT1.F1
N56913159: JNGFF2.69 RN26.2 RN28.2
N56955777: CK12.1 RK10.1
N56956040: RK10.2 UK1.21
N57579497: JNGFF1.38 RN114.1
N57661434: CA1.1 CA4.1 CA6.1 RA2.2 RA4.1 RA7.2 RA8.1
N57663406: CA7.1 UA1.32
N57663450: CA13.1 UA1.38
N57663469: CA15.2 RA12.2 UA1.39
N58709056: QE10.1 RE172.2 RE477.2
N58709139: CE30.1 RE180.2
N58727680: JESPI1.8 RE98.1 RE99.1
N59164860: QE4.3 RE198.1 RE199.2
N60395557: QE11.1 RE213.2
N61623149: C50.1 U6.12
N61623319: C51.1 U6.10
N61986536: LN11.2 UN3.3
N61986579: LN10.2 UN3.6
N61986581: LN9.2 UN3.5
N62005758: RS5.2 RS10.1 U16.B2
N63010433: R209.2 R210.1 U17.4
N63010478: R208.2 U17.3
N63223478: CZ28.1 RZ32.1
N63306822: C60.1 U19.6
N63708406: CS1.2 RS2.1
N63957445: RA10.1 RA123.1 UA1.33
N64482855: T1.1(TP-1) UCPU1.AG7
N64482857: T2.1(TP-1) UCPU1.AG6
N64522458: T3.1(TP-1) UCPU1.W37
N64522460: T4.1(TP-1) UCPU1.W31
N64536849: T5.1(TP-1) UCPU1.Y29
N64536851: T6.1(TP-1) UCPU1.AE34
N64536853: T7.1(TP-1) UCPU1.BU31
N64602818: QC3.2 RC539.1
N64745820: RC435.2 UCPU1.AH26
N64745822: RC434.2 UCPU1.AJ27
N64745824: RC434.1 RC436.2
N64746013: T16.1(TP-1) UCPU1.F37
N64746015: T17.1(TP-1) UCPU1.F34
N64746017: T18.1(TP-1) UCPU1.CP36
N64746019: T19.1(TP-1) UCPU1.CN36
N64746021: T20.1(TP-1) UCPU1.BK34
N64746023: T21.1(TP-1) UCPU1.BR18
N64746045: T27.1(TP-1) UCPU1.A34
N64746047: T28.1(TP-1) UCPU1.B35
N64746049: RC420.1 UCPU1.C34
N64746051: T24.1(TP-1) UCPU1.BP34
N64746053: T26.1(TP-1) UCPU1.BP35
N64747389: RC119.2 SW3.1
N64796589: C73.1 U12.10
N64796626: C71.1 U12.12
N65319885: RI143.2 UI4.7 UI4.8
N65324745: RI144.2 UI5.7 UI5.8
N65324759: RI67.1 UI5.16
N65514253: RI55.1 UI4.16
N65905221: QN4.1 QN4.4
N67238504: T138.1(TP-1) UCPU1.CR36
N67241110: T139.1(TP-1) UCPU1.CR34
N67242383: T140.1(TP-1) UCPU1.CP1
N67243636: T141.1(TP-1) UCPU1.CN1
N67244875: T142.1(TP-1) UCPU1.A36
N67247327: T143.1(TP-1) UCPU1.A32
N67247377: T144.1(TP-1) UCPU1.D1
N67250001: T145.1(TP-1) UCPU1.C1
N67278610: QN5.1 QN5.4
N67571971: RT129.1 UT5.E11
N67571980: CT194.1 UT5.H7
N67571982: RT139.1 UT5.G2
N67572033: TC6.1(TP-1) UT5.G4
N67572034: TC7.1(TP-1) UT5.F4
N67572050: RT61.1 UT5.F1
N67601552: QV11.2 QV11.3 RV80.2
N67681387: QB6.3 RB35.1
N67847342: RT289.2 RT294.2 UT15.1
N67847355: RT290.2 UT15.3
N67960376: R281.2 R282.2 U5.2
N67960444: R273.2 U5.1
N68666777: QM3.2 RM107.2
N68671545: DV2.1 RV83.1
N68671579: DV3.1 RV84.1
N68771268: RV54.2 UV5.2
N68776898: QN11.2 U33.4
N68781752: C59.1 U8.6
N68785059: C27.1 U15.6
N68785597: C30.1 UC17.6
N68787020: DN7.2 QN2.3 RN71.1 RN106.2
N68787104: C37.1 U4.12
N68787277: C38.1 U4.10
N68787388: QN6.1 RN109.1 RN111.2
N68788728: CA144.1 UA8.12
N68788738: CA145.1 UA8.10
N68793308: C93.1 QV12.2 R258.2
N69252412: CV50.1 UV6.5
N69266710: CV51.1 UV6.11
N69266720: RV89.1 UV6.6
N69961719: RT285.2 UT14.1
N69961744: RT284.2 UT14.2
N70275813: CA155.1 UA7.6
N70634990: RV90.1 UV1.5
N70635655: RV91.1 UV1.4
N70788772: DV1.1 RV92.1
N70846965: RR20.1 UR2.4
N70846994: RR19.1 UR2.5
N71314969: QZ20.1 RZ1412.1
N71426147: QV6.2 RV46.1
N71426226: QV4.2 RV39.1
N71426333: QV4.1 RV41.2
N71426344: QV6.1 RV47.2
N71525133: QE5.2 RE198.2
N71576104: CN60.2 RN117.1
N71576192: RN117.2 UN3.10
N71690509: CT205.1 QT3.2 RT302.2
N71690515: QT3.5 QT4.2 RT300.1 RT303.1
N71690517: QT3.6 RT303.2
N71690519: CT204.1 QT2.2 RT298.1 RT299.1
N71690560: QT3.3 RT299.2
N71690933: CT206.1 QT1.1 RT296.2 RT297.1 UT16.4
N71697328: QN10.2 RN118.2
N72527102: T151.1(TP-1) UCPU1.CR35
N122282431: RR11.1 UR1.28

Pads without a net: FD1 1; FD2 1; FD3 1; FD4 1; JAPS1 16 17 18; JCAM1 17 18; JCR1 16; JEDP1 3; JFP1 7 8 10 12 14; JHDMI1 14; JKB1 27 28; JLTE1 12 13; JLTE2 12 13; JNGFF1 10 28 40 42 44 46 48 65; JNGFF2 6 10 20 22 24 26 28 30 32 34 36 40 42 44 46 48 56 58 67; JNGFF3 6 8 12 16 20 58 60 62 66 68 70; JSIM1 1 C4 C6 C8; JTP1 2; PQ112 3 4 5; PU101 5; PU102 5; PU200 13; PU400 4; PU401 4; PU800 10 12; PU900 2 3 40 41; PU1500 5; PU1501 5; QN12 3 4; RC85 1; RC435 1; RC632 1; RE531 2; RN114 2; RT105 2; RT122 2; RT268 2; RT269 2; RT271 2; RT272 2; RT274 2; RT275 2; U7 1; UA1 1 6 7 8 9 10 11 12 13; UC9 1; UCPU1 A35 AA24 AA26 AA35 AB25 AC24 AC25 AC26 AC35 AD24 AD26 AE35 AF31 AG37 AJ1 AJ2 AJ3 AJ4 AL1 AL2 AL3 AL4 AL34 AM3 AM4 AM7 AN1 AN2 AN3 AN4 AR3 AT3 AU3 BC28 BH3 BH4 BJ34 BJ36 BK35 BK36 BL34 BL36 BL37 BP8 BP9 BT8 BT9 BU34 BV24 BV25 BV29 BV30 BV34 BW3 BW4 BW8 BW9 BY30 BY32 CA31 CA32 CC35 CE27 CF17 CF20 CF22 CF27 CF29 CG1 CG2 CG5 CG6 CG14 CG22 CH12 CH25 CH27 CH28 CH32 CH36 CJ27 CJ29 CJ30 CJ31 CK17 CL35 CM10 CM14 CM16 CM18 CM22 CM27 CM28 CN4 CN7 CN8 CN12 CN14 CN16 CN20 CN22 CN28 CP3 CP4 CP6 CP7 CP8 CP16 CP18 CP28 CR3 CR4 CR8 CR16 CR18 CR22 CR24 CR26 CR28 D34 D37 G1 G2 G3 G4 H3 H4 K12 K14 K15 K17 K18 K20 L25 M24 M26 P24 P26 R24 R25 R26 T25 V24 V25 W3 W25 Y3 Y24 Y25; UD1 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; UD2 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; UD3 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; UD4 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; UE1 A11 B10; UE4 1; UI4 9 15; UI5 9 15; UK1 30 31 35 36 38 43 44 45 46; UR1 31; UT1 A9 B9 L11; UT2 A23 AB23 AC23 B23 D19 D20 E18 E19 E20 V18 W19 Y19; UT5 A9 B9 L11; UT16 3; UV5 11; UV6 3 4 9; UZ6 3 4 5 7 10 11 12 13 15 25 26 27 28 30 31

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 673 vias
v2: diameter 0.254, hole 0.102, TOP to IN1, 2768 vias
v3: diameter 0.406, hole 0.203, TOP to BOTTOM, 169 vias
v4: diameter 0.406, hole 0.203, IN1 to IN3, 3352 vias
v5: diameter 0.254, hole 0.102, IN3 to BOTTOM, 3614 vias
v6: diameter 0.457, hole 0.203, TOP to BOTTOM, 2399 vias
v7: diameter 0.508, hole 0.254, TOP to BOTTOM, 56 vias
v8: diameter 0.254, hole 0.102, GND1 to IN1, 324 vias
v9: diameter 0.254, hole 0.102, TOP to GND1, 738 vias
v10: diameter 0.254, hole 0.102, IN3 to GND4, 37 vias
v11: diameter 0.254, hole 0.102, GND4 to BOTTOM, 1267 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.0VA_PG: length 2.8
  BOTTOM w0.127: PU800.9 121.42,50.92 RE507.2 122.22,50.82 v1(122.44,50.6)
1.2V_DDR_EN: length 120.4
  TOP w0.127: v2(117.03,14.64) 117.03,15.32 117.75,16.04 117.75,17.47 v1(117.81,17.53) 117.81,18.66 116.93,19.54 116.93,22.62 116.12,23.43 116.12,30.6 118.02,32.51 121.31,32.51 122.32,33.51 123.04,33.51 v2(124.07,34.54)
  IN1 w0.061: v2(117.03,14.64) 117.82,13.85 117.82,13.12 114.61,9.92 54.33,9.92 52.21,12.05 52.21,15.66 51.85,16.02 51.85,16.58 52.49,17.21 52.49,21.81 52.1,22.2 52.1,26.03 v6(51.39,26.74) ; v2(124.07,34.54) 123.83,34.78 122.07,34.78 v4(121.65,35.2)
  IN3 w0.061: v5(122.01,35.36) 121.84,35.2 v4(121.65,35.2)
  BOTTOM w0.127: DC7.2 123.79,34.64 122.77,35.65 122.15,35.65 122.01,35.52 v5(122.01,35.36) 122.01,34.65 CC257.1 RC612.2 ; v6(51.39,26.74) 51.27,26.62 PU600.1
1.8V_PRIM_PG: length 1.7
  BOTTOM w0.127: RE165.2 113.64,20.44 PR503.1 113.64,21.72 113.71,21.79 PU500.5
3.3V_CAM_EN#: length 123.4
  TOP w0.127: RC611.1 102.82,27.13 102.32,27.63 RC616.1 v2(101.84,27.63)
  IN1 w0.061: v4(102.78,32.75) 101.94,31.91 101.94,30.5 102.6,29.84 102.6,28.5 101.84,27.74 v2(101.84,27.63)
  IN2 w0.061: v4(52.78,38.13) 52.78,36.32 54.9,34.2 54.9,30.7 55.65,29.95 56.52,29.95 57.4,29.06 59.63,29.06 59.99,29.41 65.55,29.41 65.85,29.11 66.91,29.11 67.27,29.48 73.66,29.48 74.14,28.99 93.81,28.99 95.12,27.68 95.12,22.38 95.61,21.89 95.61,20.59 95.76,20.44 99.93,20.44 100.75,21.25 102.11,21.25 102.96,22.1 104.73,22.1 105.65,23.02 v4(105.88,23.02)
  IN3 w0.061: v4(52.78,38.13) 52.56,38.13 52.07,38.61 51.48,38.61 49.61,40.48 49.61,55 51.22,56.62 55.14,56.62 55.47,56.95 v5(58.03,56.95) ; v4(105.88,23.02) 105.88,23.38 106.33,23.83 106.33,24.94 105.36,25.9 104.01,25.9 102.6,27.31 102.6,28.52 102.78,28.7 102.78,28.87 102.91,29.01 102.91,29.74 102.99,29.82 102.99,30.75 103.46,31.22 103.46,31.56 102.78,32.24 v4(102.78,32.75) v5(103.13,32.75)
  BOTTOM w0.127: v5(58.03,56.95) v1(58.86,56.95) 60.7,56.95 61.23,57.47 61.23,58.81 60.95,59.08 QV1.2
3.3V_TS_EN: length 353.9
  TOP w0.102: UE1.J7 267.43,54.81 v2(267.39,54.81)
  TOP w0.127: v2(41.1,71.27) 41.1,70.77 41.57,70.29 43.11,70.29 43.32,70.08 43.32,69.65 43.76,69.21 45.36,69.21 45.88,68.69 45.88,68.34 46.25,67.98 47.22,67.98 v1(47.47,68.22) 47.99,68.75 R222.1
  IN1 w0.061: v4(41.28,70.97) 41.28,71.09 v2(41.1,71.27) ; v2(267.39,54.81) 267.21,54.81 v4(267.05,54.97)
  IN2 w0.061: v4(267.05,54.97) 267.57,55.49 269.49,55.49 269.84,55.15 269.84,54.4 269.95,54.29 271.35,54.29 272.03,53.6 272.03,47.28 268.62,43.87 267.39,43.87 266.3,42.78 264.33,42.78 262.4,40.85 257.21,40.85 255.41,39.05 238.06,39.05 217.36,18.36 212.33,18.36 212.01,18.04 202.71,18.04 201.11,16.44 182.84,16.44 179.3,12.89 152.55,12.89 152.3,13.15 133.7,13.15 133.09,13.76 133.09,15.96 131.53,17.52 128.48,17.52 126.7,18.25 123.61,18.25 123.14,17.77 114.11,17.77 109.55,13.21 103.79,13.21 103.48,13.51 101.23,13.51 101.02,13.31 97.34,13.31 96.88,12.85 57.89,12.85 56.82,13.93 53.74,13.93 53.59,13.78 52.97,13.78 52.48,13.28 48.55,13.28 48.29,13.55 44.21,13.55 44.05,13.39 42.48,13.39 39.99,15.88 27.61,15.88 24.02,19.47 24.02,22.44 24.39,22.81 24.49,22.81 25.06,22.81 25.17,22.81 27.8,25.45 27.8,29.77 28.1,30.06 28.1,35.59 28.49,35.98 28.49,36.61 30.17,38.29 30.17,39.54 32.18,41.55 32.18,43.39 34.32,45.54 34.32,48.58 35.16,49.42 35.16,53.52 35.43,53.78 35.43,54.38 36.28,55.23 36.28,62.73 36.55,63.01 36.55,63.32 38.69,65.46 38.69,68.38 v4(41.28,70.97)
3.3V_TS_EN_R: length 3.6
  TOP w0.127: v1(49.97,69.78) R145.1 R223.2 R222.2 48,69.79 48,70.68 48,70.68 48.05,70.73 UC17.3
3.3V_WWAN_EN: length 37.7
  TOP w0.102: UE1.C6 266.86,59.38 v2(267.04,59.38)
  TOP w0.127: U4.3 255.52,42.06 R266.1 255.32,42.08 255.12,42.28 255.12,42.98 256.89,44.76 v1(256.89,46.74) 256.89,46.93 v2(256.59,47.24)
  IN1 w0.061: v2(267.04,59.38) 267.19,59.23 267.41,59.23 267.7,58.94 267.7,57.09 267.3,56.69 267.3,55.68 267.54,55.44 268.12,55.44 268.5,55.06 268.5,54.7 268.93,54.27 269.92,54.27 270.74,53.45 270.74,52.28 271.62,51.4 271.62,51.04 269.72,49.14 269.72,47.98 269.1,47.36 267,47.36 266.71,47.65 264.94,47.65 264,46.71 261.45,46.71 260.97,47.19 256.63,47.19 v2(256.59,47.24)
3V_5V_ALWON: length 375
  TOP w0.102: RE469.2 CE50.1
  TOP w0.127: v2(284.35,65.95) 288.16,65.95 289.79,64.32 291.27,64.32 295.7,59.88 PR412.1 ; v6(227.88,51.82) v1(228.66,51.82)
  IN1 w0.061: v4(54.62,10.32) 54.43,10.32 52.54,12.21 52.54,16.13 v4(52.2,16.46) ; v4(252.22,63.6) 255,63.6 258.09,66.69 263.87,66.69 264.94,65.98 265.51,65.8 266.09,65.62 v2(267.18,64.53) 267.18,63.16 268.86,61.48 271.1,61.48 271.97,62.35 273.29,62.35 276.89,65.95 v2(284.35,65.95)
  IN2 w0.061: v4(54.62,10.32) 55.03,9.91 119.55,9.91 121.26,11.62 121.26,13.55 124.44,16.72 126.75,16.72 128.71,15.92 130.29,14.35 130.29,12.79 130.69,12.39 131.28,12.39 132.16,11.51 151.61,11.51 151.87,11.25 184.58,11.25 185.88,12.55 186.57,12.55 201.58,12.55 203.63,14.59 216.45,14.59 227.58,25.72 v6(228.54,25.72) ; v4(252.22,63.6) 248.42,59.8 235.86,59.8 v6(227.88,51.82) 227.39,51.33 222.68,51.33 213.52,42.17 207.54,42.17 205.44,40.07 v6(205.44,39.35)
  IN3 w0.061: v5(41.24,44.16) 40.66,43.59 40.66,42.57 42.86,40.37 43.87,40.37 44.49,39.74 44.49,38.41 43.39,37.31 43.39,36.92 43.59,36.72 46.26,36.72 48.44,34.54 48.44,34.19 50.08,32.55 51.96,32.55 52.39,32.12 52.39,30.46 52.22,30.3 52.22,28.28 52.39,28.11 52.39,16.65 v4(52.2,16.46)
  BOTTOM w0.127: PR306.1 204.45,40.34 v6(205.44,39.35) ; v5(41.24,44.16) 41.54,44.46 42.41,44.46 42.71,44.16 PR404.1 ; v6(228.54,25.72) 228.54,38.06 226.47,40.13 226.47,45.28 227.02,45.84 227.02,50.97 v6(227.88,51.82)
3V_BST: length 3.6
  BOTTOM w0.127: v1(201.43,44.79) 201.43,45.4 PR300.1
  BOTTOM w0.305: PU300.1 200.48,44.51 200.8,44.82 PR300.1
3V_CS: length 2.6
  TOP w0.127: v6(200.83,43.95) 200.83,44.03 v1(201.37,44.57)
  TOP w0.254: PR308.1 200.37,43.63 200.69,43.95 v6(200.83,43.95)
  BOTTOM w0.203: v6(200.83,43.95) 200.48,43.61 PU300.3
3V_EN: length 6.3
  BOTTOM w0.127: v1(205.46,40.84) 203.64,40.84 203.22,40.42 PR306.2 202.92,40.34 202.6,40.66 201.14,40.66 200.89,40.91 200.89,41.22 200.5,41.61 PU300.8
3V_FB: length 4.6
  BOTTOM w0.127: v1(204.18,41.55) 203.34,41.55 PC310.1
  BOTTOM w0.203: PU300.7 200.53,42.01 201.32,41.22 PR304.1 PR302.2 PC310.1
3V_LX: length 0.9
  TOP w0.127: v6(197.81,46.68) v1(198.7,46.68)
3V_MODE: length 3
  TOP w0.127: v1(202.79,43.94) 202.43,43.57 PR307.1
  TOP w0.254: PR307.1 201.08,43.57 v6(200.81,43.3)
  BOTTOM w0.203: PU300.4 200.72,43.21 v6(200.81,43.3)
3V_TRK: length 2.8
  TOP w0.127: v6(200.82,42.69) v1(200.82,41.57)
  TOP w0.254: PC309.1 200.28,42.98 200.57,42.69 v6(200.82,42.69)
  BOTTOM w0.203: PU300.5 200.71,42.81 v6(200.82,42.69)
3V_VCC: length 19.3
  TOP w0.254: v6(205,38.88) 204.91,38.97 204.91,39.82 205.45,40.35 v1(205.45,42.92) 205.45,44.47 204.76,45.15 198.32,45.15 v6(196.8,46.68)
  BOTTOM w0.254: v6(205,38.88) 204.84,38.88 PR310.2 ; v6(196.8,46.68) 197.01,46.46 197.01,46.04 PC313.1 196.82,45.85 196.82,44.68 197,44.51 PU300.19
3V_VIN: length 0.8
  TOP w0.127: v6(198.35,40.77) v1(198.35,41.55)
3VALW_PG: length 5
  BOTTOM w0.127: PU300.9 200.31,41.11 201.01,40.4 202.39,40.4 203.22,39.58 PR310.1 203.22,38.98 v1(203.69,38.51)
5VALW_BST: length 2.6
  TOP w0.127: v6(40.37,41.52) v1(40.37,40.68)
  TOP w0.508: PR401.1 40.24,41.66 v6(40.37,41.52)
  BOTTOM w0.254: v6(40.37,41.52) 40.41,41.52 40.66,41.27 PU400.8
5VALW_EN: length 2
  BOTTOM w0.254: PU400.11 41.97,43.1 PR413.1 PR404.2
5VALW_ENLDO: length 2.8
  BOTTOM w0.254: PR400.2 43.52,43 43.09,42.56 42.72,42.56 42.47,42.31 PU400.12
5VALW_LP: length 2
  TOP w0.127: v2(40.75,38.56) v1(40.75,37.61)
  IN1 w0.508: v4(40.41,38.81) 40.66,38.56 v2(40.75,38.56)
  IN3 w0.508: v5(40.97,38.81) v4(40.41,38.81)
5VALW_LX: length 1.9
  TOP w0.127: PR402.1 v1(38.01,37.73)
  vias: v6(38.9,39.78) v6(38.92,39.11)
5VALW_PG: length 2.9
  TOP w0.127: v2(42.99,39.26) 42.73,39.52 PR403.1 42.46,39.52 41.78,38.84 RE511.1
  IN1 w0.061: v4(42.63,39.33) 42.92,39.33 v2(42.99,39.26)
  IN3 w0.061: v4(42.63,39.33) 42.78,39.19 v5(42.78,39.01)
  BOTTOM w0.127: PU400.3 42.47,38.88 42.6,39.01 v5(42.78,39.01)
5VALW_VCC: length 8.1
  TOP w0.254: PR403.2 40.88,40.25 40.88,42.83 40.17,43.54 v2(40.12,43.54)
  IN1 w0.254: v2(40.12,43.54) v4(39.59,43.54)
  IN3 w0.254: v5(39.59,43.13) v4(39.59,43.54)
  BOTTOM w0.254: PU400.9 40.97,42.33 40.17,43.13 PC411.1 39.82,43.36 v5(39.59,43.13)
5VALW_VIN:
  vias: v1(47.78,41.97)
5VALWB_BST: length 3.9
  TOP w0.127: v1(296.62,62.25) 297.06,62.69 PR409.1
  TOP w0.254: PR409.1 298.04,61.46 v6(297.89,61.31)
  BOTTOM w0.254: v6(297.89,61.31) 297.49,60.9 PU401.8
5VALWB_EN: length 2.5
  TOP w0.127: PR412.2 298.56,60.92 v3(298.44,61.04)
  IN1 w0.061: v2(298.46,60.01) 298.54,59.93 v4(298.54,59.65) 298.56,59.63 v2(298.56,59.07)
  IN3 w0.061: v5(298.54,59.3) 298.54,59.65 v4(298.54,59.65)
5VALWB_ENLDO: length 1.7
  BOTTOM w0.254: PU401.12 298.95,58.8 299.46,58.29 PR408.2
5VALWB_LP: length 1.5
  BOTTOM w0.254: PU401.6 294.01,60.3 PC418.2
5VALWB_LX:
  vias: v1(299.67,65.79) v6(299.5,66.38)
5VALWB_PG: length 3.6
  BOTTOM w0.127: PR411.1 294.05,58.54 RE512.1 293.64,57.87 v1(292.88,57.11)
  BOTTOM w0.254: PU401.3 294.08,58.8 PR411.1
5VALWB_VCC: length 10.5
  IN3 w0.254: v5(293.14,58.82) 293.27,58.95 294.55,58.95 297.6,61.99 299.69,61.99 v5(300.1,61.59)
  BOTTOM w0.254: PU401.9 299.83,61.59 v5(300.1,61.59)
5VALWB_VIN:
  vias: v1(298.51,53.7)
+0.6VS: length 92.5
  TOP w0.381: RD32.2 v2(86.48,14.84) RD34.2 RD38.2 RD40.2 84.8,14.62 84.42,14.24 83.29,14.24 83.02,14.51 83.02,15.16 82.71,15.46 CD112.1 77.96,15.46 CD109.1 ; RD74.2 94.42,15.32 94.42,14.57 CD108.1 CD106.1 93.49,14.53 RD22.2 RD24.2 RD28.2 RD26.2 RD30.2 RD66.2 RD68.2 RD78.2 v2(88.71,14.84) ; v2(64.51,14.84) RD79.2 RD81.2 RD69.2 RD71.2 RD49.2 v2(67.86,14.84) RD47.2 RD43.2 RD41.2 70.02,14.84 CD103.1 CD100.1 71.07,14.43 72.86,14.43 v3(72.92,14.5) 73.42,14.5 74.38,15.46 CD113.1 75.49,15.45 CD104.1 ; RD63.2 RD51.2 RD55.2 RD53.2 RD57.2 RD59.2 ; v2(65.94,28.22) 66.31,28.58 66.31,28.88 RD73.2
  TOP w0.508: CD109.1 CD104.1
  IN1 w0.381: v2(65.94,28.22) v4(65.94,27.81) ; v2(63.44,14.84) v4(63.04,14.84) ; v2(64.51,14.84) v4(64.99,14.84) ; v4(86.88,14.83) 86.87,14.84 v2(86.48,14.84) ; v4(89.11,14.84) v2(88.71,14.84) ; v2(67.86,14.84) v4(68.37,14.84)
  IN2 w0.381: v4(65.94,27.81) 65.41,27.28 v6(54.73,27.28)
  IN3 w0.381: v4(86.88,14.83) 86.89,14.84 v5(87.24,14.84) ; v5(62.59,14.84) 62.59,14.84 v4(63.04,14.84) 63.1,14.9 64.93,14.9 v4(64.99,14.84) v5(65.42,14.84) ; v5(67.93,14.84) v4(68.37,14.84) ; v5(89.48,14.84) v4(89.11,14.84)
  BOTTOM w0.127: v5(62.59,14.84) 62.59,14.84
  BOTTOM w0.381: CD107.1 RD60.2 RD58.2 RD54.2 RD56.2 RD52.2 v5(90.67,14.84) ; RD39.2 RD37.2 RD33.2 v5(67.93,14.84) RD31.2 ; CD102.1 81.44,22.03 80.94,21.53 80.94,19.35 81.44,18.85 CD101.1 82.11,18.85 82.59,18.37 82.59,16.49 84.23,14.84 RD42.2 RD48.2 RD44.2 RD50.2 RD46.2 v5(87.24,14.84) RD70.2 RD72.2 RD82.2 v5(89.48,14.84) ; v5(65.42,14.84) RD75.2 RD65.2 RD67.2 RD29.2 RD25.2 RD27.2 RD23.2 RD21.2 CD105.1 60.13,14.84 59.7,15.27 59.7,16.44 59,17.14 58.86,17.14 57.7,18.31 56.81,18.31 56.39,18.72 56.39,23.64 55.52,24.51 55.52,25.81 55.24,26.08
  vias: v6(54.72,26.72) v6(54.73,26.14)
+0.6VSP: length 1.4
  BOTTOM w0.127: 52.69,27.3 52.69,28.31 v1(53,28.62)
+1.0V_AMPHYPLL: length 4.9
  TOP w0.127: v2(98.93,59.34) v3(98.22,59.34)
  IN1 w0.061: v2(98.93,59.34) v4(98.93,58.98)
  IN3 w0.061: v5(99.67,58.45) 99.35,58.45 98.93,58.87 v4(98.93,58.98)
  BOTTOM w0.127: v5(99.67,58.45) CC102.1 99.67,58.69
  BOTTOM w0.254: CC80.1 99.68,57.45 99.68,56.99 99.88,56.79 99.88,55.85 UCPU1.BV2
+1.0V_CLK: length 2.8
  TOP w0.127: v3(113.4,53.68) v6(111.49,53.68) 111.49,53.37 CC262.1
+1.0V_PRIM_CORE: length 7.2
  TOP w0.127: v6(118.28,47.35) v3(117.51,47.35)
  IN1 w0.254: v2(100.38,44.93) 100.03,45.19 v4(99.99,45.19)
  IN3 w0.254: v5(99.76,42.44) v4(99.99,42.67) ; v5(102.36,48.32) v4(102.59,48.55) ; v5(99.11,42.44) v4(99.32,42.7) ; v5(99.76,43.28) v4(99.99,43.51) ; v5(101.71,44.96) v4(101.94,45.19) ; v5(101.71,48.32) v4(101.94,48.55) ; v5(99.76,46.64) v4(99.99,46.87) ; v5(99.76,44.12) v4(99.99,44.35) ; v5(100.41,42.44) v4(100.64,42.67) ; v5(99.76,45.8) v4(99.99,46.03) ; v5(99.76,44.96) v4(99.99,45.19) ; v5(101.71,45.8) v4(101.94,46.03) ; v5(101.71,44.12) v4(101.94,44.35) ; v5(102.36,46.64) v4(102.59,46.87) ; v5(102.36,47.48) v4(102.59,47.71) ; v5(99.11,46.64) v4(99.34,46.87) ; v5(101.71,43.28) v4(101.94,43.51) ; v5(100.41,43.28) v4(100.64,43.51)
  vias: v6(118.28,46.77) v6(118.28,46.21) v6(118.27,45.62) v6(118.77,47.05) v6(118.77,46.49) v6(118.76,45.9) v6(118.76,45.33)
+1.0V_PRIM_COREP: length 14.6
  TOP w0.254: v6(127.47,51.66) 126.55,51.66 v1(124.2,49.3) 121.85,49.3 121.49,48.94 121.49,45.94 v2(121.66,45.76)
  IN1 w0.254: v4(121.96,45.51) 121.92,45.51 v2(121.66,45.76)
  IN3 w0.254: v5(123.05,43.99) 122.82,44.21 121.63,44.21 121.51,44.33 121.51,45.07 v4(121.96,45.51)
  BOTTOM w0.254: PR1418.2 127.9,51.39 127.64,51.66 v6(127.47,51.66)
+1.0V_VCCPLL:
  vias: v2(98.48,49.12) v4(98.04,49.39) v4(98.69,49.39) v5(97.81,49.16) v5(98.46,49.16)
+1.0V_VCCST: length 333.4
  TOP w0.254: PR914.1 44.97,52.52 44.79,52.34 44.79,51.35 45.8,50.34 47.15,50.34 47.52,50.71 48.38,50.71 PC903.1 48.62,51.57 PR913.1 ; PR915.1 48.37,52.21 PR913.1 ; PR913.1 49.6,52.21 49.84,51.97 50.4,51.97 v2(51.86,53.43)
  TOP w0.381: v2(192.77,31.82) 191.5,30.55 v3(191.5,29.67) 191.5,26.84 186.47,21.81 182,21.81 178.61,18.41 153.73,18.41 149.6,19.6 141.11,22.23 141.01,22.33 133.14,30.19 133.14,32.13 131.72,33.54 v2(131.72,35.43)
  TOP w0.508: PR912.1 45.31,53.16 45.31,53 PR914.1
  TOP w0.635: 104.62,63.99 102.04,63.99 101.6,63.54 101.6,61.69 101.04,61.13 v2(98,61.13) 96.34,61.13 93.85,58.64 v2(93.85,53.09) ; 105.73,63.86 106.65,62.94 120.77,62.94 v2(121.02,63.19)
  IN1 w0.254: v2(192.77,31.82) 193.29,31.82 194.48,33.02 194.93,33.02 204.14,42.22 204.14,45.1 205.88,46.85 211.97,46.85 212.81,46.01 223.63,46.01 225.65,48.02 235.55,48.02 236.03,48.51 240.09,48.51 240.53,48.07 249.13,48.07 249.98,47.22 255.87,47.22 256.33,46.76 260.92,46.76 261.86,45.81 263.08,45.81 263.42,46.16 266.66,46.16 267.52,47.02 269.25,47.02 270.08,47.85 270.08,49.01 270.74,49.68 271.17,49.68 272.87,51.38 272.87,52.75 274.5,54.37 275.94,54.37 276.22,54.65 v2(276.22,54.98) ; v2(98,61.13) 98.6,60.53 98.6,59.45 97.92,58.76 v6(97.92,57.83) ; v4(52.26,53.46) 51.89,53.46 v2(51.86,53.43) ; v4(97.4,49.43) 96.79,49.43 96,50.22 96,50.54 95.41,51.12 95.05,51.12 94.96,51.03 94.64,51.03 94.44,51.24 94.44,51.52 94.45,51.53 94.45,51.83 93.85,52.43 v2(93.85,53.09)
  IN1 w0.508: v4(131.66,36.28) 131.66,36.11 131.72,36.05 v2(131.72,35.43) ; v2(121.02,63.19) 121.02,62.87 v4(120.8,62.65)
  IN2 w0.254: v4(52.26,53.46) 52.22,53.5 52.22,54.95 50.35,56.82 50.35,59.74 51.03,60.43 52.66,60.43 53.07,60.01 53.07,58.41 53.69,57.79 61.21,57.79 62.59,59.17 74.39,59.17 74.76,59.54 77.32,59.54 v6(77.62,59.84)
  IN2 w0.635: v4(131.66,36.28) 131.66,38.25 127.66,42.25 126.12,42.25 123.67,44.7 121.58,44.7 121.02,45.26 121.02,48.22 119.98,49.26 119.98,49.81 119.54,50.25 119.1,50.25 118.49,50.86 118.49,60.34 v4(120.8,62.65)
  IN3 w0.254: v6(77.62,59.84) 77.62,59.6 78.2,59.01 79.6,59.01 v5(79.97,59.39)
  BOTTOM w0.203: CC202.1 97.05,57.28 97.05,56.03 97.14,55.94 UCPU1.BP2
  BOTTOM w0.254: v5(79.97,59.39) 80.12,59.53 82.9,59.53 84.44,61.08 93.86,61.08 94.32,60.61 RC79.1
  BOTTOM w0.356: RC219.1 RC154.1 RC156.1 RC158.1 78.14,59.32 v6(77.62,59.84)
  vias: v2(98.2,50.3) v2(98.49,50.3) v5(97.16,49.16)
+1.0V_VCCSTG: length 62.3
  TOP w0.127: v2(78.12,40.53) 77.53,41.12 v3(77.53,41.33) ; 75.7,51.17 75.7,51.63 76.14,52.06 76.62,52.06 76.97,52.42 76.97,53.38 76.72,53.64 75.88,53.64 75.67,53.42 v2(75.67,53.23)
  TOP w0.254: 75.7,51.17 75.58,51.04 75.58,49.48 v2(75.71,49.34) ; v2(78.12,40.53) 78.12,40.39 RC436.1
  IN1 w0.254: v2(75.71,49.34) 75.71,49.31 75.94,49.08 v4(75.94,49.05) ; v2(75.67,53.23) v4(75.67,52.84) ; v2(78.12,40.53) v4(77.58,40.53)
  IN2 w0.254: v4(78.2,59.84) 78.2,59.55 78.01,59.36 77.46,59.14 76.21,59.14 75.35,58.27 75.35,56.83 74.81,56.29 74.81,54.15 74.98,53.98 74.98,53.37 75.21,53.14 75.36,53.14 v4(75.67,52.84) ; v4(77.58,40.53) 76.75,41.37 76.75,48.35 76.05,49.05 v4(75.94,49.05)
  IN3 w0.254: v4(78.2,59.84) 78.2,59.83 78.2,59.53 78.39,59.34 79.24,59.34 79.76,59.86 80.12,59.86 80.54,59.44 v5(80.54,59.16)
  IN3 w0.305: 77.81,61.21 v5(77.87,61.15) 77.94,61.08 77.94,60.2 78.2,59.94 v4(78.2,59.84)
  IN3 w0.381: v5(76.87,62.25) 76.87,62.14 77.81,61.21
  BOTTOM w0.127: RC257.1 70.94,62.67 71.37,62.67 RC252.1 RC239.1 72.87,62.69 74.55,62.69 74.97,62.27 RC240.1
  BOTTOM w0.254: UCPU1.BG2 93.26,55.07 93.26,55.56 92.63,56.19 RC534.1 92.63,58.6 92.43,58.8 CC201.1 91.99,59.05 RC153.2 91.68,59.75 91.19,60.24 84.79,60.24 83.23,58.68 80.9,58.68 80.54,59.04 v5(80.54,59.16)
  BOTTOM w0.305: v5(77.87,61.15) 78.14,61.42 CZ5.1
  BOTTOM w0.381: RC240.1 RC254.1 RC255.1 v5(76.87,62.25) ; CZ5.1 79.16,61.42 R206.2
+1.0V_VCCSTG_CPU: length 6.4
  BOTTOM w0.203: RC153.1 v1(90.28,57.83) 90.28,57.52 92.59,55.21 92.59,54.5 92.91,54.18 UCPU1.BG3
+1.0V_VCCSTG_FUSE: length 3.5
  BOTTOM w0.127: RC534.2 91.71,57.91 92.05,57.57 v1(92.05,57.38) 92.05,56.24 UCPU1.BG1
+1.0V_VCCSTG_R: length 3.7
  BOTTOM w0.102: v1(80.22,58.83) 80.22,58.83 79.95,58.83 79.29,59.49 R206.1
  BOTTOM w0.508: UZ4.6 79.89,60.08 79.71,59.9 R206.1
+1.0VA: length 10
  TOP w0.254: CC67.1 97.31,43.66 CC68.1
  IN1 w0.203: v4(98.08,43.5) 97.96,43.63 v2(97.69,43.63) 97.67,43.61 v4(97.17,43.61)
  IN3 w0.254: v5(100.41,44.96) v4(100.72,45.27) ; v4(98.08,43.5) 97.86,43.28 v5(97.81,43.28) ; v5(97.81,47.48) v4(98.05,47.71) ; v5(101.06,45.8) v4(101.29,46.03) ; v5(98.46,42.44) v4(98.7,42.66) ; v5(99.76,48.32) v4(100.01,48.54) ; v5(100.41,45.8) v4(100.64,46.03) ; v5(97.81,48.32) v4(98.09,48.55) ; v5(99.11,44.96) v4(99.38,45.23) ; v5(99.11,44.12) v4(99.37,44.36) ; v5(101.71,47.48) v4(101.94,47.71) ; v5(103.01,48.32) v4(103.24,48.56) ; v4(100.01,47.72) 99.99,47.72 v5(99.76,47.48) ; v5(97.15,42.43) v4(97.38,42.68) ; v5(98.45,48.3) 98.72,48.56 v4(98.72,48.57) ; v5(98.46,44.96) v4(98.68,45.22) ; v5(101.06,43.28) v4(101.29,43.51) ; v4(97.17,43.61) 97.16,43.61 v5(97.16,43.28) ; v5(101.06,47.48) v4(101.33,47.71) ; v5(101.06,48.32) v4(101.29,48.56) ; v5(100.41,44.12) v4(100.64,44.35) ; v5(97.16,47.48) v4(97.42,47.73) ; v5(97.81,46.64) v4(98.05,46.88) ; v5(98.46,44.12) v4(98.71,44.34)
  vias: v2(99.9,47.36) v2(100.19,47.36) v2(100.66,47.96) v2(100.66,47.66) v2(100.66,47.35) v2(100.94,47.96) v2(100.94,47.66) v2(100.94,47.35) v2(114.53,55.99) v2(114.53,55.68) v2(115.31,55.97) v2(115.31,55.68) v2(115.31,55.35) v2(115.61,55.67) v2(115.61,55.34) v3(100.19,51.64) v4(114.04,56.3) v4(114.48,56.95) v4(114.93,56.95) v4(114.93,56.52) v4(114.93,56.08) v4(114.93,55.64) v5(114.45,56.52) v5(114.45,56.17) v5(115.31,56.57) v5(115.31,56.25) v5(115.31,55.95) v6(113.88,56.85) v6(114.12,57.36)
+1.0VA_XDP: length 56.5
  TOP w0.254: 55.03,64.52 55.03,63.6 54.8,63.37 54.8,62.72 55.18,62.33 55.18,60.08 v2(54.18,59.08)
  TOP w0.305: JXDP1.44 56.68,69.72 56.99,70.03 64.07,70.03 64.94,70.89 64.94,71.33 64.66,71.61 63.66,71.61 63.28,71.23 57.47,71.23 56.98,71.72 JXDP1.43
  TOP w0.381: 55.03,64.52 55.37,64.86 RC125.1
  IN1 w0.254: v2(54.18,59.08) 54.36,58.91 v4(54.59,58.91)
  IN2 w0.254: v4(54.59,58.91) 55.28,59.6 74.13,59.6 75.75,61.22 78.02,61.22 78.77,60.47 v4(78.77,59.75)
  IN3 w0.254: v4(78.77,59.75) 78.75,59.77 78.75,59.87 78.3,60.32 78.3,61.35 77.51,62.15 v5(77.51,62.2)
  BOTTOM w0.254: RC230.1 78.14,62.82 RC251.2
  vias: v3(56.63,65.82)
+1.0VAP: length 12.3
  TOP w0.127: v1(120.59,60.13) 120.26,60.13 v6(120.12,59.99)
  IN1 w0.254: v6(120.12,59.99) 120.12,61.26 v6(122.1,63.24)
  BOTTOM w0.254: PR803.1 117.99,54.46 PC806.1 117.73,55.31 117.46,55.58 117.46,57.6 117.84,57.98 118.93,57.98 120.12,59.16 v6(120.12,59.99)
+1.0VS_VCCIO: length 121.9
  TOP w0.127: v2(60.27,66.46) 60.26,66.46 60.26,66.43 RC521.1 ; v3(83.76,38.65) 83.25,39.16 v2(83.25,39.83) ; 83.2,40.58 CC234.1 ; CC236.1 82.25,40.6
  TOP w0.254: CC54.1 92.99,40.4 v2(92.98,40.39)
  TOP w0.381: QE4.1 v2(104.19,65.7)
  IN1 w0.061: v2(82.22,40.63) 82.22,40.63 v4(82.61,40.63) ; v4(83.52,40.63) 83.16,40.63 v2(83.13,40.65) ; v2(82.37,39.83) v4(82.84,39.57) 83.2,39.8 v2(83.25,39.83)
  IN1 w0.254: v4(83.43,51.07) 83.48,51.12 v2(83.48,51.47) ; v2(94.26,41.23) v4(94.44,40.62) ; v2(60.27,66.46) 61.5,66.05 61.91,65.7 62.18,65.43 62.27,65.35 62.27,65.34 v4(62.58,65.03)
  IN1 w0.381: v4(104.91,62.97) 104.63,63.25 104.63,65.26 v2(104.19,65.7)
  IN2 w0.061: v6(104.64,27.7) 104.64,27.61 104.3,27.27 v4(104.3,27.22)
  IN2 w0.254: v4(75.85,49.81) 76.03,49.99 76.03,51.86 75.17,52.72 74.33,52.72 73.77,53.28 73.77,54.64 73.29,55.12 73.29,56.17 v4(73.48,56.36) 73.48,56.37 73.53,56.41 73.53,56.61 71.39,58.74 63,58.74 62.35,58.09 62.35,56.82 v4(62.36,56.81)
  IN2 w0.381: v4(96.91,45.19) 96.85,45.25 v4(96.85,46.09) 96.85,49.34 96.18,50 96.18,51.18 96.39,51.39 96.39,52.11 96.12,52.38 96.12,56.25 94.48,57.89 94.48,58.32 94.47,58.32 94.47,59.67 95.93,61.13 101.1,61.13 103.17,63.21 104.68,63.21 v4(104.91,62.97)
  IN3 w0.061: v5(83.73,38.99) v4(83.49,38.73) ; v5(82.82,38.99) v4(83.05,38.73) ; v4(82.61,40.63) 82.36,40.37 v5(82.36,40.36) ; v5(82.82,39.92) v4(82.84,39.57) ; v5(97.16,45.8) v4(96.85,46.09) ; v5(83.27,39.46) v4(83.27,39.08) ; v5(82.36,39.46) v4(82.47,39.12) ; v5(83.73,39.92) v4(83.75,40.29)
  IN3 w0.076: v4(83.52,40.63) v5(83.27,40.38) ; v5(97.16,44.96) 96.93,45.19 v4(96.91,45.19)
  IN3 w0.254: v4(94.12,39.01) 94.1,38.99 v5(93.74,38.99) ; v5(63.32,59.63) 63.37,59.58 64.67,59.58 65.03,59.95 65.03,61.55 65.37,61.89 65.37,63.54 64.84,64.07 63.96,64.07 63,65.03 v4(62.58,65.03) ; v4(93.8,39.44) 93.82,39.47 v5(94.22,39.47) ; v4(93.41,40.79) 93.3,40.68 v5(93.3,40.38) ; v4(73.48,56.36) 73.68,56.56 75.97,56.56 77.22,55.31 77.22,55.09 v5(77.22,55.09) ; v4(62.36,56.81) v5(62.74,56.81) ; v5(93.78,39.92) 93.48,39.92 v4(93.37,39.81) 93.37,39.53 v5(93.29,39.44) ; v4(83.43,51.07) 83.43,51.1 84.27,51.94 84.27,52.48 84.26,52.48 84.26,53.46 83.68,54.04 82.21,54.04 80.11,56.14 v5(79.93,56.14) ; 82.59,41.8 82.33,42.06 77.09,42.06 76.83,42.31 76.83,48.79 75.88,49.75 75.88,49.78 v4(75.85,49.81) ; v5(94.21,40.38) v4(94.44,40.62)
  BOTTOM w0.102: v5(82.82,39.92) 83.02,40.12 83.1,40.2 v5(83.27,40.38) ; v5(82.82,39.92) 82.59,39.69 82.59,39.68 v5(82.36,39.46) 82.56,39.26 ; v5(82.82,39.92) 83.02,39.72 83.1,39.63 v5(83.27,39.46) ; v5(82.82,39.92) 82.64,40.1 82.6,40.14 ; v5(83.27,40.38) 83.48,40.59 ; v5(83.27,40.38) 83.46,40.2 ; v5(83.27,40.38) 83.07,40.58 ; 94.02,40.58 v5(94.21,40.38) 94.21,40.37 93.76,39.92 UCPU1.BH25 ; UCPU1.BH25 93.58,39.74 93.49,39.64 UCPU1.BH26 93.51,39.25 ; UCPU1.BH25 93.75,39.93 93.3,40.38 v5(93.3,40.38) 93.48,40.57 ; UCPU1.BH25 93.75,39.92 94.21,39.46 UCPU1.BJ26 93.99,39.24 ; 83.55,40.1 v5(83.73,39.92) 83.46,39.65 83.46,39.64 v5(83.27,39.46) ; 82.56,40.58 UCPU1.AK24 82.56,40.18 ; v5(83.27,39.46) 83.07,39.25 ; v5(83.27,39.46) 83.47,39.26
  BOTTOM w0.203: v5(77.22,55.09) 77.22,55.15 77.26,55.19 77.26,55.55 77.08,55.73 77.05,55.73 76.94,55.84 76.94,55.85 76.87,55.92 76.87,56.25 77.13,56.51 77.7,56.51 77.92,56.73 79.63,56.73 79.93,56.42 v5(79.93,56.14)
  BOTTOM w0.254: v5(63.32,59.63) 62.68,58.99 62.68,56.87 v5(62.74,56.81)
  vias: v2(97.13,45.64) v4(103.19,27.22) v4(103.82,27.22) v5(82.84,41.29) v5(82.84,40.91) v5(83.22,41.29) v5(83.22,40.91) v5(93.74,41.27) v5(93.76,40.91) v5(94.09,41.27) v5(94.09,40.89) v5(103.29,28.21) v5(104.3,28.21) v5(104.69,28.21) v5(104.71,27.25) v6(102.95,27.71) v6(103.52,27.71) v6(104.08,27.71)
+1.0VS_VCCIOP: length 7.2
  IN3 w0.254: v5(107.9,18.18) 107.65,18.43 107.64,18.43 107.56,18.51 106.06,18.51 104.96,19.6 v5(104.96,23.28)
+1.2V_DDR: length 203.3
  TOP w0.076: UD3.H3 88.25,19.05 v2(88.25,19.05) ; v5(66.07,26.23) 66.07,26.2 v2(66.06,26.2)
  TOP w0.127: v3(75.73,25.82) CC50.1
  TOP w0.254: v5(70.62,25.43) 71.12,25.93 71.12,27.68 70.79,28.01 CD32.1 ; v5(64.77,23.03) UD2.H9 v5(65.42,23.83) ; UD3.G2 v5(86.97,18.23) ; v5(69.32,26.23) 69.1,26.45 CD37.1 ; v5(64.77,26.23) UD2.G12 ; v5(88.92,23.83) UD3.H9 v5(88.27,23.03)
  TOP w0.305: CD18.1 61.95,26.66 v5(61.52,26.23) ; CD4.1 86.12,28.69 86.32,28.49 v5(86.32,26.23) ; v5(88.27,26.23) UD3.G12 87.93,26.54 CD5.1 ; UD2.G12 63.68,26.68 CD3.1 ; CD29.1 91.4,26.35 v5(91.52,26.23) ; CD13.1 92.62,28.72 92.62,26.44 v5(92.82,26.23) ; v5(66.07,26.23) UD2.L12 66.99,26.51 CD9.1 66.99,29.4 67.2,29.61 v2(67.66,29.61) ; CD6.1 89.7,28.78 90.22,28.26 UD3.L12 ; CD15.1 84.7,28.71 85.02,28.38 v5(85.02,26.23) ; v5(83.72,23.83) 83.58,23.69 CD8.1
  TOP w0.381: CD11.1 72.99,24.62 v2(73.06,24.69) 73.56,24.18 73.56,23.64 73.26,23.35 CD14.1 ; CC49.1 82.11,27.04 v5(83.72,25.43) ; CD6.1 89.7,29.27 90.06,29.63 90.81,29.63 CD29.1 ; CC47.1 CD32.1 ; CD2.1 72.75,25.97 73.25,25.97 v2(73.27,25.95) 73.29,25.98 CC46.1 73.98,25.82 CC50.1 ; v2(58.09,22.24) 58.18,22.33 CD16.1 58.18,23.81 CD17.1 58.18,23.98 CD39.1 v2(58.18,25.29) ; CD13.1 92.93,29.23 93.31,29.61 93.92,29.61 CC31.1 ; CC45.1 CC48.1 94.89,26.21 v5(94.12,25.43) ; RD12.1 v6(58.14,26.05)
  IN1 w0.203: v4(64.77,26.63) v5(64.77,26.23) v2(64.77,25.43) ; v5(83.72,23.03) v4(83.39,23.03) ; v5(88.92,24.63) v4(88.6,25.03) v5(88.27,25.43) ; v5(70.62,25.43) v4(70.95,25.43) ; v2(66.06,26.2) 66.07,26.19 v5(66.07,25.43) v4(65.74,25.03) v5(65.42,24.63) ; v5(69.32,26.23) v4(69.46,26.53) ; v5(92.82,26.23) v4(92.78,26.56) ; v5(91.52,26.23) v4(91.62,26.56) ; v4(88.05,26.49) v5(88.27,26.23) ; v2(67.66,29.61) 67.61,29.66 67.61,29.99 v4(67.6,30) ; v5(83.72,25.43) v4(83.39,25.43) ; v5(83.72,23.83) v4(83.39,23.83) ; v5(65.42,23.83) v4(65.74,23.45) v5(66.07,23.03) ; v4(87.91,19.51) 87.91,19.51 87.91,19.41 88.25,19.07 v2(88.25,19.05) ; v5(70.62,23.03) v4(70.95,23.03) ; v5(61.52,26.23) v4(61.56,26.56) ; v5(60.22,25.43) v4(59.89,25.43) ; v5(62.82,26.23) v4(62.72,26.56) ; v4(89.57,26.63) v5(89.57,26.23) v5(89.57,25.43) ; v5(68.02,26.23) v4(67.91,26.56) ; v5(70.62,23.83) v4(70.95,23.83) ; v5(86.32,26.23) v4(86.43,26.55)
  IN1 w0.229: v5(92.17,21.43) v4(92.43,21.65) ; v5(65.42,20.63) v4(65.67,20.85) v5(66.07,20.63) ; v4(88.02,21.65) v5(88.27,21.43) ; v5(65.42,21.43) v4(65.67,21.65) ; v5(66.07,21.43) v4(66.32,21.65) ; v5(68.67,19.83) v4(68.92,20.05) ; v5(62.17,21.43) v4(61.92,21.65) ; v5(64.12,18.23) v4(63.79,18.02) v5(63.47,18.23) ; v2(64.77,19.03) v4(64.44,19.34) ; v5(64.12,20.63) v4(63.87,20.85) ; v5(92.17,20.63) v4(92.43,20.85) ; v5(68.67,21.43) v4(68.92,21.65) ; v5(66.72,20.63) v4(66.97,20.85) ; v5(92.17,19.83) v4(92.43,20.05) ; v5(88.92,21.43) v4(88.67,21.65) ; v5(90.22,18.23) v4(90.48,18.02) ; v5(85.67,20.63) v4(85.42,20.85) ; v5(62.17,19.83) v4(61.92,20.05) ; v5(68.67,20.63) v4(68.92,20.85) ; v5(64.77,20.63) v4(64.68,20.31) ; v5(86.97,18.23) 86.97,17.95 v4(87.02,17.9) ; v5(67.37,18.23) v4(67.04,18.45) v5(66.72,18.23) ; v5(89.57,21.43) v4(89.83,21.65) ; v5(87.62,20.63) v4(87.37,20.85) ; v5(62.17,20.63) v4(61.92,20.85) ; v4(88.67,20.85) v5(88.92,20.63) ; v5(85.67,21.43) v4(85.42,21.65) ; v5(85.67,19.83) v4(85.42,20.05) ; v5(90.22,20.63) v4(89.83,20.85) v5(89.57,20.63)
  IN1 w0.254: v5(68.02,23.03) v4(67.74,23.43) ; v2(90.85,18.24) 90.85,18.23 90.69,18.23 v4(90.48,18.02) ; v5(94.12,23.03) v4(94.45,23.03) ; v2(66.06,26.2) v4(66.27,26.57) ; v5(89.57,23.03) v4(89.83,22.74) ; v5(60.22,23.83) v4(59.89,23.83) ; v5(62.82,23.03) 62.82,23.37 v4(62.83,23.37) ; v2(60.54,29.36) 60.5,29.39 v4(60.5,29.76) ; v5(60.22,23.03) v4(59.89,23.03) ; v5(91.52,23.03) v4(91.78,23.25) ; v2(73.27,25.95) 73.27,26.31 v4(73.16,26.41) ; v5(88.92,23.83) v4(88.6,23.45) v5(88.27,23.03) ; v5(64.77,21.43) v4(64.68,21.75) ; v5(94.12,23.83) v4(94.45,23.83) ; v5(85.02,26.23) v4(84.91,26.55) ; v5(88.27,20.63) v4(88.67,20.85) ; v5(64.77,23.03) v4(64.77,22.7) ; v5(94.12,25.43) v4(94.45,25.43)
  IN1 w0.305: v4(86.07,23.25) 86.11,23.25 v5(86.32,23.03)
  IN1 w0.381: v2(73.06,24.69) v4(73.06,24.34) ; v4(58.11,22.58) 58.09,22.56 v2(58.09,22.24) ; v2(58.18,25.29) 58.43,25.55 v4(58.52,25.55)
  IN3 w0.203: v5(65.42,20.63) v4(65.67,20.85) ; v5(68.02,26.23) v4(67.91,26.56) ; v5(70.62,23.03) v4(70.95,23.03) ; v5(61.52,26.23) v4(61.56,26.56) ; v5(91.52,26.23) v4(91.62,26.56) ; v5(88.92,24.63) v4(88.6,25.03) v5(88.27,25.43) ; v4(89.57,26.63) v5(89.57,26.23) v5(89.57,25.43) ; v4(67.6,30) 67.6,29.79 v5(67.41,29.61) ; v5(65.42,24.63) v4(65.74,25.03) v5(66.07,25.43) ; v5(94.12,25.43) v4(94.45,25.43) ; v4(88.05,26.49) v5(88.27,26.23) ; v5(70.62,25.43) v4(70.95,25.43) ; v5(81,35.74) v4(81.23,35.51) ; v5(66.07,23.03) 65.74,23.36 v4(65.74,23.45) ; v5(83.72,23.83) v4(83.39,23.83) ; v5(92.82,26.23) v4(92.78,26.56) ; v5(62.82,26.23) v4(62.72,26.56) ; v5(70.62,23.83) v4(70.95,23.83) ; v5(83.72,23.03) v4(83.39,23.03) ; v5(64.77,26.23) v4(64.77,26.63) ; v4(65.74,23.45) v5(66.07,23.83) ; v4(65.74,23.45) v5(65.42,23.83) ; v5(60.22,25.43) v4(59.89,25.43) ; v5(83.72,25.43) v4(83.39,25.43)
  IN3 w0.229: v5(85.67,21.43) v4(85.42,21.65) ; v5(92.17,19.83) v4(92.43,20.05) ; v5(88.92,20.63) v4(88.67,20.85) ; v5(85.67,20.63) v4(85.42,20.85) ; v4(66.97,20.85) v5(66.72,20.63) ; v5(85.67,19.83) v4(85.42,20.05) ; v5(92.17,21.43) v4(92.43,21.65) ; v5(91.52,23.03) v4(91.78,23.25) ; v5(89.61,19.07) v4(89.87,19.34) ; v4(65.67,20.85) v5(66.07,20.63) ; v5(87.62,20.63) v4(87.37,20.85) ; v4(87.02,17.9) 86.97,17.95 v5(86.97,18.23) ; v5(89.57,21.43) v4(89.83,21.65) ; v5(85.02,26.23) v4(84.91,26.55) ; v5(66.72,18.23) v4(67.04,18.45) v5(67.37,18.23) ; v5(88.92,21.43) v4(88.67,21.65) ; v5(66.07,19.03) v4(66.32,19.25) ; v5(92.17,20.63) v4(92.43,20.85) ; v5(69.32,26.23) v4(69.46,26.53) ; v5(89.57,23.03) v4(89.83,22.74) ; v5(89.57,20.63) v4(89.83,20.85) ; v5(86.32,23.03) v4(86.07,23.25) ; v5(90.22,18.23) v4(90.48,18.02) ; v5(86.32,26.23) v4(86.43,26.55) ; v5(63.47,18.23) v4(63.79,18.02) v5(64.12,18.23) ; v5(64.77,20.63) v4(64.68,20.31) ; v4(88.02,21.65) v5(88.27,21.43)
  IN3 w0.254: v5(60.22,23.03) v4(59.89,23.03) ; v5(66.07,21.43) v4(66.32,21.65) ; v5(62.17,21.43) v4(61.92,21.65) ; v5(90.85,18.24) 90.71,18.24 90.49,18.02 v4(90.48,18.02) ; v5(64.77,23.03) v4(64.77,22.7) ; v5(94.12,23.83) v4(94.45,23.83) ; v5(65.42,21.43) v4(65.67,21.65) ; v5(62.17,20.63) v4(61.92,20.85) ; v4(62.83,23.37) 62.82,23.37 v5(62.82,23.03) ; v5(68.67,19.83) v4(68.92,20.05) ; v5(68.67,21.43) v4(68.92,21.65) ; v5(88.27,23.03) v4(88.6,23.45) v5(88.92,23.83) ; v4(88.67,20.85) v5(88.27,20.63) ; v4(72.56,35.51) v5(72.79,35.74) ; v5(91.93,35.74) v4(92.19,35.48) ; v5(64.12,20.63) v4(63.87,20.85) ; v5(62.17,19.83) v4(61.92,20.05) ; v5(60.22,23.83) v4(59.89,23.83) ; v5(94.12,23.03) v4(94.45,23.03) ; v5(88.29,35.74) v4(88.55,35.48) ; v5(66.07,26.23) v4(66.27,26.57) ; v5(64.77,21.43) v4(64.68,21.75) ; v5(68.67,20.63) v4(68.92,20.85) ; v4(89.83,20.85) v5(90.22,20.63) ; v5(84.64,35.74) v4(84.9,35.48) ; v5(68.02,23.03) v4(67.74,23.43)
  IN3 w0.381: v5(56.35,30.96) v4(55.99,30.96) ; v5(64.96,29.53) v4(64.96,29.93)
  BOTTOM w0.254: CC32.1 83.48,33.04 UCPU1.AM36 ; 77.87,32.1 77.87,29.82 78.33,29.36 79.93,29.36 CC35.1 ; 77.87,32.1 78.57,32.8 UCPU1.AD36 ; 77.87,32.1 76.76,32.1 76.05,32.81 UCPU1.Y36 ; v5(83.72,25.43) 82.11,27.04 81.79,27.04 CD53.1 81.28,27.55 81.28,30.3 CC35.1 ; 90.32,26.86 90.32,26.33 UD3.L12 v5(89.57,26.23) ; 87.53,26.87 87.53,26.33 UD3.G12 v5(88.27,26.23) ; UCPU1.AH36 81.08,30.51 CC35.1 ; v5(89.57,23.03) UD1.H9 v5(88.92,23.83) ; v5(69.32,26.23) 69.32,26.24 69.32,26.69 ; 93.04,32.15 93.67,32.78 UCPU1.BH36 ; v5(86.32,26.23) 86.17,26.39 86.17,26.82 ; 88.63,32.6 UCPU1.AY36 ; 85.02,26.69 v5(85.02,26.23) ; UD2.G12 v5(64.77,26.23) v2(64.77,25.43) ; UD2.L12 v5(66.07,26.23) ; UD3.G2 v5(86.97,18.23)
  BOTTOM w0.305: CD65.1 63.82,27.11 64.12,26.8 UD2.G12 ; v5(91.52,26.23) 91.48,26.27 CD75.1 ; CD68.1 92.6,28.98 92.6,26.45 v5(92.82,26.23) ; CD74.1 62.55,26.51 v5(62.82,26.23)
  BOTTOM w0.356: CD77.1 61.28,29.38 61.53,29.64 62.29,29.64 62.55,29.39 CD74.1
  BOTTOM w0.381: v5(56.35,30.96) 56.66,30.96 56.95,30.66 UC9.5 ; 86.17,26.82 CD85.1 86.26,29.32 CC36.1 ; v5(64.96,29.53) 64.96,29.51 65.47,29 CD61.1 CD60.1 ; CD76.1 90.32,26.86 ; 69.32,26.69 69.32,27.13 70.14,27.96 70.4,27.96 71.16,28.72 CD56.1 71.61,29 CD12.1 ; CD68.1 92.65,29.38 91.39,30.64 CC33.1
  BOTTOM w0.508: 85.02,26.69 85.02,27.37 84.48,27.91 CD64.1 CC34.1 84.15,30.6 83.92,30.37 CC32.1 ; CD73.1 87.53,26.87 ; 88.63,32.6 88.63,32.39 88.95,32.07 CC37.1 88.99,30.64 CC38.1 CC33.1 92.5,32.15 93.04,32.15
  vias: v2(80.73,14.14) v2(81.13,14.14) v2(81.76,14.14) v4(55.03,19.96) v4(55.03,19.45) v4(55.03,18.94) v4(55.03,18.43) v4(55.03,17.93) v4(55.79,19.96) v4(55.79,19.45) v4(55.79,18.94) v4(55.79,18.43) v4(55.79,17.93) v5(54.65,19.96) v5(54.65,19.7) v5(54.65,19.45) v5(54.65,19.2) v5(54.65,18.94) v5(54.65,18.69) v5(54.65,18.43) v5(54.65,18.18) v5(54.65,17.93) v5(55.41,19.96) v5(55.41,19.7) v5(55.41,19.45) v5(55.41,19.2) v5(55.41,18.94) v5(55.41,18.69) v5(55.41,18.43) v5(55.41,18.18) v5(55.41,17.93) v6(59.3,18.26) v6(59.3,17.7) v6(75.86,18.11) v6(76.42,18.11) v6(97.97,17.95)
+1.2V_DDRP: length 2.8
  TOP w0.127: PC609.1 50.64,22.62 v1(50.44,22.42)
  TOP w0.254: PC609.1 PR605.1 51.16,24.27 v6(51.39,24.04)
  vias: v6(51.07,20.5) v6(51.06,19.85) v6(51.07,19.24) v6(51.07,18.63) v6(51.08,17.99) v6(51.08,17.42)
+1.8V_MEM: length 45.9
  TOP w0.762: 119.44,22.04 119.44,24.17 119.34,24.28 119.34,29.41 119.44,29.51
  IN1 w0.203: v5(70.62,24.63) v4(70.95,24.63) ; v5(83.72,24.63) v4(83.39,24.63)
  IN1 w0.229: v4(83.47,18.82) 83.48,18.83 v5(83.72,19.03) ; v5(60.22,20.63) v4(59.97,20.85) ; v5(60.22,19.83) v4(59.97,20.05) ; v5(83.72,21.43) v4(83.47,21.22) ; v5(83.72,20.63) v4(83.47,20.42) ; v5(60.22,21.43) v4(59.97,21.65) ; v5(60.22,19.03) v4(59.97,19.25) ; v5(83.72,19.83) v4(83.47,19.62)
  IN1 w0.254: v5(70.62,19.83) v4(70.95,19.83) ; v5(94.12,21.43) v4(94.45,21.43) ; v5(94.12,19.03) v4(94.45,19.03) ; v5(94.12,20.63) v4(94.45,20.63) ; v5(70.62,20.63) v4(70.95,20.63) ; v5(70.62,19.03) v4(70.95,19.03) ; v5(94.12,19.83) v4(94.45,19.83) ; v5(60.22,24.63) v4(59.89,24.63) ; v5(94.12,24.63) v4(94.45,24.63) ; v5(70.62,21.43) v4(70.95,21.43)
  IN1 w0.762: 118.07,20.44 113.77,20.44 112.84,19.5 109.16,19.5 108.47,20.19 106.21,20.19 103.53,22.87 95.95,22.87 95.15,22.07 95.15,21.99
  IN3 w0.203: v5(70.62,24.63) v4(70.95,24.63) ; v5(83.72,24.63) v4(83.39,24.63)
  IN3 w0.229: v5(94.12,19.83) v4(94.45,19.83) ; v5(94.12,19.03) v4(94.45,19.03) ; v5(94.12,20.63) v4(94.45,20.63) ; v5(83.72,19.83) v4(83.47,19.62) ; v5(83.72,20.63) v4(83.47,20.42) ; v5(83.72,21.43) v4(83.47,21.22) ; v5(94.12,21.43) v4(94.45,21.43) ; v4(83.47,18.82) 83.48,18.83 v5(83.72,19.03)
  IN3 w0.254: v5(70.62,19.03) v4(70.95,19.03) ; v5(70.62,20.63) v4(70.95,20.63) ; v5(60.22,19.03) v4(59.97,19.25) ; v5(60.22,19.83) v4(59.97,20.05) ; v5(70.62,19.83) v4(70.95,19.83) ; v5(60.22,24.63) v4(59.89,24.63) ; v5(60.22,20.63) v4(59.97,20.85) ; v5(70.62,21.43) v4(70.95,21.43) ; v5(94.12,24.63) v4(94.45,24.63) ; v5(60.22,21.43) v4(59.97,21.65)
  vias: v2(118.67,20) v2(119.04,20.54) v2(119.03,19.98) v2(119.41,20) v3(77,21.08)
+1.8V_MEM_R: length 0.6
  TOP w0.102: 121.53,30.75 121.53,31.2 v1(121.44,31.29)
+1.8V_PRIM: length 138.6
  TOP w0.381: RC24.1 101.13,40.79 101.64,41.29
  TOP w0.508: RC491.2 219.37,30.28 219.87,29.78 221.04,29.78 221.41,30.16 v6(221.41,30.6) 221.41,30.92 220.98,31.35 RC597.2
  IN1 w0.381: v4(109.83,42.02) 109.64,42.21 v2(109.64,42.4)
  IN2 w0.381: v6(221.41,30.6) 221.41,30.22 220.9,29.71 219.63,29.71 215.35,25.43 208.25,25.43 206.09,27.59 197.7,27.59 197.24,28.05 190.03,28.05 177.96,15.97 153.83,15.97 153.56,16.24 147.8,16.24 143.54,20.5 140.89,20.5 140.12,21.28 v4(135.47,21.28)
  IN3 w0.254: v5(103.01,44.12) v4(103.24,44.35) ; v5(103.66,45.8) v4(103.89,46.03) ; v5(103.66,44.12) v4(103.89,44.35) ; v5(103.01,44.96) v4(103.24,45.19) ; v5(103.66,44.96) v4(103.89,45.19) ; v5(103.01,46.64) v4(103.24,46.87) ; v5(103.66,46.64) v4(103.89,46.87)
  IN3 w0.305: v4(109.83,42.02) 109.83,41.64 v5(109.79,41.6)
  IN3 w0.381: v5(135.04,21.74) 135.47,21.3 v4(135.47,21.28) ; v4(113.42,39.77) 112.89,39.77 v6(112.88,39.78)
  BOTTOM w0.305: UCPU1.CP23 109.73,41.54 v5(109.79,41.6) ; v6(112.88,39.78) 112.8,39.78 112.71,39.87 112.34,39.87 RC464.1
  BOTTOM w0.356: CC98.1 111.68,45.54 111.93,45.79 112.65,45.79 113.37,45.07 113.37,44.65 RH59.1
  BOTTOM w0.508: v5(135.04,21.74) 135.27,21.74 137.96,24.43 140.4,24.43 RV68.1 140.75,26.23 137.19,26.23 136.76,26.31 136.71,26.32 136.69,26.33 136.31,26.4 135.27,26.81 134.85,27.07 133.98,27.93 127.51,27.93 127.23,28.21 122.93,28.21
  vias: v2(103.42,45.53) v2(104.02,45.61) v2(104.13,44.75) v2(113.45,43.5) v2(113.45,43.2) v2(122.39,28.11) v3(100.9,43.15) v4(113.36,42.8) v4(113.37,42.32) v4(121.25,28.21) v4(121.68,28.21) v5(113.44,43.9) v5(113.44,43.21) v5(122.11,28.14) v5(122.41,28.14) v6(114.59,33.53) v6(114.59,32.95) v6(114.93,32.45) v6(115.53,32.45)
+1.8V_PRIMP: length 2.9
  TOP w0.102: v6(111.82,26.16) 111.82,25.69 v1(112.06,25.44)
  BOTTOM w0.254: 113.74,27.56 114.19,27.12 PC505.2
  BOTTOM w0.381: PR502.1 115.24,27 PC505.2
+1.8V_PRIMR: length 39.2
  TOP w0.127: 225.77,49.17 v3(225.77,48.34)
  TOP w0.381: v2(263.24,47.39) 263.94,47.39 RE184.1
  IN1 w0.508: v2(263.24,47.39) 262.99,47.14 261.53,47.14 260.81,47.85 256.29,47.85 255.38,48.76 241.07,48.76 240.13,49.71 228.25,49.71 v2(227.68,50.27)
+1.8V_PRIMR_RIGHT:
  vias: v1(226.96,46.73)
+1.8VA_EC: length 9.9
  TOP w0.33: UE1.N5 265.84,50.74 265.34,50.25 CE15.1
  TOP w0.356: v2(259.89,51.52) RE186.1
  TOP w0.381: v2(264.45,49.39) 264.53,49.46 CE15.1
  TOP w0.508: v2(264.45,49.39) 264.45,49.38 RE184.2
  IN1 w0.508: v2(259.89,51.52) 260.16,51.52 260.22,51.45 v4(260.3,51.45) ; v2(264.45,49.39) 264.44,49.39 264.2,49.62 v4(264.2,50.13)
  IN2 w0.508: v4(260.3,51.45) 260.3,51.14 260.87,50.56 263.77,50.56 v4(264.2,50.13)
+1.8VA_LDO_PD_A: length 7.2
  TOP w0.127: RT52.2 25.22,67.96 v2(25.49,67.69) ; CT94.1 29.07,65.19 28.63,65.63 v2(28.63,65.99)
  IN1 w0.061: v4(28.76,65.53) 28.65,65.63 28.65,65.97 v2(28.63,65.99) 28.6,65.96 27.4,65.96 26.64,66.72 26.39,66.72 25.49,67.62 v2(25.49,67.69)
  IN3 w0.061: v5(28.64,65.14) 28.64,65.37 28.76,65.5 v4(28.76,65.53)
  BOTTOM w0.076: v5(28.64,65.14) 28.5,65.14 UT1.K1
+1.8VA_LDO_PD_B: length 15
  IN1 w0.061: v4(24.78,75.37) v2(25.02,75.13) ; v4(29.61,72.42) 29.58,72.45 v2(29.27,72.45)
  IN2 w0.061: v4(24.78,75.37) 25.49,75.37 25.66,75.54 26.16,75.54 26.57,75.96 27.36,75.96 28.73,77.32 29.24,77.32 31.58,74.97 31.58,73.07 30.95,72.43 29.63,72.43 v4(29.61,72.42)
  IN3 w0.061: v4(29.61,72.42) 28.69,72.42 v5(28.54,72.27)
  BOTTOM w0.127: UT5.K1 28.37,72.43 v5(28.54,72.27)
+1.8VD_LDO_PD_A: length 1.2
  IN1 w0.254: v2(28.02,70.15) 28.05,70.17 28.08,70.17 v4(28.3,70.4)
  IN3 w0.305: v4(28.3,70.4) 28.29,70.28 27.85,69.91 v5(27.74,69.91)
+1.8VD_LDO_PD_B: length 1.9
  TOP w0.127: v2(28.1,77.46) 27.98,77.33 CT98.1
  IN1 w0.061: v2(28.1,77.46) 28.13,77.46 28.44,77.77 v4(28.49,77.77)
  IN3 w0.061: v5(28.1,77.43) 28.12,77.43 28.46,77.77 v4(28.49,77.77)
  BOTTOM w0.127: UT5.A2 28.1,77.31 v5(28.1,77.43)
+1.8VS: length 307.5
  TOP w0.305: QN12.2 273.35,28.07 ; 273.35,28.07 272.59,28.07 272.34,27.82 272.34,26.78 RN115.1 ; 273.35,28.07 QN12.5 ; 264.54,23.78 QN7.5 ; 264.54,23.78 QN7.2 ; 264.54,23.78 264.24,24.07 264.24,24.52
  TOP w0.356: RN115.1 272.68,26.02 272.81,25.89 RN105.1 273.14,25.69 273.25,25.8 v2(273.42,25.8)
  TOP w0.381: RC499.1 RC500.1 ; 264.24,24.52 264.24,25.27 264.6,25.62 264.6,26.38 264.19,26.79 RN3.1 RN92.1 262.9,26.79 v6(262.45,26.35)
  TOP w0.508: v2(125.48,34.42) 127.09,32.82 128.26,32.82 130.42,30.66 131.77,30.66 140.81,21.73 149.43,19.05 153.65,17.84 178.84,17.84 182.14,21.14 191.74,21.14 192.21,21.62 192.21,24.05 192.66,24.49 196.06,24.49 201.29,29.72 204.38,29.72 207.87,33.22 v3(207.87,34.91) 207.87,37.65 216.9,46.68 216.9,51.63 218.11,52.84 219.53,52.84 221.27,51.1 221.27,48.85 221.65,48.47 R47.2 ; RC500.1 113.47,44.49 v2(116.33,41.64)
  IN1 w0.508: v2(116.33,41.64) 116.34,41.64 118.06,39.92 120.02,39.92 123.98,35.96 123.98,35.41 124.97,34.42 v2(125.48,34.42) ; v4(272.55,26.35) 272.97,26.35 273.42,25.9 v2(273.42,25.8) 274,25.8 274.6,25.2 274.6,18.14 v6(280.48,12.26)
  IN2 w0.508: v4(272.55,26.35) v6(262.45,26.35) 255.16,26.35 254.42,27.09 254.42,32.48 251.6,35.3 241.33,35.3 239.33,33.29 v6(237.34,33.29)
  IN3 w0.508: v6(221.35,47.9) 221.4,47.95 225.73,47.95 228.45,45.23 v5(237.46,45.23) ; v5(198.72,66.39) 198.24,66.87 198.24,68.53 v5(198.69,68.98) 198.89,68.98 199.8,68.08 202.36,68.08 v5(202.86,68.57)
  BOTTOM w0.254: RS3.1 202.89,67.1 202.2,66.4 RS6.1 ; CS9.1 197.88,63.58 197.88,64.64 198.39,65.14 198.39,65.83 198.72,66.16 v5(198.72,66.39)
  BOTTOM w0.305: CS10.1 199.34,65.87 199.3,65.83 Q12.2 ; Q12.5 199.3,64.38 199.12,64.56 198.61,64.56 198.26,64.2 198.26,63.82 197.95,63.52 CS9.1
  BOTTOM w0.381: CS10.1 RS7.1
  BOTTOM w0.508: RS3.1 203.67,68.6 203.76,68.69 212.2,68.69 213.22,69.7 213.98,69.7 214.34,69.35 214.34,67.57 218.07,63.84 218.07,48.68 218.85,47.9 v6(221.35,47.9) ; v6(237.34,33.29) 236.57,34.05 236.57,44.34 v5(237.46,45.23) ; v5(198.72,66.39) 198.73,66.4 CS10.1
