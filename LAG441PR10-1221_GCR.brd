# Allegro board LAG441PR10-1221_GCR.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB20_N3: length 164.6
  IN1 w0.074: v4(104.01,61.74) 103.84,61.57 103.55,61.57 103.45,61.47 102.94,61.47 100.89,63.52 86.57,63.52 86.03,64.06 85.56,64.06 82.11,67.51 70.09,67.51 69.68,67.1 68.38,67.1 68.09,66.81 64.77,66.81 63.4,68.18 63.4,68.32 62.13,69.59 60.33,70.26 58.06,70.7 57.4,71.02 56.85,71.23 56.02,71.65 55.21,72.27 54.68,72.79 53.61,72.79 53.03,73.37 51.32,73.37 50.41,74.29 49.85,74.29 49.03,75.1 42.39,75.1 41.85,74.55 40.12,74.55 39.95,74.72 37.26,74.72 36.55,74.01 33.72,74.01 32.85,73.15 32.85,71.41 32.7,71.26 32.62,71.26 v4(32.46,71.41) ; v4(19.42,17.24) 19.25,17.07 19.25,14.93 v2(19.4,14.78)
  IN3 w0.074: v4(104.01,61.74) v5(104.38,61.74) ; v4(32.46,71.41) 32.56,71.32 33.51,71.32 35.12,69.71 35.12,68.17 35.35,67.95 35.35,64.31 36.17,63.49 36.17,57.57 36.4,57.34 36.4,55.08 36.6,54.88 36.6,53 36.17,52.57 36.17,49.45 35.9,49.18 35.9,49.17 34.52,47.78 34.52,46.44 34.22,46.14 34.22,45.19 29.31,40.28 27.77,40.28 27.35,40.7 24.38,40.7 23.29,39.61 22.11,39.61 20.8,38.29 20.34,38.29 19.01,36.97 17.99,36.97 16.96,35.93 16.03,35.93 15.69,35.59 15.69,21.48 19.26,17.92 19.26,17.4 v4(19.42,17.24)
  BOTTOM w0.076: v5(104.38,61.74) 104.5,61.61 104.62,61.61 104.79,61.44 104.79,60.67 104.7,60.58 v7(104.7,59.12) 104.7,58.74 105.29,58.15 105.29,57.69 105.31,57.68 105.31,57.1 105.29,57.08 105.29,55.99 104.86,55.56 104.86,55.47 104.86,55.31 104.92,55 104.85,54.76 104.85,54.64 104.92,54.5 104.92,54.28 104.84,54.09 104.84,53.88 104.9,53.82 104.99,53.82 105.12,53.95 UCPU1.CG3
USB20_N4: length 244.7
  IN1 w0.074: v4(104,57.8) 103.84,57.96 103.84,58.08 104.02,58.26 104.46,58.26 104.71,58.01 106.11,58.01 106.41,58.31 109.08,58.31 109.41,58.64 115.01,58.64 116.78,56.87 116.78,53.81 117.32,53.27 117.32,52.22 117.82,51.73 117.82,50.88 118.47,50.23 118.47,49.17 119.99,47.65 119.99,44.8 121.01,43.78 123.86,43.78 125.16,42.48 125.16,42.11 126.59,40.68 127.3,40.68 128.32,39.67 129.16,39.67 129.27,39.77 129.78,39.77 130.88,38.54 132.03,36.87 133.93,33.2 135.82,30.6 137.61,28.57 140.24,26.07 140.96,25.46 141.93,24.71 142.59,24.23 142.94,23.99 146.13,21.92 146.61,21.63 148.27,20.78 148.5,20.67 148.72,20.57 148.72,20.57 150.17,20.01 150.18,20.01 150.27,19.97 150.69,19.8 150.8,19.76 152.76,19.14 152.77,19.14 153.97,18.88 155.6,18.42 158.15,17.81 175.41,17.81 180.8,23.2 189.57,23.2 190.16,23.78 194.56,23.78 197.69,26.92 198.66,26.92 201.8,30.06 203.3,30.06 208.62,35.38 208.62,37.7 211.8,40.89 212.99,40.89 214.1,41.99 216.01,41.99 216.3,41.7 218.62,41.7 219.08,42.15 227.25,42.15 227.7,41.7 241.88,41.7 243.36,40.21 248.63,40.21 250.77,38.08 267.59,38.08 267.97,38.46 279.62,38.46 279.76,38.32 280.74,38.32 281.25,38.84 281.25,44.59 282,45.33 282,48.53 283.96,50.49 283.96,57.38 286.77,60.19 286.77,61.73 286.52,61.97 286.4,61.97 v2(286.21,62.05)
  IN3 w0.074: v5(104.07,57.27) 103.97,57.37 103.97,57.77 v4(104,57.8)
  BOTTOM w0.076: v5(104.07,57.27) 103.92,57.13 103.92,56.71 103.31,56.09 103.31,55.13 103.11,54.93 103.11,54.79 103.18,54.72 103.47,54.72 103.55,54.65 103.55,54.47 103.41,54.33 103.31,54.33 UCPU1.CD3
USB20_N6: length 66
  IN1 w0.074: v4(90.17,61.72) 90.02,61.88 90.02,62.09 90.12,62.19 100.05,62.19 101.34,60.9 101.34,59.24 101.26,59.17 101.14,59.17 101.04,59.27 100.9,59.27 100.81,59.18 100.81,59 100.98,58.83 v4(101.02,58.83)
  IN3 w0.074: v5(60.09,57.58) 60.22,57.45 60.22,57.27 60.42,57.07 60.81,57.07 61.26,57.52 70.65,57.52 70.93,57.79 76.43,57.79 76.67,57.69 80.29,57.69 82.1,55.88 82.1,55.71 82.7,55.1 86.67,55.1 87.04,55.48 87.38,55.48 88.07,56.17 88.55,56.17 90.17,57.79 v4(90.17,61.72) ; v4(101.02,58.83) 101.23,58.62 v5(101.23,58.4)
  BOTTOM w0.076: UCPU1.CC1 102.57,55.49 102.57,55.63 102.68,55.74 102.68,56.24 103.21,56.77 103.21,57.24 103.01,57.45 101.82,57.45 101.45,57.81 101.45,58.02 101.37,58.09 101.06,58.09 100.97,58.18 100.97,58.35 101.05,58.43 101.18,58.43 101.2,58.4 v5(101.23,58.4)
  BOTTOM w0.112: v5(60.09,57.58) 60.21,57.7 60.21,58 60.09,58.12 58.98,58.12 58.48,58.62 v7(58.48,59.12) 58.48,59.48 58.25,59.72 58.02,59.72 57.94,59.64 UV6.8 UV6.1 55.44,59.64 55.31,59.76 55.07,59.76 54.52,60.32 54.35,60.32 LV6.4
USB20_N6_R: length 40.5
  IN1 w0.074: v4(39.59,58.76) 39.73,58.62 41.21,58.62 41.75,59.16 44.25,59.16 45.73,57.67 46.24,57.67 v4(46.42,57.86)
  IN3 w0.074: v5(37.91,75.49) 38.05,75.36 38.05,72.59 38.44,72.2 38.44,66.45 38.79,66.1 38.79,63.69 39.41,63.07 39.41,59.81 40.01,59.21 40.01,58.71 39.9,58.6 39.74,58.6 v4(39.59,58.76) ; v5(52.74,60.04) 52.74,60.21 52.83,60.3 52.91,60.3 53.02,60.19 53.02,59.92 52.61,59.52 50.63,59.52 48.8,57.69 46.58,57.69 v4(46.42,57.86)
  BOTTOM w0.112: v5(52.74,60.04) 53.02,60.31 53.43,60.31 LV6.3 ; v5(37.91,75.49) 38.02,75.59 38.02,75.91 37.65,76.28 35.51,76.28 34.43,77.37 JEDP1.7
USB20_N7: length 193.3
  TOP w0.112: LN4.1 259.53,26.96 v7(259.53,28.11) 259.53,29.61 v2(259.66,29.75)
  IN1 w0.074: v4(105.16,50.96) 105.32,50.8 105.58,50.8 105.92,51.14 109.25,51.14 110.48,49.91 110.48,47.67 111.26,46.89 111.26,45.47 111.93,44.8 111.93,43.09 112.44,42.58 112.44,39.17 115.12,36.48 115.12,35.8 117.87,33.05 120.18,33.05 120.4,32.83 123.08,32.83 123.72,32.19 125.64,32.19 126.7,31.13 128,31.13 129.11,30.02 130.54,28.59 130.88,28.08 132.29,26.37 133.54,24.99 134.12,24.4 135.07,23.55 137.59,21.49 141.41,18.54 144.13,16.95 145.37,16.31 147.33,15.45 149.71,14.57 150.36,14.38 154.68,13.35 154.69,13.35 156.62,12.83 157.01,12.74 177.69,12.74 181.87,16.92 198.47,16.92 200.84,19.29 205.99,19.29 208.18,21.48 208.18,24.98 208.82,25.62 209.15,25.62 209.49,25.96 209.49,27.84 211.36,29.71 213.03,29.71 215.88,32.56 215.88,33.08 216.91,34.12 223.15,34.12 223.7,34.68 248.23,34.68 249.56,33.34 253.97,33.34 256.31,31 259.34,31 259.56,30.78 259.56,29.85 v2(259.66,29.75)
  IN3 w0.074: v5(104.93,50.73) v4(105.16,50.96)
USB20_N7_R: length 2.4
  TOP w0.112: LN4.2 259.54,26.05 259.54,25.55 v6(259.72,25.36)
  BOTTOM w0.112: v6(259.72,25.36) 259.52,25.15 259.52,24.99 259.65,24.86 JNGFF1.9
USB20_N8: length 219.4
  TOP w0.112: v2(263.58,32.15) 263.45,32.01 263.45,31.31 266.79,27.97 266.79,25.54 272.05,20.28 272.74,20.28 274.23,18.78 274.23,18.03 LB1.1
  IN1 w0.074: v4(102.39,50.96) 102.55,50.96 102.76,51.17 102.76,52.52 102.86,52.62 102.86,53.07 103.25,53.46 103.6,53.46 105.16,53.46 105.67,53.97 106.84,53.97 107.01,54.13 108.93,54.13 110.59,52.47 110.59,51.27 111.53,50.33 111.53,48.63 111.97,48.19 111.97,47.53 112.99,46.51 112.99,44.89 114.17,43.7 114.17,40.53 116.14,38.57 116.14,36.15 118.28,34.01 120.57,34.01 120.8,33.78 123.48,33.78 124.11,33.15 126.03,33.15 127.07,32.11 128.38,32.11 131.33,29.16 132.66,27.5 133.34,26.74 134.52,25.52 135.89,24.24 136.87,23.38 138.35,22.15 139.74,21.08 141.48,19.83 141.96,19.52 143.28,18.67 144.7,17.84 146.72,16.87 148.05,16.28 149.21,15.84 153.07,14.78 153.13,14.77 153.21,14.75 153.23,14.74 153.24,14.74 154.5,14.39 157.51,13.74 177.16,13.74 182.16,18.73 196.35,18.73 197.93,20.31 205.36,20.31 207.02,21.98 207.02,27.68 214.09,34.74 214.92,34.74 215.49,35.31 217.84,35.31 218.83,36.31 248.09,36.31 249.96,34.43 258.6,34.43 259.92,33.11 261.09,33.11 261.42,32.78 263.27,32.78 263.47,32.58 263.47,32.26 v2(263.58,32.15)
  IN3 w0.074: v5(102.16,50.73) v4(102.39,50.96)
USB20_N8_R: length 3.6
  TOP w0.112: v6(274.43,16.43) 274.24,16.62 274.24,17.13 LB1.2
  BOTTOM w0.112: JUSH1.8 274.55,18.24 274.41,18.09 274.41,17.54 274.24,17.38 274.24,16.62 v6(274.43,16.43)
USB20_N9: length 258.3
  IN1 w0.074: v4(105.62,52.91) 105.8,52.73 107.02,52.73 107.25,52.51 107.66,52.51 108.08,52.92 108.76,52.92 109.26,52.43 109.3,52.43 109.73,52 109.73,51.34 110.96,50.11 110.96,47.87 111.74,47.09 111.74,45.67 112.41,45 112.41,43.29 112.96,42.73 112.96,42.21 113.69,41.48 113.69,40.34 115.63,38.4 115.63,35.98 118.08,33.53 120.37,33.53 120.6,33.31 123.28,33.31 123.91,32.67 125.83,32.67 126.87,31.63 128.18,31.63 130.96,28.85 130.98,28.8 131.17,28.52 132.41,27 133.82,25.48 135.93,23.5 138.47,21.43 140.13,20.18 142.22,18.68 142.85,18.3 145.6,16.77 146.59,16.3 147.69,15.84 149.24,15.25 149.85,15.06 150.85,14.8 150.85,14.79 154.05,14.02 156.73,13.29 156.97,13.24 177.34,13.24 177.39,13.29 177.43,13.29 181.54,17.39 198.26,17.39 200.69,19.83 205.73,19.83 207.57,21.66 207.57,27.45 214.33,34.21 215.12,34.21 215.56,34.64 222.75,34.64 223.27,35.16 248.54,35.16 249.77,33.93 254.4,33.93 256.74,31.59 259.77,31.59 260.26,32.07 262.22,32.07 262.43,31.86 267.71,31.86 268.92,33.07 270.32,33.07 272.43,35.18 281.52,35.18 282.79,36.46 282.79,41.82 284.23,43.26 284.23,44.63 285.57,45.97 285.57,50.44 286.83,51.71 290.62,51.71 297.28,58.36 298.4,58.36 302,61.97 308.34,61.97 308.57,61.74 308.57,61.46 v2(308.65,61.38)
  IN3 w0.074: v5(105.85,52.68) v4(105.62,52.91)
USB20_N9_L: length 2.3
  TOP w0.112: R276.2 308.44,62.17 308.44,62.38 v6(308.63,62.57) 308.42,62.78 308.42,63 L2.4
  BOTTOM w0.112: v6(308.63,62.57) 308.44,62.37 308.44,62.18 R276.2
USB20_N9_R: length 10.5
  TOP w0.112: v6(308.63,67.79) 308.46,67.62 308.46,67.3 308.59,67.16 D3.8 D3.2 308.59,65.53 308.44,65.38 308.44,65.18 308.47,65.15 308.47,64.51 308.44,64.48 308.44,63.89 L2.3
  BOTTOM w0.112: JFP1.11 311.24,65.32 311.09,65.17 309.19,65.17 308.25,66.11 308.25,67.23 308.41,67.39 308.6,67.39 308.72,67.51 308.72,67.71 v6(308.63,67.79)
USB20_N10: length 150.7
  IN1 w0.074: v4(207.22,39.27) 206.4,39.27 206.08,39.59 206.08,40.14 206.54,40.6 207.6,40.6 207.97,40.23 207.97,35.59 202.94,30.56 201.62,30.56 198.54,27.48 197.44,27.48 194.41,24.45 189.88,24.45 189.27,23.85 180.77,23.85 175.22,18.29 158.22,18.29 157.94,18.37 157.48,18.48 154.65,19.25 153.9,19.42 153.09,19.63 152.4,19.81 151.88,19.94 151.87,19.95 150.51,20.39 149.7,20.7 148.86,21.06 148.77,21.11 147.37,21.83 146.26,22.45 146.23,22.47 145.51,22.91 145.5,22.91 143.37,24.31 141.62,25.59 141.61,25.59 141.53,25.65 140.8,26.25 140.27,26.71 140.26,26.71 139.8,27.16 139.33,27.61 139.33,27.61 138.52,28.39 138.51,28.39 138.36,28.54 138.36,28.56 138.18,28.76 138.18,28.76 137.5,29.5 137.49,29.51 137.34,29.67 137.34,29.69 137.08,30.03 136.74,30.34 136.39,30.74 134.58,33.3 132.4,37.2 131.98,37.89 131.39,38.71 129.9,40.41 128.99,40.41 127.7,41.69 127.7,43.35 126.9,44.26 121.2,44.26 120.47,44.99 120.47,48.13 119.62,48.98 119.62,49.76 118.43,50.96 118.43,51.83 117.88,52.38 117.88,53.4 117.26,54.02 117.26,57.09 115.22,59.12 109.22,59.12 108.89,58.79 106.11,58.79 105.8,58.48 104.97,58.48 104.71,58.74 103.82,58.74 102.83,57.75 102.83,57.6 v4(102.94,57.49)
  IN3 w0.074: v4(207.22,39.27) 207.08,39.42 206.84,39.42 v5(206.69,39.27) ; v4(102.94,57.49) 102.93,57.49 102.9,57.45 v5(102.9,57.15)
  BOTTOM w0.076: v5(102.9,57.15) 102.73,56.98 102.73,56.7 102.38,56.34 102.38,55.48 102.47,54.98 102.4,54.76 102.4,54.64 102.48,54.5 102.48,54.28 102.4,54.09 102.4,53.79 102.46,53.73 102.55,53.73 102.68,53.85 UCPU1.CC3
  BOTTOM w0.112: LN6.1 v5(206.69,39.27)
USB20_N10_R: length 2.7
  BOTTOM w0.112: LN6.2 207.82,39.42 209.27,39.42 209.4,39.3 JNGFF3.5
USB20_P1: length 102.9
  IN1 w0.074: v4(103.16,61.84) 103.16,61.97 101.33,63.79 86.69,63.79 86.14,64.34 85.67,64.34 82.22,67.79 69.94,67.79 69.54,67.38 68.26,67.38 67.97,67.09 64.9,67.09 63.68,68.3 63.68,68.44 62.15,69.98 61.97,70.09 59.58,70.78 58.39,70.93 56.64,71.65 56.22,71.86 55.63,72.31 54.83,73.11 53.82,73.11 53.27,73.66 51.45,73.66 50.52,74.59 49.96,74.59 49.17,75.38 42.28,75.38 41.76,74.86 40.21,74.86 40.06,75 37.15,75 36.43,74.29 33.27,74.29 32.04,73.06 32.04,71.97 31.75,71.68 31.75,68.35 30.78,67.39 30.78,66.66 30.51,66.38 30.51,65.63 29.49,64.61 29.49,64.01 28.99,63.52 28.62,63.52 v4(28.45,63.35)
  IN3 w0.074: v4(28.45,63.35) 28.4,63.29 28.25,63.29 28.16,63.37 28.16,63.51 28.09,63.58 27.25,63.58 26.42,64.42 26.42,64.72 v5(26.22,64.91) ; v4(103.16,61.84) v5(103.55,61.84)
  BOTTOM w0.076: v5(103.55,61.84) 103.78,61.84 103.82,61.79 103.82,61.45 103.68,61.31 103.68,60.47 103.66,60.45 103.66,59.91 103.68,59.89 103.68,58.82 104.71,57.79 104.71,56.31 104.11,55.7 104.11,55.38 104.02,55.15 104.04,54.88 104.1,54.79 104.1,54.66 103.95,54.44 103.92,54.41 103.72,54.41 103.55,54.23 103.55,53.93 UCPU1.CE4
  BOTTOM w0.112: v5(26.22,64.91) UT1.L5
USB20_P2: length 100.9
  IN1 w0.074: v4(26.6,71.48) 26.77,71.31 26.77,71.14 26.98,70.92 28.75,70.92 28.99,70.68 30.04,70.68 31.55,72.2 31.55,73.34 32.98,74.77 36.09,74.77 36.81,75.48 40.3,75.48 40.43,75.36 41.58,75.36 42.09,75.86 46.18,75.86 47.23,76.92 50.33,76.92 50.84,76.41 50.84,74.97 51.65,74.16 53.51,74.16 54.04,73.64 55,73.64 55.97,72.67 58.04,72.67 58.37,72.56 59.27,71.89 59.62,71.58 59.63,71.58 59.69,71.55 59.7,71.54 61.24,70.83 62.05,70.63 62.44,70.37 64.16,68.65 64.16,68.5 65.09,67.57 67.77,67.57 68.07,67.87 69.33,67.87 69.74,68.27 82.42,68.27 85.87,64.82 86.34,64.82 86.88,64.27 102.56,64.27 103.91,62.93 103.91,62.85 v4(103.73,62.67)
  IN3 w0.074: v4(103.73,62.67) 103.95,62.9 v5(103.95,63.04) ; v4(26.6,71.48) 26.62,71.46 v5(26.62,71.14)
  BOTTOM w0.076: UT5.L5 26.14,71.85 26.14,71.53 26.21,71.46 26.3,71.46 26.4,71.55 26.51,71.55 26.55,71.51 26.66,71.51 26.79,71.38 26.79,71.25 26.68,71.14 v5(26.62,71.14) ; 103.03,58.65 103.03,58.64 103.05,58.63 103.05,58.35 103.3,58.1 103.74,58.1 v7(103.93,57.9) 104.34,57.49 104.34,56.67 103.55,55.88 103.55,55.22 UCPU1.CE2
  BOTTOM w0.112: v5(103.95,63.04) 103.95,62.84 103.84,62.73 103.4,62.73 103.03,62.36 103.03,58.65
USB20_P3: length 164.6
  IN1 w0.074: v4(104.04,61.22) 103.89,61.37 103.63,61.37 103.53,61.27 102.85,61.27 100.81,63.32 86.49,63.32 85.94,63.86 85.48,63.86 82.02,67.31 70.17,67.31 69.76,66.9 68.46,66.9 68.17,66.61 64.68,66.61 63.2,68.1 63.2,68.24 62.02,69.42 60.28,70.07 57.99,70.51 57.32,70.83 56.77,71.04 55.92,71.48 55.07,72.11 54.6,72.59 53.53,72.59 52.95,73.17 51.24,73.17 50.32,74.09 49.76,74.09 48.95,74.9 42.48,74.9 41.93,74.35 40.04,74.35 39.87,74.52 37.34,74.52 36.63,73.81 33.8,73.81 33.05,73.07 33.05,71.33 32.78,71.06 32.61,71.06 v4(32.46,70.91) ; v2(18.9,14.78) 19.05,14.93 19.05,17.07 v4(18.88,17.24)
  IN3 w0.074: v4(32.46,70.91) 32.63,70.73 32.74,70.73 32.81,70.8 32.81,71.04 32.88,71.11 33.43,71.11 34.92,69.62 34.92,68.09 35.15,67.86 35.15,64.23 35.97,63.41 35.97,57.49 36.2,57.26 36.2,55 36.4,54.8 36.4,53.08 35.97,52.66 35.97,49.53 35.7,49.26 35.7,49.25 34.31,47.87 34.31,46.52 34.02,46.23 34.02,45.27 29.23,40.48 27.86,40.48 27.43,40.9 24.3,40.9 23.21,39.81 22.03,39.81 20.72,38.49 20.26,38.49 18.93,37.17 17.91,37.17 16.87,36.14 15.95,36.14 15.49,35.68 15.49,21.4 19.06,17.83 19.06,17.42 v4(18.88,17.24) ; v5(104.35,61.36) 104.34,61.37 104.1,61.32 v4(104.04,61.22)
  BOTTOM w0.076: v5(104.35,61.36) 104.44,61.45 104.55,61.45 104.62,61.37 104.62,60.74 104.54,60.65 104.54,59.39 104.52,59.38 104.52,58.83 104.54,58.81 104.54,58.67 105.12,58.08 v7(105.12,57.38) 105.12,56.06 104.69,55.63 104.69,55.47 104.69,55.29 104.75,55.01 104.68,54.79 104.68,54.59 104.76,54.46 104.76,54.32 104.68,54.13 104.68,53.81 104.83,53.65 105,53.65 105.12,53.53 UCPU1.CG4
USB20_P4: length 244.7
  IN1 w0.074: v2(286.21,61.55) 286.21,61.7 286.28,61.77 286.44,61.77 286.57,61.64 286.57,60.27 283.76,57.46 283.76,50.58 281.8,48.62 281.8,45.42 281.05,44.67 281.05,38.93 280.65,38.52 279.84,38.52 279.71,38.66 267.89,38.66 267.5,38.28 250.85,38.28 248.71,40.41 243.44,40.41 241.96,41.9 227.79,41.9 227.33,42.36 218.99,42.36 218.54,41.9 216.38,41.9 216.09,42.2 214.01,42.2 212.91,41.09 211.72,41.09 208.42,37.79 208.42,35.46 203.21,30.26 201.71,30.26 198.58,27.12 197.61,27.12 194.47,23.98 190.08,23.98 189.49,23.4 180.72,23.4 175.33,18.01 158.17,18.01 155.65,18.61 154.02,19.08 154.01,19.08 152.82,19.33 150.76,19.99 150.35,20.16 150.25,20.2 150.24,20.2 148.87,20.73 148.58,20.86 148.36,20.96 146.71,21.81 146.24,22.09 143.05,24.16 142.7,24.4 142.05,24.87 141.09,25.62 140.37,26.22 137.75,28.71 135.98,30.73 134.1,33.31 132.2,36.98 131.04,38.66 129.87,39.97 129.18,39.97 129.08,39.87 128.4,39.87 127.38,40.88 126.67,40.88 125.36,42.2 125.36,42.56 123.94,43.98 121.09,43.98 120.19,44.88 120.19,47.73 118.67,49.26 118.67,50.31 118.02,50.96 118.02,51.81 117.52,52.3 117.52,53.35 116.98,53.9 116.98,56.96 115.09,58.84 109.33,58.84 109,58.51 106.33,58.51 106.03,58.21 104.79,58.21 104.54,58.46 103.94,58.46 103.64,58.17 103.64,57.89 103.56,57.8 v4(103.47,57.8)
  IN3 w0.074: v5(103.68,57.28) 103.76,57.37 103.76,57.51 v4(103.47,57.8)
  BOTTOM w0.076: v5(103.68,57.28) 103.76,57.21 103.76,56.78 103.14,56.16 103.14,55.2 102.94,55 102.94,54.37 UCPU1.CD4
USB20_P6: length 66
  IN1 w0.074: v4(89.65,61.72) 89.82,61.89 89.82,62.17 90.04,62.39 100.14,62.39 101.54,60.99 v4(101.54,58.82)
  IN3 w0.074: v4(89.65,61.72) 89.51,61.58 89.51,61.4 89.59,61.32 89.85,61.32 89.97,61.2 89.97,57.87 88.47,56.37 87.99,56.37 87.29,55.68 86.96,55.68 86.59,55.3 82.79,55.3 82.3,55.79 82.3,55.97 80.37,57.89 76.71,57.89 76.47,57.99 70.84,57.99 70.57,57.72 61.18,57.72 60.73,57.27 60.51,57.27 60.43,57.35 60.43,57.48 v5(60.54,57.59) ; v4(101.54,58.82) 101.54,58.47 v5(101.61,58.39)
  BOTTOM w0.076: UCPU1.CC2 102.78,55.07 102.89,55.19 102.95,55.31 102.95,55.42 102.88,55.65 102.84,55.7 102.84,56.17 103.38,56.7 103.38,57.31 103.07,57.61 101.94,57.61 101.61,57.93 v5(101.61,58.39)
  BOTTOM w0.112: LV6.1 54.32,60.52 54.6,60.52 55.16,59.97 55.33,59.97 55.4,60.04 UV6.2 UV6.7 57.91,60.04 58.03,59.92 58.33,59.92 58.72,59.53 58.72,58.67 59.07,58.32 60.17,58.32 60.42,58.08 60.42,57.71 v5(60.54,57.59)
USB20_P6_R: length 41.4
  IN1 w0.074: v4(46.42,57.32) 46.27,57.47 45.65,57.47 44.17,58.96 41.84,58.96 41.29,58.42 39.77,58.42 v4(39.6,58.24)
  IN3 w0.074: v5(38.35,75.48) 38.34,75.47 38.31,75.47 38.25,75.41 38.25,72.68 38.65,72.28 38.65,66.53 38.99,66.18 38.99,63.77 39.61,63.15 39.61,59.89 40.21,59.29 40.21,58.62 39.99,58.4 39.76,58.4 v4(39.6,58.24) ; v4(46.42,57.32) 46.58,57.49 48.88,57.49 50.71,59.32 52.7,59.32 53.22,59.84 53.22,60.28 52.99,60.5 52.83,60.5 52.76,60.57 v5(52.76,60.76)
  BOTTOM w0.112: v5(38.35,75.48) 38.22,75.6 38.22,76 37.73,76.49 35.6,76.49 34.83,77.26 JEDP1.8 ; DV10.1 v5(52.76,60.76) 53,60.52 53.45,60.52 LV6.2
USB20_P7: length 193.4
  TOP w0.112: LN4.4 259.32,26.94 259.32,27.79 259.29,27.82 259.29,28.4 259.32,28.43 259.32,29.64 v2(259.2,29.76)
  IN1 w0.074: v4(105.16,50.31) 105.16,50.5 105.26,50.6 105.66,50.6 106,50.94 109.16,50.94 110.28,49.83 110.28,47.59 111.06,46.81 111.06,45.38 111.73,44.72 111.73,43.01 112.24,42.49 112.24,39.09 114.92,36.4 114.92,35.72 117.79,32.85 120.09,32.85 120.32,32.63 123,32.63 123.63,31.99 125.55,31.99 126.61,30.93 127.92,30.93 129.03,29.82 130.39,28.46 130.72,27.96 132.14,26.24 133.4,24.85 133.98,24.25 134.94,23.4 137.46,21.34 141.3,18.37 144.03,16.78 145.28,16.13 147.25,15.26 149.65,14.38 150.31,14.18 154.64,13.16 156.57,12.63 156.99,12.54 177.77,12.54 181.95,16.72 198.55,16.72 200.93,19.09 206.07,19.09 208.38,21.4 208.38,24.89 208.9,25.42 209.23,25.42 209.69,25.88 209.69,27.76 211.44,29.51 213.11,29.51 216.08,32.48 216.08,33 217,33.92 223.23,33.92 223.79,34.48 248.15,34.48 249.48,33.14 253.89,33.14 256.23,30.8 259.26,30.8 259.36,30.7 259.36,30.1 259.28,30.03 259.15,30.03 259.07,29.95 259.07,29.82 259.13,29.76 v2(259.2,29.76)
  IN3 w0.074: v5(104.93,50.08) v4(105.16,50.31)
USB20_P7_R: length 2.4
  TOP w0.112: v6(259.13,25.35) 259.33,25.56 259.33,26.05 LN4.3
  BOTTOM w0.112: v6(259.13,25.35) 259.3,25.18 259.3,25 259.15,24.85 JNGFF1.7
USB20_P8: length 219.3
  TOP w0.112: LB1.4 274.03,18.02 274.03,18.7 272.69,20.04 v7(272.36,20.04) 272,20.04 266.58,25.46 266.58,27.89 263.24,31.23 263.24,32.07 v2(263.16,32.15)
  IN1 w0.074: v4(102.39,50.31) 102.46,50.31 102.72,50.57 102.72,50.84 102.96,51.08 102.96,52.43 103.06,52.53 103.06,52.99 103.33,53.26 103.68,53.26 105.24,53.26 105.76,53.77 106.93,53.77 107.09,53.93 108.85,53.93 110.39,52.39 110.39,51.18 111.33,50.24 111.33,48.55 111.77,48.11 111.77,47.45 112.79,46.43 112.79,44.8 113.97,43.62 113.97,40.45 115.94,38.48 115.94,36.06 118.2,33.81 120.49,33.81 120.71,33.58 123.39,33.58 124.03,32.95 125.95,32.95 126.99,31.9 128.3,31.9 131.18,29.02 132.51,27.37 133.19,26.6 134.38,25.38 135.76,24.09 136.74,23.23 138.23,22 139.62,20.92 141.37,19.66 141.85,19.35 143.18,18.49 144.61,17.66 146.64,16.69 147.97,16.09 149.14,15.65 153.02,14.59 153.08,14.57 153.1,14.57 153.18,14.55 153.18,14.55 154.45,14.2 157.48,13.54 177.25,13.54 182.24,18.53 196.43,18.53 198.01,20.11 205.44,20.11 207.22,21.89 207.22,27.59 214.17,34.54 215,34.54 215.58,35.11 217.92,35.11 218.92,36.11 248,36.11 249.88,34.23 258.52,34.23 259.84,32.91 261,32.91 261.34,32.58 263.19,32.58 263.27,32.5 263.27,32.25 v2(263.16,32.15)
  IN3 w0.074: v4(102.39,50.31) v5(102.16,50.08)
USB20_P8_R: length 3.6
  TOP w0.112: v6(273.85,16.43) 274.03,16.61 274.03,17.13 LB1.3
  BOTTOM w0.112: JUSH1.9 274.06,18.24 274.2,18.09 274.2,17.63 274.04,17.46 274.04,16.62 v6(273.85,16.43)
USB20_P9: length 258.4
  IN1 w0.074: v2(308.08,61.38) 308.28,61.38 308.37,61.47 308.37,61.66 308.26,61.77 302.09,61.77 298.48,58.16 297.36,58.16 290.71,51.5 286.92,51.5 285.77,50.36 285.77,45.89 284.43,44.54 284.43,43.17 282.99,41.74 282.99,36.37 281.6,34.98 272.52,34.98 270.41,32.87 269.01,32.87 267.79,31.66 262.35,31.66 262.13,31.87 260.34,31.87 259.86,31.39 256.65,31.39 254.32,33.72 249.69,33.72 248.45,34.96 223.35,34.96 222.84,34.44 215.64,34.44 215.21,34.01 214.42,34.01 207.77,27.36 207.77,21.58 205.82,19.62 200.78,19.62 198.34,17.19 181.62,17.19 177.51,13.09 177.47,13.09 177.42,13.04 156.95,13.04 156.68,13.1 154,13.83 150.8,14.6 150.79,14.6 150.79,14.6 149.91,14.83 149.79,14.87 149.18,15.06 149.17,15.06 147.57,15.67 147.62,15.65 146.52,16.11 146.51,16.11 145.51,16.59 142.81,18.09 142.74,18.12 142.11,18.51 140.01,20.01 138.34,21.27 135.8,23.35 133.67,25.34 132.26,26.86 131,28.4 130.8,28.71 130.79,28.74 128.1,31.43 126.79,31.43 125.75,32.47 123.83,32.47 123.19,33.11 120.51,33.11 120.29,33.33 118,33.33 115.43,35.9 115.43,38.31 113.49,40.26 113.49,41.4 112.76,42.13 112.76,42.65 112.2,43.2 112.2,44.91 111.54,45.58 111.54,47.01 110.76,47.79 110.76,50.02 109.53,51.26 109.53,51.92 109.21,52.23 109.17,52.23 108.68,52.72 108.17,52.72 107.75,52.31 107.17,52.31 106.94,52.53 105.79,52.53 105.62,52.36 v4(105.62,52.26)
  IN3 w0.074: v4(105.62,52.26) v5(105.85,52.03)
USB20_P9_L: length 2.2
  TOP w0.112: R277.2 308.24,62.13 308.24,62.36 v6(308.05,62.55) 308.22,62.73 308.22,63.01 L2.1
  BOTTOM w0.112: v6(308.05,62.55) 308.24,62.36 308.24,62.13 R277.2
USB20_P9_R: length 10.6
  TOP w0.112: L2.2 308.24,63.92 v7(308.24,64.83) 308.24,65.4 308.09,65.55 D3.1 D3.9 308.09,67.15 308.26,67.32 308.26,67.59 v6(308.05,67.79)
  BOTTOM w0.112: v6(308.05,67.79) 308.05,66.03 309.11,64.97 311.09,64.97 311.24,64.82 JFP1.13
USB20_P10: length 150.7
  IN1 w0.074: v4(207.21,39.78) 207.21,40.06 207.12,40.15 206.92,40.15 206.84,40.07 206.84,39.55 206.77,39.47 206.48,39.47 206.28,39.67 206.28,40.06 206.62,40.4 207.52,40.4 207.77,40.15 207.77,35.67 202.86,30.76 201.54,30.76 198.46,27.68 197.35,27.68 194.33,24.65 189.79,24.65 189.19,24.05 180.69,24.05 175.13,18.49 158.25,18.49 157.99,18.56 157.53,18.67 154.7,19.44 153.95,19.62 153.14,19.83 153.01,19.86 153,19.88 152.99,19.88 152,20.11 150.58,20.58 149.78,20.89 148.94,21.25 148.85,21.29 147.46,22 146.34,22.64 145.61,23.08 143.49,24.48 141.73,25.76 141.66,25.81 140.93,26.4 140.4,26.85 140.4,26.86 139.47,27.75 139.47,27.76 138.66,28.53 138.65,28.54 138.56,28.63 138.55,28.65 138.33,28.89 138.32,28.9 137.64,29.64 137.64,29.65 137.55,29.75 137.55,29.76 137.22,30.17 136.88,30.48 136.54,30.87 134.75,33.4 132.57,37.3 132.15,38.01 131.55,38.83 129.99,40.61 129.07,40.61 127.9,41.78 127.9,43.43 126.99,44.46 121.29,44.46 120.67,45.08 120.67,48.22 119.82,49.07 119.82,49.84 118.63,51.04 118.63,51.91 118.08,52.46 118.08,53.48 117.46,54.11 117.46,57.17 115.3,59.33 109.14,59.33 108.81,58.99 106.02,58.99 105.71,58.68 105.05,58.68 104.79,58.94 103.74,58.94 102.63,57.83 102.63,57.68 v4(102.43,57.49)
  IN3 w0.074: v5(102.51,57.16) 102.51,57.41 v4(102.43,57.49) ; v4(207.21,39.78) 207.04,39.62 206.84,39.62 v5(206.69,39.77)
  BOTTOM w0.076: v5(102.51,57.16) 102.57,57.09 102.57,56.77 102.21,56.41 102.21,55.46 102.3,54.99 102.24,54.79 102.24,54.59 102.32,54.46 102.32,54.32 102.24,54.13 102.24,53.72 102.39,53.56 102.54,53.56 UCPU1.CC4
  BOTTOM w0.112: LN6.4 v5(206.69,39.77)
USB20_P10_R: length 2.7
  BOTTOM w0.112: JNGFF3.3 209.41,39.8 209.24,39.63 207.8,39.63 LN6.3
USB_OC0#: length 125.9
  TOP w0.127: v2(106.77,52.04) 107.34,52.04 RC53.1 ; v2(52.04,30.52) 51.46,31.11 51.46,31.97 52.31,32.82 95.14,32.82 v1(97.12,34.8) 97.12,35.03 v2(97.61,35.52) ; UI5.13 v6(21.81,12.48)
  IN1 w0.061: v2(106.77,52.04) 106.54,52.07 106.47,52.01 v4(106.44,52.01) ; v4(52.06,30.94) 52.06,30.54 v2(52.04,30.52) ; v4(97.9,36.19) 97.61,35.89 v2(97.61,35.52)
  IN2 w0.061: v4(97.9,36.19) 97.88,36.21 97.88,36.29 99,37.41 99,38.25 99.2,38.45 99.94,38.45 100.16,38.68 100.16,39.54 100.34,39.72 102.47,39.72 103.57,40.82 103.57,43.66 103.35,43.88 103.12,43.88 102.91,44.09 102.91,47.91 103.19,48.18 103.38,48.18 103.57,48.37 103.57,48.84 103.71,48.98 104.16,48.98 105.13,49.94 105.34,49.94 105.88,50.48 105.88,51.51 106.38,52.01 v4(106.44,52.01)
  IN3 w0.061: v6(21.81,12.48) 21.81,12.05 22.72,11.14 25.77,11.14 27.8,13.18 36.64,13.18 37.89,11.93 45.6,11.93 47.71,14.03 51.8,14.03 52.26,14.48 52.26,15.56 51.83,16 51.83,16.68 52.25,17.1 52.25,28.05 52.06,28.24 v4(52.06,30.94) ; v5(106.77,52.03) 106.48,52.03 106.46,52.01 v4(106.44,52.01)
USB_OC1#: length 224.2
  TOP w0.127: RC54.1 RC459.1 107.34,52.67 v2(107.64,52.98)
  IN1 w0.061: v2(107.64,52.98) 107.62,53.01 v4(107.31,53.01) ; v4(217.54,43.74) 217.8,44.01 224.83,44.01 225.55,44.72 231.56,44.72 232.23,44.05 248.45,44.05 250.14,42.36 252.14,42.36 252.89,43.1 272.78,43.1 281.24,51.57 281.24,59.71 283.63,62.1 284.66,62.1 285.88,63.32 288.51,63.32 v2(288.51,63.32)
  IN2 w0.061: v4(217.54,43.74) 215.64,43.74 213.68,41.79 207.7,41.79 206.12,40.21 206.12,39.08 205.29,38.25 205.19,38.25 197.21,38.25 193.87,34.91 190.09,34.91 189.32,34.14 189.32,33.86 176.03,20.57 155.8,20.57 155.55,20.82 149.7,20.82 145.44,25.08 143.04,25.08 133.27,34.85 130.34,34.85 121.99,43.21 121,43.21 119.54,44.67 119.54,47.57 119.07,48.04 116.01,48.04 113.89,50.16 112.47,50.16 110.04,52.6 107.72,52.6 v4(107.31,53.01)
  IN3 w0.076: v4(107.31,53.01) 106.98,52.68 v5(106.77,52.68)
USB_OC2#: length 3.1
  TOP w0.127: RC460.1 106.65,50.63 RC55.1 106.13,51.42 v1(105.94,51.61)
  IN1 w0.061: v4(106.61,50.61) 106.6,50.6 v2(106.18,50.6)
  IN3 w0.061: v4(106.61,50.61) 106.6,50.62 v5(106.25,50.62)
  BOTTOM w0.127: UCPU1.CK8 106.68,50.63 v5(106.25,50.62)
USB_OC3#: length 7.6
  BOTTOM w0.076: UCPU1.CK9 106.81,50.05 109.55,50.05
  BOTTOM w0.127: 109.55,50.05 111.23,51.72 RC623.1 RC624.1
USB_POWERSHARE_ENL#: length 299.6
  TOP w0.127: v2(269.98,46.88) 269.26,46.88 v1(269.05,46.67) ; v6(16.79,13.46) 16.81,13.48 UI5.6
  IN1 w0.061: v2(269.98,46.88) v4(269.98,46.48) ; v6(16.79,13.46) 16.39,13.46 15.94,13.91 15.94,16.5 19.5,20.06 25.8,20.06 26.45,19.42 v4(26.45,18.36) ; v4(264.61,54.67) 264.48,54.81 v2(264.23,54.81)
  IN2 w0.061: v4(264.61,54.67) 264.72,54.78 265.86,54.78 266.18,54.46 268.84,54.46 270.64,52.67 270.64,48.56 269.98,47.9 v4(269.98,46.48) 269.98,45.94 268.42,44.38 267.19,44.38 266.09,43.29 264.12,43.29 263.54,42.71 257.04,42.71 256.77,42.98 254.17,42.98 250.75,39.56 237.85,39.56 217.15,18.86 212.12,18.86 211.8,18.55 202.5,18.55 200.9,16.95 182.63,16.95 179.08,13.4 152.76,13.4 152.49,13.67 133.92,13.67 133.6,13.98 133.6,16.16 131.74,18.03 128.58,18.03 126.8,18.75 123.4,18.75 122.93,18.28 113.9,18.28 109.33,13.71 104,13.71 103.69,14.02 101.01,14.02 100.81,13.82 97.13,13.82 96.67,13.36 58.1,13.36 57.03,14.44 53.53,14.44 53.38,14.29 52.76,14.29 52.27,13.79 49.21,13.79 46.16,16.84 40.48,16.84 40.02,16.38 37.82,16.38 37.08,17.13 29.5,17.13 29.5,17.13 28.17,17.13 26.94,18.36 v4(26.45,18.36)
USB_POWERSHARE_ENR#: length 47.9
  TOP w0.102: UE1.K3 264.02,54.01 263.72,53.71 v2(263.72,53.71)
  TOP w0.127: v1(286.65,59.1) 287.51,59.95 UI4.6
  IN1 w0.061: v4(287.42,59.83) 287.51,59.91 v2(287.51,60.17) ; v2(263.72,53.71) 262.83,53.71 262.02,52.9 260.13,52.9 259.68,53.35 259.36,53.35 v2(259.22,53.49) 257.96,53.49 v4(257.01,54.44)
  IN2 w0.061: v4(287.42,59.83) 285.25,59.83 284.61,60.47 276.68,60.47 276.36,60.15 276.36,59.77 273.63,57.04 273.09,57.04 272.88,57.24 271.31,57.24 270.35,56.29 270.35,56.29 270.18,56.12 268.63,56.12 267.72,57.03 267.19,57.03 266.74,57.48 266.74,58.48 266.61,58.61 266.31,58.61 265.96,58.26 265.96,58.07 265.8,57.91 265.31,57.91 264.68,57.27 263.13,57.27 262.81,57.59 262.81,58.03 262.62,58.22 262.1,58.22 259.91,56.03 258.04,56.03 257.01,55 v4(257.01,54.44)
USB_POWERSHARE_VBUS_EN_L: length 299.1
  TOP w0.127: UI5.5 17.12,13.98 17.03,13.89 16.42,13.89 v2(16.36,13.95) 16.51,14.1 16.61,14.1 16.72,14.22 16.72,14.94 v1(16.25,15.41)
  IN1 w0.061: v4(25.92,19.25) 25.92,19.52 25.5,19.94 19.55,19.94 16.09,16.48 16.09,14.22 v2(16.36,13.95) ; v2(263.43,54.8) 263.67,54.8 v4(263.8,54.67)
  IN2 w0.061: v4(263.8,54.67) 264.13,54.34 264.74,54.34 265.01,54.61 265.76,54.61 266.04,54.34 268.79,54.34 270.51,52.62 270.51,48.67 269,47.16 269,45.61 267.9,44.51 267.12,44.51 266.03,43.41 264.07,43.41 263.49,42.84 257.09,42.84 256.82,43.11 254.12,43.11 250.95,39.95 238.06,39.95 217.69,19.58 212.66,19.58 211.75,18.68 202.45,18.68 200.85,17.07 182.58,17.07 179.03,13.53 152.81,13.53 152.55,13.79 133.98,13.79 133.73,14.05 133.73,16.22 131.79,18.15 128.6,18.15 126.82,18.88 123.35,18.88 122.88,18.41 113.85,18.41 109.28,13.84 104.05,13.84 103.74,14.15 100.96,14.15 100.76,13.95 97.07,13.95 96.62,13.49 58.16,13.49 57.07,14.57 53.48,14.57 53.33,14.41 52.71,14.41 52.21,13.92 49.26,13.92 46.21,16.98 40.43,16.98 39.96,16.51 37.87,16.51 37.13,17.25 29.56,17.25 29.55,17.26 28.23,17.26 26.23,19.25 v4(25.92,19.25)
USB_POWERSHARE_VBUS_EN_R: length 46.9
  TOP w0.127: RI68.1 288.26,42.2 v2(288.25,42.21) ; v1(284.87,59.33) 284.63,59.57 v6(284.63,59.87) 284.62,59.89 RI123.2 285.24,60.41 285.9,59.75 286.88,59.75 287.01,59.88 UI4.5 ; UE1.G5 265.84,56.58 266.2,56.95 266.2,57.37 v2(266.23,57.4)
  IN1 w0.061: v2(266.23,57.4) 266.25,57.42 v4(266.25,57.74) ; v4(286.9,49.1) 287.92,48.09 287.92,45.04 288.77,44.19 288.77,43.22 288.25,42.7 v2(288.25,42.21)
  IN2 w0.061: v6(284.63,59.87) 284.17,60.34 276.73,60.34 276.49,60.1 276.49,59.72 273.66,56.89 272.99,56.89 272.76,57.12 271.36,57.12 270.41,56.16 270.4,56.16 270.24,56 268.53,56 267.64,56.89 267.1,56.89 v4(266.25,57.74)
  IN3 w0.061: v4(286.9,49.1) 284.63,51.37 v6(284.63,59.87)
USBCOMP: length 0.7
  IN1 w0.061: v2(103.67,52.66) 103.64,52.66 v4(103.39,52.84)
  IN3 w0.076: v4(103.39,52.84) 103.23,52.68 v5(103.08,52.68)
USH_DET#: length 68.8
  TOP w0.127: UE1.C13 272.59,59.61 273.89,60.9 273.89,60.98 274.27,61.36 v2(274.38,61.36)
  IN1 w0.061: v4(278.53,61.39) 277.63,62.29 275.63,62.29 274.99,61.65 274.81,61.65 274.52,61.36 v2(274.38,61.36)
  IN3 w0.061: v5(276.59,16.48) 276.59,20.49 277.46,21.36 277.46,23.57 279.02,25.13 279.02,33.42 280.1,34.5 280.1,35.22 279.51,35.81 279.51,51.93 279.11,52.33 279.11,60.81 v4(278.53,61.39)
  BOTTOM w0.127: v5(276.59,16.48) 275.12,15 268.19,15 266.82,16.38 266.82,16.99 265.55,18.25 JUSH1.26
USH_EXPANDER_SMBCLK: length 146.1
  TOP w0.127: v2(254.67,59.45) v1(253.54,59.45) ; v2(264.41,60.05) 264.41,60.23 264.24,60.41
  IN1 w0.061: v6(200.4,64.85) 200.4,65.61 201.76,66.97 219.89,66.97 222.43,64.44 233.75,64.44 235.11,63.07 247.12,63.07 249.56,60.64 252.26,60.64 253.54,59.35 254.57,59.35 v2(254.67,59.45) 254.67,59.41 254.73,59.35 256.88,59.35 257.4,59.87 257.4,60.64 257.85,61.09 260.7,61.09 261.62,60.16 263.85,60.16 v4(263.97,60.05) v2(264.41,60.05)
  IN3 w0.061: v4(263.97,60.05) 264.09,59.93 265.07,59.93 265.98,59.02 265.98,58.11 265.78,57.91 265.5,57.91 265.37,57.78 265.37,57.37 265.7,57.04 267.16,57.04 267.59,57.48 267.59,58.19 268.15,58.75 268.15,61.74 270.02,63.6 270.7,63.6 272.31,65.21 274.05,65.21 275.1,64.16 275.1,62.54 276.49,61.16 276.49,52.06 277.8,50.76 277.8,44.3 276.74,43.25 276.74,42.72 277.94,41.52 277.94,38.72 277.02,37.8 277.02,31.19 275.5,29.67 275.5,28.48 276.74,27.23 276.74,25.13 275.62,24 275.62,23.1 272.89,20.37 v5(272.89,19.77)
  BOTTOM w0.127: Q12.6 198.8,63.51 199.08,63.24 199.9,63.24 200.4,63.74 v6(200.4,64.85) ; v5(272.89,19.77) 273.06,19.6 JUSH1.11
USH_EXPANDER_SMBDAT: length 149.2
  TOP w0.102: UE1.E5 v2(265.83,58)
  IN1 w0.061: v2(259.18,58.77) 259.34,58.77 259.83,58.28 261.13,58.28 262.09,59.24 263.19,59.24 263.57,58.86 264.02,58.86 264.97,57.91 265.73,57.91 v2(265.83,58) 265.83,58.05 v4(265.6,58.28) 265.82,58.28 265.99,58.45 265.99,58.68 265.84,58.83 265.84,59.28 265.11,60 264.76,60 264.46,59.71 263.79,59.71 263.52,59.98 261.54,59.98 260.62,60.9 257.93,60.9 257.59,60.56 257.59,59.8 256.96,59.16 253.47,59.16 252.18,60.45 249.48,60.45 247.05,62.88 235.04,62.88 233.67,64.25 222.35,64.25 219.81,66.78 202.45,66.78 v6(200.89,65.22)
  IN3 w0.061: v4(265.6,58.28) 265.18,57.86 265.18,57.29 265.62,56.85 267.23,56.85 267.78,57.4 267.78,58.11 268.34,58.67 268.34,61.66 270.1,63.42 270.78,63.42 272.39,65.02 273.97,65.02 274.91,64.08 274.91,62.47 276.3,61.08 276.3,51.99 277.61,50.68 277.61,44.38 276.56,43.33 276.56,42.64 277.75,41.44 277.75,38.79 276.84,37.88 276.84,31.27 275.31,29.75 275.31,28.4 276.56,27.16 276.56,25.21 275.43,24.08 275.43,23.18 272.71,20.45 272.7,20.45 272.43,20.19 v5(272.43,19.63)
  BOTTOM w0.127: JUSH1.12 272.55,19.51 v5(272.43,19.63) ; v6(200.89,65.22) 200.65,65.46 Q12.3
USH_PWR_STATE#: length 68.6
  TOP w0.127: UE1.H2 263.4,55.61 262.96,55.16 261.02,55.16 v2(260.49,54.63)
  IN1 w0.061: v2(260.49,54.63) 260.39,54.73 v4(260.11,54.73)
  IN3 w0.061: v5(254.06,28.93) 254.24,28.93 256.62,31.31 260.02,31.31 260.72,32.01 262.97,32.01 264.84,33.89 264.84,34.6 264.65,34.79 264.65,35.92 265.03,36.3 265.03,42.63 263.45,44.21 263.45,46.6 262.29,47.76 262.29,49.16 261.76,49.69 260.35,49.69 258.92,51.11 255.83,51.11 255.47,51.47 255.47,53.31 255.69,53.52 258.9,53.52 v4(260.11,54.73)
  BOTTOM w0.127: JUSH1.22 267.55,19.28 267.13,19.7 263.44,19.7 262.76,20.37 v1(259.79,20.37) 258.16,20.37 254.86,23.67 254.86,26.61 254.4,27.07 254.4,28.59 v5(254.06,28.93)
UVP_FAULT: length 111.2
  TOP w0.127: v2(49.3,30.86) 49.83,30.86 50.25,31.29 50.29,31.29 v1(51.54,32.53) 52.08,33.07 94.71,33.07 97.59,35.95 99.7,35.95 100.27,36.52 102.18,36.52 102.31,36.39 105.53,36.39 105.76,36.62 106.13,36.62 106.2,36.69 108.94,36.69 110.67,38.42 117.54,38.42 118.43,39.31 120.11,39.31 120.39,39.03 121.5,39.03 122.19,39.72 125.43,39.72 125.84,40.13 v2(125.95,40.13) ; PD1502.2 36.75,30.65 37.64,31.54 PU1501.1 37.64,32.47 36.25,33.86 36.25,36.38 PQ1507.2 35.87,37.33 v2(36.54,38)
  IN1 w0.061: v2(49.3,30.86) 48.83,30.86 47.22,32.46 47.22,34.28 45.7,35.8 42.74,35.8 40.54,38 v2(36.54,38) ; v2(125.95,40.13) 126.71,39.38 127.05,39.38 128.56,37.87 v4(128.93,37.87)
  IN3 w0.061: v5(129.3,37.87) v4(128.93,37.87)
VCI_IN1#: length 3.3
  TOP w0.127: 265.84,60.41 265.45,60.79 265.45,61.51 265.59,61.65 265.59,63.28 265.47,63.4 RE135.1
VCI_IN2#: length 7.1
  TOP w0.102: UE1.D4 264.84,58.62 v2(264.73,58.62)
  IN1 w0.061: v2(264.73,58.62) 264.64,58.62 264.18,59.07 263.65,59.07 263.29,59.43 262.02,59.43 261.05,58.46 259.91,58.46 259.19,59.19 259.19,59.35 v2(259.18,59.36)
VCI_IN3#: length 7.4
  TOP w0.102: v2(265.13,58.41) 265.13,58.1 UE1.E4
  IN1 w0.061: v2(259.22,59.91) 259.49,59.64 260.03,59.64 260.37,59.3 261.15,59.3 261.5,59.66 262.98,59.66 263.08,59.56 263.36,59.56 263.69,59.23 264.2,59.23 264.53,58.9 264.81,58.9 265.13,58.58 v2(265.13,58.41)
VDIFF_GT: length 4.3
  TOP w0.127: v2(47.57,61.92) v1(47.57,60.5)
  TOP w0.254: PC907.1 PR938.1 47.14,62.35 v2(47.57,61.92)
  IN1 w0.203: v4(47.22,61.88) 47.53,61.88 v2(47.57,61.92)
  IN3 w0.254: v5(46.78,61.52) 47.14,61.88 v4(47.22,61.88)
VDIFF_IA: length 4.7
  TOP w0.127: v2(45.75,61.62) 46.07,61.62 46.27,61.42 v1(46.27,60.2)
  TOP w0.254: PC904.1 PR929.1 45.39,62.25 45.75,61.88 v2(45.75,61.62)
  IN1 w0.061: v2(45.75,61.62) 45.53,61.39 v4(45.53,61.38)
  IN3 w0.061: v4(45.53,61.38) 45.46,61.44 v5(45.18,61.44)
VDIFF_SA: length 2.7
  BOTTOM w0.203: PC912.1 50.79,61.08 PR943.1 49.64,61.08 49.05,60.49 PU900.14
VFB_GT: length 4.3
  TOP w0.127: v1(48.17,61.69) 47.97,61.89 v2(47.97,62.14)
  TOP w0.254: PR940.1 48.06,64.56 PC907.2 PR938.2 47.98,62.68 47.98,62.14 v2(47.97,62.14)
  IN1 w0.203: v2(47.97,62.14) 47.97,61.75 v4(47.97,61.74)
  IN3 w0.254: v5(47.19,61.44) 47.67,61.44 v4(47.97,61.74)
VFB_IA: length 4.6
  TOP w0.127: v1(46.71,61.77) 46.3,62.17 v2(46.3,62.76)
  TOP w0.254: PR933.1 46.3,64.56 PC904.2 v2(46.3,62.76)
  IN1 w0.061: v2(46.3,62.76) 46.29,62.77 v4(45.85,62.77)
  IN3 w0.061: v4(45.85,62.77) 45.85,62.54 45.63,62.32 45.63,62.07 v5(45.59,62.05)
  BOTTOM w0.127: v5(45.59,62.05) 45.59,62.05 PU900.7
VFB_SA: length 6.8
  TOP w0.127: PR945.1 49,62.14 v6(49.16,61.97) 49.13,61.94 v1(49.13,60.76) 49.13,60.44 v6(49.37,60.2)
  BOTTOM w0.127: v6(49.37,60.2) 49.27,60.09 PU900.15
  BOTTOM w0.203: v6(49.16,61.97) 49.18,61.99 PR943.2 51.09,61.99 51.78,61.31 PC912.2
VID0_PRIM_CORE: length 3.7
  BOTTOM w0.254: PU1401.4 126.85,44.97 127.11,44.71 127.46,44.71 127.83,44.33 PR1428.1 127.86,44.16 PR1427.1 128.69,43.4 PR1421.2
VID0_VCCIO: length 2.2
  BOTTOM w0.203: PU1400.4 101.77,18.52 101.55,18.31 PR1411.1 PR1406.2
VID1_PRIM_CORE: length 5
  TOP w0.127: v6(128.88,45.07) v3(128.1,45.07)
  BOTTOM w0.254: PU1401.3 127.35,45.37 127.66,45.07 v6(128.88,45.07) PR1429.1 130.29,45.07 PR1426.1 130.35,44.23 PR1420.2
VID1_VCCIO: length 2.9
  BOTTOM w0.203: PU1400.3 102.07,18.02 101.7,17.66 101.7,17.1 101.38,16.78 PR1410.1 PR1405.2
VIDSCLK_R: length 3.3
  BOTTOM w0.076: 77.98,57.2 77.58,56.8 76.91,56.8 76.54,56.44 76.54,55.94 76.72,55.76 76.72,55.51 76.86,55.38 UCPU1.AA1
  BOTTOM w0.127: RC159.1 77.98,57.2
VIDSOUT_R: length 3.6
  BOTTOM w0.076: RC157.1 77.18,56.97 76.84,56.97 76.38,56.5 76.38,55.89 76.57,55.7 76.57,55.34 76.95,54.95 UCPU1.AA2
VOUT_PRIM_CORE: length 2.4
  BOTTOM w0.254: PR1418.1 126.99,50.32 PR1419.1 126.85,50.18 PU1401.12
VOUT_VCCIO: length 2.2
  BOTTOM w0.127: PU1400.12 106.22,18.52 106.56,18.18 PR1409.1 PR1424.1
VR_SVID_ALERT#: length 40.2
  TOP w0.127: PR925.1 45.31,51.42 45.96,50.77 v1(46.13,50.77) 46.95,50.77 47.35,51.17 48.02,51.17 v2(48.1,51.09)
  IN1 w0.061: v2(48.1,51.09) 48.29,51.09 v4(48.6,51.4)
  IN3 w0.061: v5(77,58.55) 76.9,58.65 70.57,58.65 70.34,58.42 67.39,58.42 66.93,58.89 55.19,58.89 54.59,59.49 53.8,59.49 52.97,58.66 50.99,58.66 48.28,55.95 48.28,53.99 48.6,53.68 v4(48.6,51.4)
  BOTTOM w0.076: RC155.2 v5(77,58.55)
VR_SVID_CLK: length 38
  TOP w0.127: v6(48.74,55.85) 48.6,55.7 PR922.1
  IN3 w0.061: v5(78.49,58.29) 78.47,58.27 76.78,58.27 76.55,58.36 70.69,58.36 70.46,58.13 67.27,58.13 66.81,58.6 54.79,58.6 54.53,58.34 52.31,58.34 52.28,58.37 51.15,58.37 50.16,57.38 50.16,57.28 50.43,57.01 50.43,56.9 50.35,56.83 50.27,56.83 49.99,57.11 49.89,57.11 49.82,57.03 49.82,56.93 50.12,56.63 50.12,56.51 50.05,56.44 49.96,56.44 49.64,56.76 49.54,56.76 49.47,56.69 49.47,56.59 49.79,56.27 49.79,56.17 49.72,56.1 49.62,56.1 49.3,56.42 49.2,56.42 49.13,56.34 49.13,56.24 49.7,55.67 49.7,55.57 49.63,55.5 49.53,55.5 49.04,55.99 48.88,55.99 v6(48.74,55.85)
  BOTTOM w0.076: v5(78.49,58.29) 78.26,58.53 78.14,58.53 ; 78.14,58.53 RC158.2 ; 78.14,58.53 RC159.2
VR_SVID_DATA: length 37.8
  IN1 w0.061: v4(47.9,51.62) v2(46.99,51.62)
  IN3 w0.061: v4(47.9,51.62) 47.99,51.71 47.99,56.07 50.86,58.95 52.85,58.95 53.68,59.77 54.71,59.77 55.31,59.18 67.05,59.18 67.51,58.71 70.22,58.71 70.45,58.94 77.18,58.94 v5(77.57,58.55)
  BOTTOM w0.076: RC157.2 v5(77.57,58.55)
VRACPU_VTEMP: length 129.9
  TOP w0.152: v2(111.2,69.65) 111.67,69.18 113.02,69.18 114.04,70.21 119.91,70.21 120.67,69.45 123.56,69.45 124.5,68.51 127.05,68.51 127.42,68.88 129.13,68.88 129.44,68.57 129.44,68.2 PR1105.1
  TOP w0.203: v2(75.22,75.08) 75.22,74.99 78.29,71.91 78.29,70.06 v6(78.41,69.94)
  IN1 w0.152: v2(75.22,75.08) 74.87,75.43 74.87,76.12 75.09,76.35 87.71,76.35 88.35,75.71 88.81,75.71 91.6,72.92 94.27,72.92 97.78,76.42 107.59,76.42 107.89,76.13 107.89,72.83 110.3,70.41 110.5,70.41 111.2,69.7 v2(111.2,69.65)
  IN3 w0.127: v5(42.37,59.67) 42.37,59.53 42.74,59.16 42.91,59.16 ; v5(43.45,54.29) 43.16,54.29 42.94,54.5 42.94,55.53 43.36,55.96 43.36,58.82 43.03,59.16
  IN3 w0.152: v5(64.53,62.58) 64.53,62.41 64.43,62.31 63.26,62.31 62.17,61.22 55.9,61.22 55.31,61.81 54.75,61.81 53.43,63.14 52.74,63.14 51.7,64.18 44.54,64.18 43.46,63.1 43.46,62.26 43.58,62.14 43.58,59.67 43.06,59.16 42.91,59.16
  BOTTOM w0.127: PU900.45 40.77,59.69 PC913.1 39.75,59.68 PR944.1 ; v5(43.45,54.29) 42.46,53.3 PR1101.1 ; v5(42.37,59.67) 42.35,59.69
  BOTTOM w0.152: v6(78.41,69.94) 78.73,69.63 78.73,68.27 75.55,65.09 66.56,65.09 64.88,63.42 64.88,62.93 v5(64.53,62.58)
  BOTTOM w0.203: 42.35,59.69 PU900.45
VRALERT#: length 3.3
  BOTTOM w0.076: RC81.1 103.01,30.95 103.01,32.3 103.15,32.45 103.28,32.45 103.4,32.57 103.4,32.87 103.13,33.23 UCPU1.CC36
VSET_5105: length 6.5
  TOP w0.102: UE1.C9 269.04,59.62 269.15,59.73 v2(269.15,59.99)
  TOP w0.127: v2(272.16,61.85) 272.36,62.06 CE113.1 272.53,63.52 RE474.1
  IN1 w0.061: v2(272.16,61.85) 272.04,61.85 271.28,61.1 270.79,61.1 270.03,60.33 269.75,60.33 269.41,59.99 v2(269.15,59.99)
VTEMP_CORE1: length 1.6
  IN1 w0.203: v4(73.85,74.95) 74,74.95 74.13,75.08 v2(74.26,75.08)
  IN3 w0.203: v4(73.85,74.95) 73.89,74.95 74.14,75.2 v5(74.14,75.33)
  BOTTOM w0.203: PU1000.11 v5(74.14,75.33)
VTEMP_CORE2: length 1.9
  IN1 w0.254: v4(111.64,69.92) 111.67,69.94 111.67,70.19 111.28,70.58 v2(111.19,70.58)
  IN3 w0.203: v5(111.61,70.32) 111.61,69.95 v4(111.64,69.92)
  BOTTOM w0.203: PU1001.11 v5(111.61,70.32)
VTEMP_GT: length 1.3
  BOTTOM w0.254: PR1101.2 42.59,51.8 PU1100.11
VTEMP_SA: length 2
  IN1 w0.254: v2(130.8,67.74) 130.32,67.26 v4(130.21,67.26)
  IN3 w0.254: v5(130.59,67.33) 130.53,67.26 v4(130.21,67.26)
  BOTTOM w0.203: v5(130.59,67.33) 130.53,67.26 PU1101.9
VTTREF_0.6V: length 2.9
  TOP w0.127: v1(49.48,26.33) 49.81,26 PC614.1
  TOP w0.254: PC614.1 50.56,25.99 51.33,25.99 v6(51.4,25.92)
  BOTTOM w0.254: v6(51.4,25.92) 51.31,25.92 51.11,25.72 PU600.3
WLAN_COEX1: length 60.1
  IN1 w0.061: v2(273.15,31.93) 272.88,31.67 272.52,31.67 270.43,29.57 265.54,29.57 v4(265.04,30.07)
  IN3 w0.061: v4(265.04,30.07) 265.04,29.53 263.69,28.18 253.09,28.18 250.8,25.89 238.66,25.89 237.23,27.32 229.05,27.32 228.24,28.14 220.74,28.14 219.87,29 218.2,29 v5(217.75,28.55)
WLAN_COEX2: length 59.5
  IN1 w0.061: v2(272.58,31.93) 272.58,31.9 270.39,29.71 265.94,29.71 v4(265.58,30.07)
  IN3 w0.061: v4(265.58,30.07) 265.58,29.67 263.96,28.06 253.14,28.06 250.85,25.77 238.61,25.77 237.18,27.2 229,27.2 228.19,28.01 220.69,28.01 219.82,28.88 219.08,28.88 v5(218.82,28.62)
  BOTTOM w0.127: v5(218.82,28.62) 218.39,29.05 JNGFF3.46
WLAN_COEX3: length 58.9
  IN1 w0.061: v2(272.01,31.93) 271.3,31.93 269.24,29.88 266.27,29.88 v4(266.09,30.05)
  IN3 w0.061: v4(266.09,30.05) 266.09,29.84 264.18,27.93 253.19,27.93 250.9,25.65 238.56,25.65 237.13,27.08 228.95,27.08 228.13,27.89 220.64,27.89 219.91,28.62 v5(219.21,28.62)
  BOTTOM w0.127: v5(219.21,28.62) 219.21,28.87 218.54,29.55 JNGFF3.44
WLAN_SUSCLK: length 2.4
  TOP w0.127: v1(218.24,28.24) 218.42,28.05 v6(218.87,28.05) 218.9,28.09 RN48.1
  BOTTOM w0.127: JNGFF3.50 v6(218.87,28.05)
WLAN_WIGIG60GHZ_DIS#: length 80.2
  TOP w0.127: v2(224.83,44.71) 224.08,44.71 v1(223.3,43.94) 221.6,42.23 220.51,42.23 218.16,39.89 218.16,30.54 220.33,28.37 QN9.3 ; UE1.L13 273.93,51.52 v2(274.38,51.52)
  IN1 w0.061: v2(274.38,51.52) 274.14,51.28 274.14,50.29 273.41,49.56 273.41,46.83 270.92,44.33 260.45,44.33 259.97,44.81 253.88,44.81 253.69,45 225.12,45 v2(224.83,44.71)
WLAN_WIGIG60GHZ_DIS#_R: length 4.2
  TOP w0.127: QN9.4 220.33,25.32 220.19,25.17 219.9,25.17 RN78.2 219.29,25.63 v6(218.87,26.05) v1(218.22,26.05)
  BOTTOM w0.127: v6(218.87,26.05) 218.87,26.21 218.53,26.55 JNGFF3.56
WWAN_BB_RST#: length 190.5
  TOP w0.127: RN73.1 272.81,23.09 v1(272.41,22.7) v2(272.01,22.29)
  IN1 w0.061: v2(272.01,22.29) 272.01,22.27 v4(271.75,22.01)
  IN2 w0.061: v4(120.54,26.26) 119.84,26.26 118.42,27.68 118.42,28.27 116.47,30.22 114.96,30.22 111.67,33.5 111.67,37.06 108.52,40.22 107.42,40.22 106.16,41.47 v4(105.45,41.47)
  IN3 w0.061: v4(105.45,41.47) v5(105.14,41.16) ; v5(181.75,12.07) 182.08,11.74 183.76,11.74 184.38,12.37 200.99,12.37 202.71,14.08 209.42,14.08 211.59,16.25 217.31,16.25 218.77,17.71 227.96,17.71 228.77,16.9 231.35,16.9 232.11,16.14 249.34,16.14 252.16,18.97 264.98,18.97 267.28,21.27 271,21.27 v4(271.75,22.01) ; v4(120.54,26.26) 121.98,24.82 123.76,24.82 126.61,21.97 126.61,20.62 127.54,19.69 129.19,19.69 131,17.88 131.73,17.88 132.67,16.94 133.55,16.94 134.87,15.62 136.22,15.62 139.01,12.83 142,12.83 v5(142.97,11.86)
  BOTTOM w0.127: v5(181.75,12.07) 181.39,11.71 143.12,11.71 v5(142.97,11.86)
WWAN_BB_RST#_R: length 4.7
  TOP w0.127: CN59.1 273.4,25.15 v6(273.42,25.17) ; CN59.1 RN73.2 RN105.2 ; CN59.1 273.72,24.48 v1(274.33,23.87)
  BOTTOM w0.127: v6(273.42,25.17) 273.86,25.17 274.15,24.87 JNGFF1.67
WWAN_COEX1: length 3.7
  TOP w0.127: RN52.1 v2(273.15,31.35)
  IN1 w0.061: v4(273.07,30.6) 273.15,30.68 v2(273.15,31.35)
  IN3 w0.061: v5(272.68,30.3) 272.71,30.32 272.79,30.32 v4(273.07,30.6)
  BOTTOM w0.127: JNGFF1.64 273.4,30.85 272.87,30.32 272.71,30.32 v5(272.68,30.3)
WWAN_COEX2: length 2.5
  TOP w0.127: RN53.1 v2(272.58,31.35)
  IN1 w0.061: v4(272.74,31.01) 272.58,31.17 v2(272.58,31.35)
  IN3 w0.061: v5(272.62,30.68) 272.67,30.73 272.67,30.9 272.74,30.98 v4(272.74,31.01)
  BOTTOM w0.127: JNGFF1.62 272.9,30.96 v5(272.62,30.68)
WWAN_COEX3: length 2.6
  TOP w0.127: v2(272.01,30.66) RN49.1
  IN1 w0.061: v2(272.01,30.66) v4(272.01,30.27)
  IN3 w0.061: v4(272.01,30.27) 272.1,30.36 v5(272.1,30.64)
  BOTTOM w0.127: v5(272.1,30.64) 272.4,30.94 JNGFF1.60
WWAN_FULL_PWR_EN: length 217.9
  TOP w0.127: v2(228.83,30.8) 228.83,30.96 235.49,37.62 v1(235.49,43.76) 235.49,46.87 v6(236.13,47.51) ; v2(261.42,31.48) 261.42,32.68 260.32,33.78 RN9.2
  IN1 w0.061: v2(261.42,31.48) 260.87,31.48 260.02,30.63 260.02,29.38 258.96,28.31 254.94,28.31 253.83,27.2 253.83,25.81 253.06,25.05 251.88,25.05 250.89,24.06 234.61,24.06 231.18,27.49 231.18,29.89 230.28,30.8 v2(228.83,30.8)
  IN2 w0.061: v6(236.13,47.51) 231.92,47.51 220.47,36.07 218.88,36.07 216.15,33.34 216.15,32.9 215.09,31.84 199.48,31.84 198.72,31.08 188.78,31.08 176.7,19 155.11,19 154.85,19.27 149.06,19.27 144.79,23.53 144.4,23.53 142.27,23.53 139.8,25.99 131.45,25.99 130.76,25.3 125.65,25.3 125.28,24.94 123.68,24.94 123.01,25.61 121.72,25.61 120.71,26.63 119.88,26.63 118.71,27.8 118.71,28.39 116.59,30.51 115.08,30.51 112.72,32.86 112.72,33.47 111.96,34.24 111.96,37.18 108.65,40.5 108.65,41.31 v4(108.05,41.9)
  IN3 w0.061: v4(108.05,41.9) 108.07,41.89 v5(108.07,41.54)
WWAN_GPIO_CTRL: length 11
  TOP w0.127: UE1.K1 262.14,54.01 v2(261.75,53.61) ; v2(261.57,51.3) 261.57,51.06 260.46,49.96 260.46,48.11 v1(261.23,47.34) 262.76,45.81 RN90.1
  IN1 w0.061: v2(261.75,53.61) 261.62,53.49 v4(261.44,53.49) ; v4(261.24,51.3) v2(261.57,51.3)
  IN3 w0.061: v4(261.44,53.49) 261.21,53.26 261.21,51.33 v4(261.24,51.3)
WWAN_GPIO_CTRL#: length 4.7
  TOP w0.127: v1(262.13,41.17) 262.93,41.97 QN3.1 262.56,42.49 261.16,42.49 RN89.2 260.91,42.46 UN4.6
WWAN_GPIO_CTRL_R: length 3.1
  TOP w0.127: RN90.2 RN91.1 263.35,44.25 QN3.2 264.06,43.54 v1(264.71,43.54)
WWAN_GPIO_PERST#: length 204.4
  TOP w0.127: RN86.1 RN85.2 262.71,35.63 263.61,34.73 263.83,34.73 v1(265.73,32.83) 268.6,29.96 269.36,29.96 270.2,29.12 270.2,27.47 v2(270.1,27.37)
  IN1 w0.061: v4(106.08,40.86) 106.08,40.3 106.98,39.41 107.56,39.41 108.04,38.93 108.04,38.74 108.54,38.24 108.6,38.24 110.61,36.23 110.61,33.98 112.73,31.87 112.89,31.87 114.27,30.49 115.68,30.49 116.58,29.58 118.54,29.58 118.88,29.92 124.12,29.92 124.75,29.29 126.43,29.29 126.95,28.78 126.95,28.53 127.83,27.65 127.83,27.16 128.44,26.55 128.44,25.9 129.46,24.87 130.5,24.87 131.7,23.67 131.7,22.78 133.1,21.39 133.48,21.39 135.72,19.15 135.72,18.05 136.46,17.3 137.74,17.3 138.53,16.51 138.94,16.51 146.85,13.67 146.87,13.66 147.3,13.5 147.3,13.5 148.43,13.08 154.84,11.58 156.09,11.22 156.77,11.11 178.63,11.11 180.2,12.67 197.11,12.67 201.84,17.4 208.7,17.4 214.6,23.3 217.18,23.3 218.02,24.14 219.28,24.14 220.23,25.09 230.17,25.09 233.46,21.79 238.71,21.79 239.18,21.32 258.51,21.32 261.74,24.54 261.74,25.5 262.17,25.93 265.58,25.93 267.02,27.37 v2(270.1,27.37)
  IN3 w0.061: v4(106.08,40.86) 106.08,40.87 v5(105.79,41.16)
WWAN_GPIO_PERST#_R: length 2.9
  TOP w0.127: v1(262.41,39.81) 262.13,39.53 RN97.1 RN86.2 261.86,37.98 UN5.6
WWAN_GPIO_WAKE#: length 182.3
  TOP w0.127: v2(256.92,48.6) 258.16,47.35 v1(258.16,47.2) 258.16,43.21 258.34,43.03 RN80.1 RN82.1
  IN1 w0.061: v2(256.92,48.6) 256.78,48.6 v4(256.54,48.84)
  IN2 w0.061: v4(256.54,48.84) 248.56,48.84 246.68,46.96 231.59,46.96 220.57,35.94 218.93,35.94 216.28,33.29 216.28,32.84 215.14,31.7 199.52,31.7 198.77,30.95 188.83,30.95 176.75,18.87 155.06,18.87 154.79,19.14 149,19.14 144.74,23.4 142.22,23.4 139.75,25.87 131.5,25.87 130.82,25.18 125.7,25.18 125.34,24.82 123.63,24.82 122.96,25.49 121.66,25.49 121.25,25.9 119.79,25.9 118.1,27.59 118.1,28.17 116.35,29.93 114.84,29.93 108.98,35.78 108.98,38.94 108.72,39.2 v4(108.72,39.46)
  IN3 w0.061: v4(108.72,39.46) 108.72,39.67 107.76,40.63 v5(107.57,40.63)
  BOTTOM w0.127: v5(107.57,40.63) 107.57,40.68 UCPU1.CK23
WWAN_GPIO_WAKE#_R: length 4.1
  TOP w0.127: RN80.2 258.52,43.71 v1(258.52,44.53) 258.7,44.71 260.19,44.71 260.91,45.43 UN4.1
WWAN_PERST#: length 17.3
  TOP w0.127: v2(262.88,33.36) 262.88,34.12 262.27,34.73 v1(261.89,34.73) 261.88,34.73 259.87,34.73 259.5,35.1 RN87.2 RN88.1 258.78,36.3 258.49,36.6 258.49,37.55 258.7,37.76 RN113.2
  IN1 w0.061: v4(268.48,33.9) 265.77,33.9 265.09,33.22 263.02,33.22 v2(262.88,33.36)
  IN3 w0.061: v5(268.94,33.9) 268.93,33.9 v4(268.48,33.9)
  BOTTOM w0.127: v5(268.94,33.9) 269.9,32.94 JNGFF1.50
WWAN_PERST#_R: length 3
  TOP w0.127: UN5.4 259.51,36.9 RN87.1 259.66,36.89 259.88,36.67 259.88,35.45 v1(260.02,35.31)
WWAN_PEWAKE#: length 30.8
  TOP w0.127: v2(257.38,45.42) v1(257.38,43.78) 257.38,43.52 v2(258.04,42.87) 258.25,42.65 258.25,41.94 258.43,41.76 RN82.2 RN81.2 ; RN74.1 v6(270.93,32.73)
  IN1 w0.061: v6(270.27,42.35) 269.71,42.92 258.09,42.92 v2(258.04,42.87) ; v2(258.67,45.49) 257.45,45.49 v2(257.38,45.42)
  BOTTOM w0.127: JNGFF1.54 270.9,32.59 270.93,32.62 v6(270.93,32.73) 270.93,33.18 271.3,33.55 271.3,41.33 v6(270.27,42.35)
