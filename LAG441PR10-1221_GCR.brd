# Allegro board LAG441PR10-1221_GCR.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_CKE0: length 44.2
  TOP w0.076: UD3.K3 v2(89.83,18.78) 89.91,18.7 89.91,17.83 90.39,17.35 RD66.1
  IN1 w0.076: v4(73.47,38.11) 73.64,37.94 73.79,37.94 73.86,38.01 73.86,38.81 73.95,38.89 74.09,38.89 74.17,38.8 74.17,37.72 74.26,37.63 74.4,37.63 74.48,37.71 74.48,38.8 74.57,38.89 74.7,38.89 74.78,38.8 74.78,38.65 74.88,38.55 75,38.55 75.09,38.63 75.09,38.88 75.21,39 76.44,39 76.53,38.91 79.68,38.91 80.03,38.55 80.03,35.78 80.34,35.48 80.34,34.94 81.17,34.1 81.17,32.28 81.93,31.53 81.93,28.79 81.09,27.95 81.09,26.76 80.86,26.52 80.86,23.76 83.07,21.54 83.07,20.34 83.32,20.1 83.92,20.1 84,20.02 84.92,20.02 85.35,19.58 86.65,19.58 87.45,18.78 87.74,18.78 87.86,18.65 87.86,17.78 88.05,17.59 88.88,17.59 89.33,18.05 89.33,18.33 89.78,18.78 v2(89.83,18.78)
  IN3 w0.076: v5(73.7,38.34) v4(73.47,38.11)
DDR_B_CKE1: length 47.1
  TOP w0.076: v2(89.57,19.83) 89.57,19.46 89.27,19.16 89.27,18.02 89.83,17.46 RD68.1
  IN1 w0.076: v4(73.47,37.46) 73.93,37.48 74.14,37.48 74.46,37.42 74.7,37.34 75.09,37.18 75.24,37.14 77.62,37.14 77.77,37.08 78.31,36.54 78.39,36.5 78.58,36.47 78.68,36.42 78.81,36.29 78.81,35.28 78.86,35.13 78.88,35.05 78.94,34.54 78.95,34.39 78.95,34.11 78.88,33.86 78.88,31.71 78.83,31.47 78.7,30.94 78.7,23.45 78.44,23.19 78.44,20.79 83.16,16.06 90.83,16.06 92.42,17.66 92.42,17.96 91.94,18.75 91.91,18.83 91.8,19.1 91.65,19.24 91.52,19.3 90.66,19.3 90.22,19.48 90.11,19.59 v2(89.57,19.83)
  IN3 w0.076: v5(73.7,37.69) v4(73.47,37.46)
DDR_B_CKE2: length 43.8
  IN3 w0.076: v5(74.62,38.34) 74.86,38.58 79.31,38.58 79.54,38.36 79.72,38.36 79.95,38.58 80.29,38.58 80.75,38.12 80.75,36.49 80.61,36.35 80.22,36.35 80.13,36.25 80.13,36.12 80.21,36.04 80.68,36.04 80.76,35.95 80.76,35.83 80.67,35.74 80.45,35.74 80.36,35.65 80.36,35.52 80.45,35.43 80.66,35.43 80.75,35.34 80.75,34.09 81.21,33.63 81.21,33.16 80.97,32.91 80.97,32.42 80.81,32.26 80.81,31.63 78.9,29.72 78.9,23.96 79.09,23.77 79.09,19.37 79,19.28 79,18.57 80.76,16.82 86.49,16.82 86.99,17.32 87.2,17.32 87.36,17.48 87.36,17.48 87.54,17.66 87.54,18.09 88.04,18.58 v5(88.04,18.76)
  BOTTOM w0.076: RD70.1 87.8,17.76 87.93,17.89 87.93,18.65 v5(88.04,18.76) 88.27,18.99 UD1.K3
DDR_B_CKE3: length 45.4
  IN3 w0.076: v5(88.27,19.83) 88.25,19.61 88.22,19.41 88.19,19.35 88.11,19.24 87.82,18.88 87.68,18.72 87.51,18.41 87.37,18.14 87.37,17.73 87.13,17.49 86.92,17.49 86.42,16.98 80.81,16.98 79.16,18.64 79.16,19.21 79.25,19.31 79.25,23.83 79.05,24.03 79.05,29.66 80.97,31.58 80.97,32.19 81.13,32.35 81.13,32.85 81.42,33.13 81.42,33.66 81.08,34 81.08,34.19 81.39,34.5 81.5,35.24 81.55,35.46 81.55,38.24 81.26,38.53 80.94,38.63 80.32,38.75 74.81,38.75 74.57,38.64 74.37,38.45 74.37,38.29 v5(74.62,37.69)
  BOTTOM w0.076: RD72.1 88.36,16.99 88.62,17.25 88.62,19.48 v5(88.27,19.83)
DDR_B_CLK0: length 39.3
  TOP w0.076: RD76.1 88.92,15.63 88.92,16.51 88.59,16.84 88.59,18.33 88.92,18.67 v2(88.92,19.03)
  IN1 w0.076: v4(80.35,37.43) 80.35,37.64 80.47,37.76 80.61,37.76 80.75,37.61 80.75,36.5 80.32,36.06 80.32,35.78 80.49,35.61 80.49,35.18 80.7,34.97 81.36,34.97 81.48,34.85 81.48,32.41 82.24,31.66 82.24,28.66 81.41,27.83 81.41,26.64 81.16,26.39 81.16,23.89 82.96,22.09 83.46,22.09 83.55,22.01 83.55,21.85 83.72,21.68 84.04,21.68 84.2,21.84 84.2,22.22 84.3,22.32 84.42,22.32 84.51,22.24 84.51,21.86 84.69,21.68 84.99,21.68 85.18,21.86 85.18,22.4 85.28,22.5 85.44,22.5 85.54,22.4 85.54,22.14 85.73,21.95 85.96,21.95 86.15,22.14 86.15,22.5 86.25,22.6 86.49,22.6 86.53,22.64 86.85,22.64 87.03,22.46 87.03,22.16 87.22,21.97 87.53,21.97 87.73,22.17 87.73,22.51 87.82,22.6 87.94,22.6 88.03,22.51 88.03,22.23 88.21,22.06 88.62,22.06 88.83,22.26 88.83,22.52 88.94,22.63 89.26,22.63 89.62,22.28 89.62,22.11 89.55,22.03 89.33,22.03 89.16,21.86 89.16,21.27 89.33,21.1 89.33,20.95 89.16,20.79 89.16,20.48 89.33,20.32 89.33,20.16 89.16,19.99 89.16,19.68 89.26,19.58 89.26,18.95 88.99,18.68 88.87,18.68 88.8,18.76 88.8,18.91 v2(88.92,19.03)
  IN3 w0.076: v4(80.35,37.43) v5(80.08,37.69)
DDR_B_CLK1: length 38.9
  IN3 w0.076: v5(79.17,37.69) 79.27,37.79 79.38,37.79 79.43,37.74 79.44,37.73 79.48,37.59 79.67,36.06 79.84,35.41 80.07,35.14 80.07,34.24 79.95,33.98 79.57,33.42 79.48,33.29 79.44,33.19 79.43,33.1 79.43,33.04 79.44,32.93 79.46,32.8 79.62,32.34 79.68,32.02 79.68,31.76 78.98,31.06 78.83,30.99 78.74,30.96 77.82,30.04 77.82,18.22 80.3,15.74 86.09,15.74 87.19,16.14 88.39,16.88 88.72,17.16 89.14,17.8 89.19,17.98 89.19,18.41 v5(88.95,18.65)
  BOTTOM w0.076: RD80.1 89.27,15.63 89.27,18.1 89.22,18.15 89.22,18.37 v5(88.95,18.65) 88.92,18.67 UD1.J3
DDR_B_CLK#0: length 38.5
  TOP w0.076: v2(88.92,18.23) 88.74,18.05 88.74,16.9 89.07,16.58 89.07,15.63 RD78.1
  IN1 w0.076: v4(80.35,38.08) 80.52,37.91 80.67,37.91 80.91,37.67 80.91,36.44 80.47,36 80.47,35.84 80.64,35.67 80.64,35.24 80.76,35.12 81.42,35.12 81.64,34.91 81.64,32.48 82.39,31.72 82.39,28.6 81.56,27.77 81.56,26.58 81.31,26.33 81.31,23.95 83.02,22.25 83.53,22.25 83.7,22.08 83.7,21.91 83.78,21.83 83.98,21.83 84.05,21.91 84.05,22.29 84.24,22.47 84.49,22.47 84.66,22.3 84.66,21.92 84.76,21.83 84.93,21.83 85.02,21.93 85.02,22.46 85.22,22.65 85.5,22.65 85.69,22.47 85.69,22.21 85.79,22.1 85.9,22.1 86,22.2 86,22.56 86.19,22.75 86.43,22.75 86.47,22.79 86.91,22.79 87.18,22.53 87.18,22.22 87.28,22.12 87.47,22.12 87.58,22.23 87.58,22.58 87.75,22.76 88.01,22.76 88.19,22.58 88.19,22.3 88.28,22.21 88.56,22.21 88.67,22.32 88.67,22.59 88.87,22.79 89.33,22.79 89.77,22.34 89.77,22.05 89.61,21.88 89.4,21.88 89.32,21.8 89.32,21.33 89.48,21.16 89.48,20.89 89.32,20.73 89.32,20.54 89.48,20.38 89.48,20.09 89.32,19.93 89.32,19.74 89.41,19.65 89.41,18.88 88.92,18.39 v2(88.92,18.23)
  IN3 w0.076: v5(80.08,38.34) v4(80.35,38.08)
DDR_B_CLK#1: length 38.3
  IN3 w0.076: v5(79.17,38.34) 79.12,38.4 78.93,38.4 78.83,38.3 78.83,38.05 78.93,37.94 79.44,37.94 79.55,37.84 79.58,37.8 79.63,37.63 79.64,37.59 79.65,37.45 79.82,36.08 79.98,35.49 80.07,35.37 80.22,35.23 80.22,34.21 80.08,33.9 79.7,33.34 79.62,33.22 79.59,33.15 79.58,33.09 79.58,33.04 79.59,32.95 79.61,32.84 79.77,32.38 79.83,32.04 79.83,31.69 79.07,30.93 78.83,30.83 77.98,29.98 77.98,18.28 80.36,15.9 86.06,15.9 87.12,16.27 88.3,17 88.61,17.27 89,17.86 89.04,18 89.04,18.12 v5(88.92,18.23)
  BOTTOM w0.076: RD82.1 89.12,15.63 89.12,18.03 v5(88.92,18.23)
DDR_B_CS#0: length 52.8
  IN1 w0.076: v2(90.22,19.03) 90.21,19.02 89.73,19.02 89.58,18.88 89.58,18.82 89.16,18.4 89.16,18.13 89.02,17.99 88.82,17.99 88.5,18.31 88.5,18.36 88.36,18.51 88.36,18.8 88.5,18.95 88.5,19.76 87.98,20.29 v4(87.95,20.35)
  IN3 w0.076: v5(87.62,19.03) 87.31,19.03 86.76,19.59 86.21,19.59 86.08,19.72 86.08,19.95 86,20.03 85.84,20.03 85.74,20.13 85.74,20.27 85.84,20.36 87.51,20.36 v5(87.64,20.23) v4(87.95,20.35) 87.87,20.42 87.87,20.62 88.23,20.98 88.23,21.12 88.1,21.26 87.95,21.26 87.76,21.06 87.61,21.06 87.51,21.16 86.2,21.16 86.08,21.29 85.92,21.29 85.8,21.16 85.16,21.16 84.9,20.9 83.36,20.9 83.14,20.68 83.14,20.33 83.07,20.25 82.93,20.25 82.68,20.5 82.68,20.67 83.08,21.08 83.08,21.55 82.8,21.83 82.31,21.83 82.1,21.62 82.1,21.5 82.19,21.41 82.67,21.41 82.76,21.32 82.76,21.2 82.67,21.11 82.19,21.11 82.1,21.02 82.1,20.84 82,20.74 81.15,20.74 80.92,20.97 80.92,21.73 81.12,21.93 81.96,21.93 82.05,22.02 82.05,22.14 81.78,22.41 81.65,22.41 81.47,22.23 80.96,22.23 80.87,22.32 80.87,22.45 80.96,22.54 81.34,22.54 81.42,22.61 81.42,22.76 81.34,22.84 80.96,22.84 80.87,22.93 80.87,23.08 80.95,23.17 81.1,23.17 81.2,23.27 81.2,23.41 80.99,23.62 80.69,23.62 80.55,23.76 80.55,23.93 80.66,24.03 80.83,24.03 80.92,24.12 80.92,24.25 80.83,24.34 80.65,24.34 80.55,24.44 80.55,24.56 80.63,24.64 81.05,24.64 81.13,24.73 81.13,24.87 81.05,24.95 80.63,24.95 80.54,25.04 80.54,25.17 80.63,25.25 81.04,25.25 81.13,25.35 81.13,25.48 81.05,25.56 80.64,25.56 80.55,25.65 80.55,25.77 80.64,25.86 81.05,25.86 81.13,25.95 81.13,26.07 81.04,26.17 80.63,26.17 80.54,26.26 80.54,26.38 80.63,26.47 81.05,26.47 81.13,26.56 81.13,26.68 81.04,26.78 80.64,26.78 80.55,26.87 80.55,26.99 80.64,27.08 81.05,27.08 81.14,27.17 81.14,27.29 81.04,27.39 80.66,27.39 80.59,27.46 80.59,27.6 80.68,27.69 81.05,27.69 81.14,27.78 81.14,27.9 81.04,28 80.77,28 80.64,28.12 80.64,28.24 80.79,28.39 80.91,28.39 80.98,28.31 81.11,28.31 81.2,28.4 81.2,28.52 81.12,28.6 81.12,28.72 81.21,28.81 81.34,28.81 81.41,28.74 81.54,28.74 81.63,28.83 81.63,28.94 81.55,29.01 81.55,29.14 81.64,29.23 81.79,29.23 81.85,29.18 81.97,29.18 82.06,29.27 82.06,29.39 81.99,29.46 81.99,29.58 82.08,29.67 82.22,29.67 82.29,29.61 82.4,29.61 82.49,29.7 82.49,29.82 82.42,29.89 82.42,30.01 82.51,30.1 82.65,30.1 82.71,30.04 82.84,30.04 82.93,30.13 82.93,30.36 83.06,30.5 83.06,32.68 v5(82.99,32.75)
  BOTTOM w0.076: RD62.1 87.24,16.41 86.65,17 86.65,18.42 86.83,18.61 87,18.61 87.32,18.93 87.32,19.96 87.6,20.23 v5(87.64,20.23)
DDR_B_CS#1: length 53.7
  IN1 w0.076: v2(90.22,19.83) 90.51,19.54 91.6,19.54 91.78,19.72 91.78,20.08 91.57,20.29 91.48,20.29 91.38,20.39 90.69,20.39 90.55,20.53 v4(90.55,21.03)
  IN3 w0.076: v5(82.99,34.05) 83.09,34.14 83.21,34.14 83.29,34.07 83.29,33.74 83.19,33.65 82.84,33.65 82.75,33.56 82.75,33.25 82.97,33.03 83.14,33.03 83.23,32.93 83.23,30.42 83.08,30.26 83.08,30.06 81.29,28.27 81.29,24.67 81.08,24.45 81.08,23.75 81.35,23.47 81.35,23.07 82.4,22.01 82.88,22.01 83.29,21.61 83.54,21.61 83.61,21.68 85.04,21.68 85.12,21.75 85.12,21.87 85.23,21.98 89.27,21.98 89.65,22.36 90.57,22.36 90.93,22.72 91.04,22.72 91.13,22.63 91.13,22.4 91.22,22.31 91.35,22.31 91.43,22.39 91.43,22.63 91.52,22.72 93.62,22.72 93.95,22.39 94.44,22.39 94.55,22.28 94.55,21.9 94.43,21.77 94.11,21.77 94.03,21.85 94.03,21.92 93.95,22 93.82,22 93.73,21.9 93.73,21.77 93.65,21.69 93.49,21.69 93.39,21.78 93.39,22.31 93.3,22.4 93.18,22.4 93.09,22.31 93.09,21.76 93.01,21.68 92.89,21.68 92.78,21.78 92.78,22.31 92.69,22.4 92.57,22.4 92.48,22.31 92.48,22.05 92.4,21.98 92.28,21.98 92.17,22.08 92.17,22.31 92.09,22.4 91.96,22.4 91.87,22.31 91.87,22.08 91.78,22 89.72,22 89.26,21.53 89.26,21.39 88.98,21.12 88.98,20.97 89.15,20.8 89.3,20.8 89.72,21.23 90.06,21.23 90.26,21.03 v4(90.55,21.03) ; v5(87.62,19.83) 87.76,19.98 88.07,19.98 88.48,20.38 89.59,20.38 89.71,20.43 89.82,20.46 89.92,20.46 90.08,20.42 90.18,20.37 90.33,20.37 90.55,20.6 v4(90.55,21.03) ; v4(90.55,21.03) v5(90.88,21.03)
  BOTTOM w0.076: RD64.1 90.67,17.85 90.57,17.95 90.57,20.76 90.85,21.03 v5(90.88,21.03)
DDR_B_D0: length 13.1
  IN3 w0.076: v5(84.21,34.05) 84.44,33.51 84.47,33.31 84.52,32.33 84.49,31.86 84.49,31.2 84.74,30.95 84.74,29.46 83,27.73 82.59,27.19 82.5,26.95 82.5,24.35 83.08,23.77 83.08,23.69 83.25,23.52 83.6,23.52 v5(84.37,23.83)
DDR_B_D1: length 15.5
  IN3 w0.076: v5(84.21,34.7) 84,34.21 83.97,34.1 83.79,32.81 83.79,32.58 83.94,32.43 83.94,31.09 84.19,30.85 84.19,29.88 84.06,29.49 82.6,28.03 82.25,27.57 82.04,27.03 82.04,24.13 82.59,23.57 82.59,23.47 82.77,23.3 82.89,22.99 82.89,22.84 83.19,22.55 83.53,22.55 83.7,22.58 84.51,22.82 v5(85.02,23.03)
DDR_B_D2: length 12.1
  IN3 w0.076: v5(84.37,24.63) 84.1,24.63 83.62,25.12 83.23,25.12 82.99,25.36 82.99,26.16 83.32,26.5 83.32,26.96 84.75,28.39 85.29,28.39 85.5,28.61 85.5,31.27 85.27,31.51 85.27,33.99 85.36,34.08 85.47,34.08 v5(85.51,34.05)
DDR_B_D3: length 12.6
  IN3 w0.076: v5(85.51,34.7) 85.59,34.7 85.75,34.54 85.75,33.83 86.06,33.52 86.06,32 86.16,31.9 86.16,28.56 85.37,27.77 85.24,27.77 85.13,27.89 85,27.89 84.91,27.8 84.91,27.68 85.04,27.55 85.04,27.43 84.95,27.34 84.81,27.34 84.68,27.47 84.57,27.47 84.48,27.38 84.48,27.25 84.55,27.18 84.55,27.07 84.45,26.97 84.32,26.97 84.25,27.04 84.11,27.04 83.82,26.75 83.82,26.3 84.12,25.99 84.67,25.99 85.02,25.64 v5(85.02,25.43)
DDR_B_D4: length 12.6
  IN3 w0.076: v5(84.21,32.75) 84.31,32.44 84.31,31.16 84.54,30.93 84.54,29.49 82.78,27.74 82.49,27.36 82.34,26.97 82.34,24.27 82.91,23.7 82.91,23.62 83.18,23.35 83.64,23.35 84.43,23.57 v5(85.02,23.83)
DDR_B_D5: length 13.3
  IN3 w0.076: v5(84.21,33.4) 84.06,33.06 83.97,32.83 83.97,32.64 84.11,32.5 84.11,31.14 84.34,30.91 84.34,29.53 82.65,27.84 82.38,27.49 82.19,27 82.19,24.19 82.75,23.64 82.75,23.55 83.06,23.24 83.06,22.91 83.25,22.72 83.49,22.72 83.77,22.79 v5(84.37,23.03)
DDR_B_D6: length 12.5
  IN3 w0.076: v5(85.51,33.4) 85.51,33.54 85.59,33.62 85.73,33.62 85.9,33.45 85.9,31.93 85.99,31.83 85.99,31.69 85.9,31.6 85.89,31.6 85.81,31.52 85.81,31.39 85.99,31.2 85.99,31.08 85.9,30.99 85.89,30.99 85.81,30.91 85.81,30.78 85.99,30.59 85.99,30.47 85.9,30.38 85.89,30.38 85.81,30.3 85.81,30.17 85.99,29.98 85.99,29.86 85.9,29.77 85.89,29.77 85.81,29.69 85.81,29.56 85.99,29.38 85.99,29.25 85.9,29.16 85.89,29.16 85.81,29.08 85.81,28.95 85.99,28.77 85.99,28.63 85.43,28.06 84.89,28.06 83.65,26.83 83.65,26.23 84.06,25.82 84.61,25.82 84.76,25.67 84.76,25.36 84.82,25.3 84.82,24.95 v5(84.76,24.89)
  BOTTOM w0.076: UD1.R10 v5(84.76,24.89)
DDR_B_D7: length 12.1
  IN3 w0.076: v5(85.51,32.75) 85.65,32.75 85.73,32.67 85.73,32.51 85.64,32.42 85.53,32.42 85.44,32.33 85.44,32.2 85.53,32.11 85.64,32.11 85.73,32.02 85.73,31.9 85.64,31.81 85.53,31.81 85.44,31.72 85.44,31.59 85.51,31.52 85.59,31.52 85.65,31.45 85.65,28.88 85.76,28.78 85.76,28.63 85.36,28.23 84.82,28.23 83.49,26.9 83.49,26.28 83.39,26.18 83.24,26.18 83.15,26.09 83.15,25.88 83.24,25.79 83.41,25.79 83.54,25.92 83.69,25.92 83.98,25.64 83.98,25 84.09,24.89 84.43,24.89 84.54,24.99 84.54,25.35 84.45,25.43 v5(84.37,25.43)
DDR_B_D8: length 9.6
  IN3 w0.076: v5(86.72,34.05) 87.02,33.36 87.02,31.46 87.59,30.9 87.59,28.26 86.08,26.76 86.08,26.1 86.32,25.86 v5(86.32,25.43)
DDR_B_D9: length 12.5
  IN3 w0.076: v5(86.72,34.7) 86.43,34.41 86.43,33.14 86.31,33.01 86.31,32.05 86.41,31.82 86.46,31.67 86.46,28.42 84.93,26.88 84.8,26.88 84.59,26.68 84.59,26.5 84.65,26.27 84.88,26.03 85.33,25.72 85.64,25.41 85.79,25.13 85.91,25.01 85.91,24.72 v5(85.67,23.83)
DDR_B_D10: length 9.4
  IN3 w0.076: v5(86.97,25.43) 87.12,25.75 87.22,26.17 87.22,26.8 88.35,27.94 88.35,31.22 87.78,31.79 87.78,33.44 87.82,33.59 v5(88.03,34.05)
DDR_B_D11: length 13.2
  IN3 w0.076: v5(86.97,23.03) 87.79,23.43 88.03,23.67 88.03,25.68 87.74,25.97 87.74,26.62 88.98,27.87 89.29,28.9 89.29,30.47 88.85,31.52 88.67,31.7 88.51,32.26 88.51,32.61 88.45,33.24 88.35,33.51 88.27,34.1 88.21,34.34 88.18,34.4 v5(88.03,34.7)
DDR_B_D12: length 9.1
  IN3 w0.076: v5(86.32,24.63) 86.24,25.17 86.11,25.31 85.91,25.94 85.91,26.84 87.42,28.35 87.42,30.85 86.85,31.42 86.85,32.23 v5(86.72,32.75)
DDR_B_D13: length 10.7
  IN3 w0.076: v5(86.32,23.83) 86.08,24.57 86.08,25.08 85.96,25.2 85.82,25.51 85.33,26.32 85.24,26.41 85.24,26.68 85.64,27.08 86.62,28.33 87.17,29.38 87.21,29.55 87.21,30.34 87.06,30.67 86.68,31.37 86.61,31.82 86.48,32.68 86.48,32.82 v5(86.72,33.4)
DDR_B_D14: length 11.5
  IN3 w0.076: v5(88.03,33.4) 88.29,33.13 88.29,31.74 88.8,31.23 88.8,27.92 87.57,26.69 87.57,25.9 87.86,25.61 87.86,24.42 87.35,23.91 87.35,23.67 87.27,23.59 87.06,23.59 86.97,23.68 v5(86.97,23.83)
DDR_B_D15: length 8.9
  IN3 w0.076: v5(86.97,24.63) 87.04,25.07 87.2,25.3 87.27,25.41 87.38,25.79 87.38,26.74 88.53,27.88 88.53,31.26 88.11,31.68 88.11,32.66 v5(88.03,32.75)
DDR_B_D16: length 17.2
  IN1 w0.076: v4(82.14,37.46) 82.61,36.99 82.61,35.31 82.26,34.96 82.26,34.07 83.36,32.97 83.36,28.37 82.35,27.36 82.35,26.21 82.12,25.99 82.12,24.65 83.26,23.52 83.65,23.52 v2(84.37,23.83)
  IN3 w0.076: v5(81.91,37.69) v4(82.14,37.46)
DDR_B_D17: length 18.2
  IN1 w0.076: v4(82.14,36.81) 81.79,36.31 81.79,33.86 82.01,33.64 82.01,32.55 82.71,31.86 82.71,28.48 81.87,27.64 81.87,26.45 81.62,26.2 81.62,24.09 83.16,22.55 83.85,22.55 84.09,22.79 84.45,22.79 v2(85.02,23.03)
  IN3 w0.076: v5(81.91,37.04) v4(82.14,36.81)
DDR_B_D18: length 13.1
  IN1 w0.076: v2(84.37,24.63) 84.08,24.63 83.76,24.95 83.16,24.95 82.9,25.22 82.9,25.66 83.14,25.9 83.14,27.05 84.31,28.23 84.31,34.13 83.96,34.48 v4(83.96,35.51)
  IN3 w0.076: v5(83.73,35.74) v4(83.96,35.51)
DDR_B_D19: length 14.1
  IN1 w0.076: v2(85.02,24.63) 84.06,25.12 83.25,25.12 83.07,25.29 83.07,25.6 83.3,25.83 83.3,26.99 84.48,28.16 84.48,34.18 84.28,34.38 84.28,35.64 84.13,35.79 v4(83.96,36.16)
  IN3 w0.076: v5(83.73,36.39) v4(83.96,36.16)
DDR_B_D20: length 13.7
  IN1 w0.076: v4(83.96,36.81) 84.18,36.81 84.28,36.71 84.28,35.86 84.43,35.7 84.43,34.44 84.67,34.2 84.67,28.12 83.47,26.92 83.47,26.2 83.54,26.12 83.54,25.97 83.48,25.9 83.48,25.8 83.6,25.68 83.7,25.68 83.78,25.76 83.89,25.76 83.97,25.68 83.97,25.36 84.04,25.28 84.22,25.28 v2(84.37,25.43)
  IN3 w0.076: v5(83.73,37.04) v4(83.96,36.81)
DDR_B_D21: length 14.1
  IN1 w0.076: v4(83.96,37.46) 84.44,36.98 84.44,35.93 84.59,35.79 84.59,34.5 84.84,34.25 84.84,28.05 83.65,26.86 83.65,26.27 84.14,25.78 84.49,25.78 84.66,25.6 84.85,25.6 v2(85.02,25.43)
  IN3 w0.076: v5(83.73,37.69) v4(83.96,37.46)
DDR_B_D22: length 16.7
  IN1 w0.076: v2(85.02,23.83) 83.87,23.35 83.18,23.35 81.97,24.56 81.97,26.05 82.2,26.28 82.2,27.44 83.07,28.32 83.07,33.04 82.1,34.01 82.1,35.02 82.46,35.38 82.46,35.62 v4(82.14,36.16)
  IN3 w0.076: v5(81.91,36.39) v4(82.14,36.16)
DDR_B_D23: length 16
  IN1 w0.076: v4(82.14,35.51) 82.14,35.29 81.95,35.11 81.95,33.95 82.92,32.98 82.92,28.41 82.04,27.54 82.04,26.34 81.82,26.11 81.82,24.16 83.26,22.72 83.78,22.72 83.96,22.9 83.96,23 84.1,23.14 84.27,23.14 v2(84.37,23.03)
  IN3 w0.076: v5(81.91,35.74) v4(82.14,35.51)
DDR_B_D24: length 14.4
  IN1 w0.076: v4(85.79,36.16) 85.41,35.78 85.41,35.24 85.56,35.08 85.56,33.71 85.73,33.54 85.73,27.84 84.58,26.69 84.58,26.36 84.61,26.33 84.61,26.19 84.81,25.99 85.18,25.99 86.08,25.1 86.08,24.08 v2(86.32,23.83)
  IN3 w0.076: v5(85.55,36.39) v4(85.79,36.16)
DDR_B_D25: length 12.1
  IN1 w0.076: v4(85.79,35.51) 85.64,35.36 85.64,35.22 85.71,35.14 85.71,33.88 85.96,33.63 85.96,27.44 85.24,26.71 85.24,26.37 85.37,26.25 85.37,26.04 86.32,25.09 v2(86.32,24.63)
  IN3 w0.076: v5(85.55,35.74) v4(85.79,35.51)
DDR_B_D26: length 15.2
  IN1 w0.076: v2(86.97,23.83) 87.21,23.59 87.72,23.59 87.86,23.73 87.86,25.66 87.56,25.97 87.56,26.77 88.15,27.37 88.15,34.33 88.28,34.45 88.28,35.09 88.08,35.29 88.08,35.9 87.93,36.06 87.93,36.49 v4(87.61,36.81)
  IN3 w0.076: v5(87.37,37.04) v4(87.61,36.81)
DDR_B_D27: length 16.4
  IN1 w0.076: v2(86.97,23.03) 86.97,23.1 87.3,23.43 87.79,23.43 88.03,23.67 88.03,26.06 87.74,26.35 87.74,26.62 88.56,27.44 88.56,33.22 88.31,33.48 88.31,34.27 88.43,34.39 88.43,35.15 88.23,35.35 88.23,35.97 88.08,36.12 88.08,36.99 v4(87.61,37.46)
  IN3 w0.076: v5(87.37,37.69) v4(87.61,37.46)
DDR_B_D28: length 15.7
  IN1 w0.076: v4(85.79,36.81) 85.79,36.73 85.22,36.16 85.22,35.11 85.41,34.92 85.41,28.19 83.82,26.6 83.82,26.34 84.19,25.96 84.55,25.96 84.71,25.8 85.14,25.8 85.91,25.03 85.91,24.08 v2(85.67,23.83)
  IN3 w0.076: v5(85.55,37.04) v4(85.79,36.81)
DDR_B_D29: length 13.8
  TOP w0.076: UD3.E11 v2(86.65,25.83)
  IN1 w0.076: v4(85.79,37.46) 86.1,37.14 86.81,37.14 87.26,36.69 87.26,27.26 87.04,27.04 87.04,26.23 v2(86.65,25.83)
  IN3 w0.076: v5(85.55,37.69) v4(85.79,37.46)
DDR_B_D30: length 10.9
  IN1 w0.076: v4(87.61,35.51) 87.61,35.2 87.9,34.9 87.9,34.59 87.85,34.53 87.85,34.36 87.58,34.09 87.58,27.31 87.22,26.95 87.22,25.68 v2(86.97,25.43)
  IN3 w0.076: v5(87.37,35.74) v4(87.61,35.51)
DDR_B_D31: length 12.5
  IN1 w0.076: v4(87.61,36.16) 87.93,35.84 87.93,35.22 88.1,35.05 88.1,34.54 88,34.45 88,34.26 87.82,34.07 87.82,27.29 87.39,26.86 87.39,25.51 86.97,25.09 v2(86.97,24.63)
  IN3 w0.076: v5(87.37,36.39) v4(87.61,36.16)
DDR_B_D32: length 12.1
  IN3 w0.076: v5(92.17,23.83) 91.14,24.39 90.77,24.39 90.41,24.75 90.12,24.75 89.98,24.9 89.98,25.93 90.07,26.01 90.07,26.98 90.22,27.13 90.22,31.15 90,31.37 90,31.61 89.49,32.12 89.49,33.45 v5(89.24,34.05)
DDR_B_D33: length 12.9
  IN3 w0.076: v5(90.87,23.03) 89.99,23.43 89.32,24.1 89.16,24.55 89.16,26.31 89.08,26.45 89.08,26.79 89.17,27.28 89.6,28.25 89.6,30.57 89.07,31.78 88.93,31.92 88.82,32.64 88.82,33.01 88.98,34.02 89.04,34.25 v5(89.24,34.7)
DDR_B_D34: length 9.3
  IN3 w0.076: v5(90.54,34.05) 90.54,33.75 90.3,33.51 90.3,33.18 90.12,33 90.12,32.58 90.8,31.91 90.8,31.68 90.99,31.5 90.99,27.58 91.11,27.45 91.11,25.68 v5(90.87,25.43)
DDR_B_D35: length 11
  IN3 w0.076: v5(90.54,34.7) 90.81,34.43 90.81,32.68 91.33,32.15 91.33,31.85 91.5,31.68 91.5,27.83 92.11,27.22 92.11,26.15 91.76,25.81 91.76,24.88 v5(91.52,24.63)
DDR_B_D36: length 10.4
  IN3 w0.076: v5(89.24,32.75) 89.24,32.13 89.85,31.53 89.85,31.31 90.04,31.11 90.04,27.24 89.9,27.1 89.9,26.08 89.81,26 89.81,24.79 90.19,24.42 v5(91.52,23.83)
DDR_B_D37: length 11.4
  IN3 w0.076: v5(89.24,33.4) 88.99,32.84 88.99,32.71 89.09,32.02 89.38,31.73 89.82,30.7 89.82,27.88 89.57,27.3 89.4,27.13 89.25,26.76 89.25,26.49 89.33,26.35 89.33,24.58 89.51,24.14 90.06,23.59 90.28,23.59 v5(90.87,23.83)
DDR_B_D38: length 9.4
  IN3 w0.076: v5(90.54,33.4) 90.54,33.09 90.29,32.83 90.29,32.65 91,31.94 91,31.73 91.16,31.57 91.16,27.66 91.28,27.54 91.28,25.44 90.87,25.04 v5(90.87,24.63)
DDR_B_D39: length 8.1
  IN3 w0.076: v5(90.54,32.75) 90.54,32.71 91.16,32.09 91.16,31.78 91.33,31.61 91.33,27.77 91.94,27.15 91.94,26.22 91.52,25.8 v5(91.52,25.43)
DDR_B_D40: length 9.5
  IN3 w0.076: v5(91.76,34.05) 91.76,33.74 92.16,33.34 92.16,32.18 92.31,32.02 92.31,28.17 93.45,27.03 93.45,26.3 93.23,26.08 93.23,25.68 v5(93.47,25.43)
DDR_B_D41: length 10.8
  IN3 w0.076: v5(92.82,24.63) 92.82,25.09 92.58,25.33 92.58,25.9 92.28,26.2 92.28,27.5 91.81,27.97 91.81,31.82 91.64,31.99 91.64,32.29 91.35,32.58 91.35,32.94 91.47,33.05 91.47,34.41 v5(91.76,34.7)
DDR_B_D42: length 12
  IN3 w0.076: v5(93.47,23.83) 93.65,23.83 94.13,24.32 94.58,24.32 94.77,24.5 94.77,26.8 93.08,28.5 93.08,32.35 92.81,32.61 92.81,33.8 v5(93.06,34.05)
DDR_B_D43: length 14.6
  IN3 w0.076: v5(93.06,34.7) 93.37,34.39 93.37,33.06 93.59,32.83 93.59,28.69 95.3,26.98 95.3,23.14 94.87,22.72 94.09,22.72 93.77,23.03 v5(93.47,23.03)
DDR_B_D44: length 9
  IN3 w0.076: v5(91.76,32.75) 91.99,32.52 91.99,32.11 92.14,31.96 92.14,28.11 93.28,26.96 93.28,26.37 93.06,26.15 93.06,25.41 93.47,25 v5(93.47,24.63)
DDR_B_D45: length 8.6
  IN3 w0.076: v5(91.76,33.4) 91.76,33.11 91.52,32.87 91.52,32.65 91.81,32.36 91.81,32.06 91.97,31.89 91.97,28.04 92.44,27.57 92.44,26.27 92.82,25.89 v5(92.82,25.43)
DDR_B_D46: length 13.1
  IN3 w0.076: v5(93.06,33.4) 93.06,33.12 93.42,32.76 93.42,28.62 95.1,26.94 95.1,23.71 94.74,23.35 93.14,23.35 v5(92.82,23.03)
DDR_B_D47: length 12.1
  IN3 w0.076: v5(92.82,23.83) 93.14,23.52 94.67,23.52 94.94,23.78 94.94,26.87 93.25,28.56 93.25,32.56 v5(93.06,32.75)
DDR_B_D48: length 14.1
  IN1 w0.076: v4(89.43,35.98) 89.27,35.29 89.27,33.37 89.55,33.09 89.55,27.61 89.21,26.72 89.21,26.55 89.33,26.35 89.33,24.35 90.09,23.59 90.37,23.59 v2(90.87,23.83)
  IN3 w0.076: v5(89.2,35.74) v4(89.43,35.98)
DDR_B_D49: length 14.7
  IN1 w0.076: v4(89.43,36.63) 89.75,36.31 89.75,35.68 89.5,35.43 89.5,33.47 89.89,33.08 89.89,26.07 89.81,26 89.81,24.76 90.5,24.08 91.28,24.08 v2(91.52,23.83)
  IN3 w0.076: v5(89.2,36.39) v4(89.43,36.63)
DDR_B_D50: length 12.5
  IN1 w0.076: v2(90.87,24.63) 90.87,25.09 91.28,25.5 91.28,26.69 91.88,27.29 91.88,34.91 91.57,35.22 91.57,35.84 v4(91.25,36.16)
  IN3 w0.076: v5(91.02,36.39) v4(91.25,36.16)
DDR_B_D51: length 10.9
  IN1 w0.076: v2(90.87,25.43) 91.11,25.68 91.11,26.92 91.63,27.44 91.63,34.87 91.25,35.24 v4(91.25,35.51)
  IN3 w0.076: v5(91.02,35.74) v4(91.25,35.51)
DDR_B_D52: length 15.8
  IN1 w0.076: v2(92.17,23.83) 91.61,24.39 90.46,24.39 89.98,24.87 89.98,25.93 90.05,26 90.05,33.23 89.65,33.63 89.65,35.36 89.91,35.62 89.91,36.44 v4(89.43,37.28)
  IN3 w0.076: v5(89.2,37.04) v4(89.43,37.28)
DDR_B_D53: length 16.3
  IN1 w0.076: v4(89.43,37.93) 89.11,37.45 89.07,37.39 89.07,27.21 89.03,27.17 89.03,26.5 89.07,26.46 89.16,26.31 89.16,24.26 90,23.43 90.25,23.43 v2(90.87,23.03)
  IN3 w0.076: v5(89.2,37.69) v4(89.43,37.93)
DDR_B_D54: length 13.9
  IN1 w0.076: v4(91.25,37.46) 91.72,36.99 91.72,36.12 91.88,35.97 91.88,35.35 92.33,34.9 92.33,26.37 91.76,25.81 91.76,25.33 91.52,25.09 v2(91.52,24.63)
  IN3 w0.076: v5(91.02,37.69) v4(91.25,37.46)
DDR_B_D55: length 12.3
  IN1 w0.076: v2(91.52,25.43) 91.52,25.89 92.11,26.48 92.11,34.9 91.72,35.29 91.72,35.9 91.57,36.06 91.57,36.49 v4(91.25,36.81)
  IN3 w0.076: v5(91.02,37.04) v4(91.25,36.81)
DDR_B_D56: length 12.3
  IN1 w0.076: v4(93.08,36.16) 93.39,35.84 93.39,32.93 94.03,32.29 94.03,31.64 93.95,31.55 93.73,31.55 93.64,31.47 93.64,31.34 93.73,31.25 93.95,31.25 94.03,31.16 94.03,25.99 93.48,25.43 v2(93.47,25.43)
  IN3 w0.076: v5(92.84,36.39) v4(93.08,36.16)
DDR_B_D57: length 12.6
  IN1 w0.076: v2(92.82,24.63) 92.82,25.09 93.12,25.39 93.12,25.9 93.37,26.16 93.37,29.38 93.22,29.53 93.22,29.77 93.31,29.86 93.5,29.86 93.59,29.95 93.59,30.07 93.5,30.16 93.31,30.16 93.22,30.25 93.22,30.38 93.31,30.47 93.5,30.47 93.59,30.56 93.59,30.68 93.5,30.77 93.31,30.77 93.22,30.86 93.22,35.37 v4(93.08,35.51)
  IN3 w0.076: v5(92.84,35.74) v4(93.08,35.51)
DDR_B_D58: length 14.2
  IN1 w0.076: v2(93.47,23.83) 93.47,23.76 93.72,23.52 94.6,23.52 95.35,24.27 95.35,32.41 95.29,32.48 95.29,33.89 94.84,34.33 94.84,35.45 v4(94.9,35.51)
  IN3 w0.076: v4(94.9,35.51) v5(94.67,35.74)
DDR_B_D59: length 16.1
  IN1 w0.076: v2(92.82,23.83) 93.3,23.35 94.95,23.35 95.63,24.03 95.63,32.48 95.49,32.62 95.49,35.36 95.19,35.67 95.19,35.87 v4(94.9,36.16)
  IN3 w0.076: v4(94.9,36.16) v5(94.67,36.39)
DDR_B_D60: length 12.8
  IN1 w0.076: v4(93.08,37.46) 92.76,37.14 92.76,35.38 93,35.14 93,29.35 93.14,29.21 93.14,26.21 92.82,25.89 v2(92.82,25.43)
  IN3 w0.076: v4(93.08,37.46) v5(92.84,37.69)
DDR_B_D61: length 13.3
  IN1 w0.076: v4(93.08,36.81) 93.55,36.34 93.55,34.41 94.26,33.69 94.26,25.98 93.88,25.6 93.88,25.33 93.47,24.93 v2(93.47,24.63)
  IN3 w0.076: v5(92.84,37.04) v4(93.08,36.81)
DDR_B_D62: length 16.7
  IN1 w0.076: v4(94.9,36.81) 94.9,36.66 95.34,36.23 95.34,35.73 95.69,35.37 95.69,32.82 95.91,32.61 95.91,23.91 94.71,22.72 93.79,22.72 v2(93.47,23.03)
  IN3 w0.076: v4(94.9,36.81) v5(94.67,37.04)
DDR_B_D63: length 18.5
  IN1 w0.076: v4(94.9,37.46) 95.49,36.87 95.49,35.79 95.85,35.44 95.85,33 96.19,32.66 96.19,23.9 94.84,22.55 93.3,22.55 v2(92.82,23.03)
  IN3 w0.076: v4(94.9,37.46) v5(94.67,37.69)
DDR_B_DQS0: length 15
  IN3 w0.076: v5(85.42,24.38) 85.32,24.48 84.93,24.48 84.85,24.4 84.85,24.24 84.69,24.08 83.82,24.08 83.74,24.16 82.93,24.16 82.67,24.41 82.67,26.96 83.37,27.67 84.56,28.85 84.94,28.85 85.04,28.96 85.04,31.08 84.81,31.32 84.81,33.37 84.61,33.57 84.61,34.12 v5(84.86,34.37)
  BOTTOM w0.076: UD1.P10 v5(85.42,24.38)
DDR_B_DQS1: length 12.3
  IN3 w0.076: v5(87.62,24.63) 87.69,24.7 87.69,25.02 87.61,25.1 87.5,25.1 87.37,24.97 87.37,24.47 87.13,24.24 86.81,24.24 86.58,24.47 86.58,25.62 86.64,26 86.81,26.53 86.81,27.05 87.89,28.13 87.89,31.03 87.28,31.64 87.28,33.63 v5(87.37,33.72)
DDR_B_DQS2: length 17.7
  TOP w0.076: UD3.D10 v2(85.42,24.38)
  IN1 w0.076: v2(85.42,24.38) 85.33,24.47 85.22,24.47 85.06,24.32 83.18,24.32 82.58,24.91 82.58,25.79 82.81,26.02 82.81,27.17 83.98,28.34 83.98,33.06 83.28,33.75 83.28,34.94 83.52,35.19 83.52,36.05 83.4,36.18 83.4,37.04 83.32,37.12 83.13,37.12 83.05,37.04 v4(83.05,36.81)
  IN3 w0.076: v5(82.82,37.04) v4(83.05,36.81)
DDR_B_DQS3: length 15.2
  IN1 w0.076: v2(87.62,24.63) 87.52,24.63 87.45,24.56 87.45,24.39 87.28,24.22 86.82,24.22 86.58,24.46 86.58,25.33 85.91,26 85.91,26.81 86.28,27.17 86.28,33.56 86.67,33.95 86.67,34.63 86.17,35.13 86.17,36.39 86.34,36.56 86.55,36.56 86.7,36.7 v4(86.7,36.81)
  IN3 w0.076: v5(86.46,37.04) v4(86.7,36.81)
DDR_B_DQS4: length 10.6
  IN3 w0.076: v5(90.22,25) 90.31,25.08 90.44,25.08 90.62,25.26 90.62,26.13 90.46,26.28 90.46,26.72 90.68,26.94 90.68,31.35 90.46,31.57 90.46,31.81 89.91,32.36 89.91,33.39 90.13,33.61 90.13,33.78 v5(89.89,34.37)
  BOTTOM w0.076: UD1.G10 v5(90.22,25)
DDR_B_DQS5: length 13.1
  IN3 w0.076: v5(92.41,33.72) 92.41,33.55 92.62,33.35 92.62,32.37 92.77,32.21 92.77,28.37 94.19,26.95 94.19,25.9 93.87,25.58 93.87,24.48 93.62,24.23 92.64,24.23 92.18,24.69 92.07,24.69 91.98,24.6 91.98,24.47 v5(92.17,24.27)
  BOTTOM w0.076: UD1.D10 v5(92.17,24.27)
DDR_B_DQS6: length 13.8
  TOP w0.076: UD3.L10 v2(90.22,25)
  IN1 w0.076: v2(90.22,25) 90.33,25.1 90.43,25.1 90.62,25.29 90.62,26.06 90.46,26.22 90.46,26.75 90.7,26.99 90.7,33.71 90.52,33.89 90.4,33.89 90.31,33.98 90.31,34.1 90.4,34.19 90.52,34.19 90.7,34.37 90.7,35.04 90.92,35.27 90.92,36.42 90.76,36.59 90.56,36.59 v4(90.34,36.81)
  IN3 w0.076: v5(90.11,37.04) v4(90.34,36.81)
DDR_B_DQS7: length 16.6
  TOP w0.076: UD3.P10 v2(92.17,24.27)
  IN1 w0.076: v2(92.17,24.27) 92.26,24.36 92.37,24.36 92.56,24.16 94.67,24.16 94.99,24.47 94.99,25.74 94.82,25.9 94.82,33.88 94.53,34.17 94.53,36.42 94.32,36.63 94.17,36.63 v4(93.99,36.81)
  IN3 w0.076: v5(93.75,37.04) v4(93.99,36.81)
DDR_B_DQS#0: length 14.9
  IN3 w0.076: v5(85.42,25.18) 85.5,25.18 85.73,24.95 85.73,24.76 85.6,24.63 84.87,24.63 84.7,24.46 84.7,24.31 84.63,24.23 83.88,24.23 83.8,24.31 82.99,24.31 82.82,24.48 82.82,26.9 84.14,28.22 84.62,28.7 85,28.7 85.19,28.9 85.19,31.14 84.96,31.38 84.96,33.44 84.86,33.54 v5(84.86,33.72)
  BOTTOM w0.076: UD1.P11 v5(85.42,25.18)
DDR_B_DQS#1: length 12.4
  IN3 w0.076: v5(87.62,25.43) 87.22,25.03 87.22,24.54 87.07,24.39 86.87,24.39 86.73,24.53 86.73,25.61 86.79,25.96 86.96,26.51 86.96,26.99 88.05,28.07 88.05,31.09 87.43,31.71 87.43,33.38 87.62,33.57 87.62,33.83 87.37,34.08 v5(87.37,34.37)
DDR_B_DQS#2: length 17.8
  TOP w0.076: UD3.D11 v2(85.42,25.18)
  IN1 w0.076: v4(83.05,36.16) 83.2,36.16 83.37,35.99 83.37,35.25 83.13,35.01 83.13,33.69 83.83,32.99 83.83,28.4 82.66,27.24 82.66,26.09 82.43,25.86 82.43,24.85 83.12,24.16 85.31,24.16 85.34,24.13 85.53,24.13 85.67,24.27 85.67,24.52 85.42,24.77 v2(85.42,25.18)
  IN3 w0.076: v5(82.82,36.39) v4(83.05,36.16)
DDR_B_DQS#3: length 15.3
  IN1 w0.076: v2(87.62,25.43) 87.39,25.2 87.39,24.72 87.29,24.62 87.29,24.45 87.22,24.37 86.88,24.37 86.73,24.52 86.73,25.4 86.07,26.06 86.07,26.74 86.43,27.11 86.43,33.5 86.82,33.89 86.82,34.7 86.32,35.19 86.32,36.33 86.4,36.4 86.53,36.4 86.7,36.24 v4(86.7,36.16)
  IN3 w0.076: v5(86.46,36.39) v4(86.7,36.16)
DDR_B_DQS#4: length 10.6
  IN3 w0.076: v5(90.22,25.8) 90.29,25.73 90.29,25.6 90.15,25.46 90.15,25.33 90.25,25.24 90.38,25.24 90.47,25.32 90.47,26.07 90.31,26.22 90.31,26.79 90.53,27 90.53,31.29 90.31,31.51 90.31,31.75 89.75,32.3 89.75,33.47 89.7,33.53 89.7,33.65 89.77,33.72 89.89,33.72 v5(89.89,33.72)
  BOTTOM w0.076: UD1.G11 90.04,25.61 90.04,25.72 90.12,25.8 v5(90.22,25.8)
DDR_B_DQS#5: length 13.1
  IN3 w0.076: v5(92.17,25.07) 92.17,24.92 92.71,24.38 93.56,24.38 93.72,24.54 93.72,25.65 94.04,25.97 94.04,26.88 92.62,28.3 92.62,32.15 92.46,32.31 92.46,33.28 92.16,33.58 92.16,33.82 v5(92.41,34.37)
  BOTTOM w0.076: UD1.D11 v5(92.17,25.07)
DDR_B_DQS#6: length 13.9
  TOP w0.076: UD3.L11 v2(90.22,25.8)
  IN1 w0.076: v4(90.34,36.16) 90.34,36.29 90.49,36.44 90.69,36.44 90.77,36.36 90.77,35.33 90.55,35.11 90.55,34.43 90.46,34.34 90.33,34.34 90.16,34.17 90.16,33.91 90.33,33.74 90.46,33.74 90.55,33.65 90.55,27.05 90.31,26.82 90.31,26.16 90.47,26 90.47,25.35 90.37,25.26 90.26,25.26 90.15,25.36 90.15,25.73 v2(90.22,25.8)
  IN3 w0.076: v5(90.11,36.39) v4(90.34,36.16)
DDR_B_DQS#7: length 16.6
  TOP w0.076: UD3.P11 v2(92.17,25.07)
  IN1 w0.076: v2(92.17,25.07) 92.17,24.77 92.63,24.31 94.61,24.31 94.83,24.54 94.83,25.67 94.67,25.84 94.67,33.81 94.38,34.11 94.38,36.36 94.26,36.48 94.1,36.48 93.99,36.37 v4(93.99,36.16)
  IN3 w0.076: v5(93.75,36.39) v4(93.99,36.16)
DDR_B_ODT0: length 55.2
  TOP w0.076: v5(88.92,23.03) 89.88,22.07 91.97,22.07 92.51,21.53 92.51,18.92 92.73,18.71 92.88,18.71 93.13,18.46 93.13,18.04 93.4,17.78 93.56,17.78 93.77,17.57 93.77,17.04
  TOP w0.127: RD74.1 93.88,16.93 93.77,17.04
  IN1 w0.076: v4(89.14,23.29) 88.94,23.04 v5(88.92,23.03)
  IN3 w0.076: v5(82.99,33.4) 83.19,33.4 83.35,33.55 83.45,33.55 83.54,33.46 83.54,33.31 83.44,33.2 83.44,33.04 83.55,32.93 83.55,32.8 83.4,32.65 83.4,32.52 83.59,32.33 83.59,32.2 83.4,32.02 83.4,31.86 83.47,31.79 83.56,31.79 83.64,31.71 83.64,31.58 83.54,31.48 83.47,31.48 83.39,31.4 83.39,31.28 83.48,31.18 83.55,31.18 83.64,31.09 83.64,30.97 83.54,30.87 83.47,30.87 83.39,30.79 83.39,30.67 83.48,30.57 83.79,30.57 83.88,30.48 83.88,30.36 83.79,30.26 83.31,30.26 83.24,30.19 83.24,30.02 83.33,29.93 83.72,29.93 83.8,29.86 83.8,29.66 83.56,29.42 83.4,29.42 83.09,29.73 82.97,29.73 82.88,29.64 82.88,29.51 83.21,29.18 83.21,29.07 83.1,28.97 82.99,28.97 82.66,29.3 82.54,29.3 82.45,29.21 82.45,29.08 82.78,28.75 82.78,28.64 82.67,28.54 82.56,28.54 82.23,28.87 82.11,28.87 82.02,28.78 82.02,28.65 82.34,28.33 82.34,28.2 82.25,28.11 82.13,28.11 81.8,28.44 81.67,28.44 81.63,28.39 81.62,28.39 81.44,28.21 81.44,28.08 81.52,28 81.8,28 81.89,27.92 81.89,27.52 81.81,27.44 81.53,27.44 81.44,27.35 81.44,27.23 81.53,27.14 81.64,27.14 81.72,27.05 81.72,26.93 81.63,26.83 81.53,26.83 81.44,26.74 81.44,26.62 81.53,26.53 81.64,26.53 81.73,26.44 81.73,26.31 81.64,26.22 81.53,26.22 81.44,26.13 81.44,26.01 81.53,25.92 81.64,25.92 81.73,25.83 81.73,25.71 81.63,25.61 81.53,25.61 81.44,25.52 81.44,25.4 81.53,25.31 81.64,25.31 81.73,25.22 81.73,25.09 81.64,25 81.53,25 81.44,24.91 81.44,24.79 81.53,24.7 81.64,24.7 81.73,24.62 81.73,24.49 81.64,24.4 81.3,24.4 81.23,24.32 81.23,23.81 81.33,23.71 81.47,23.71 81.68,23.92 81.81,23.92 81.9,23.83 81.9,23.7 81.5,23.31 81.5,23.13 81.57,23.06 81.68,23.06 82.09,23.46 82.21,23.46 82.3,23.37 82.3,23.25 81.91,22.85 81.91,22.73 82,22.63 82.11,22.63 82.37,22.9 82.49,22.9 82.59,22.79 82.59,22.66 82.34,22.4 82.34,22.3 82.44,22.19 82.56,22.19 82.78,22.41 82.9,22.41 83.07,22.23 83.19,22.23 83.27,22.15 83.27,21.86 83.35,21.78 83.48,21.78 83.57,21.87 83.57,22.16 83.66,22.25 83.79,22.25 83.88,22.17 83.88,21.93 83.96,21.84 84.09,21.84 84.18,21.93 84.18,22.33 84.27,22.42 84.53,22.42 84.62,22.34 84.62,21.93 84.7,21.85 84.85,21.85 84.93,21.92 84.93,22.56 85,22.63 85.17,22.63 85.23,22.57 85.23,22.23 85.32,22.14 85.47,22.14 85.55,22.22 85.55,22.7 85.64,22.79 85.76,22.79 85.85,22.7 85.85,22.23 85.94,22.14 86.07,22.14 86.16,22.23 86.16,22.7 86.25,22.79 86.37,22.79 86.46,22.7 86.46,22.23 86.55,22.14 86.68,22.14 86.77,22.23 86.77,22.7 86.86,22.79 86.98,22.79 87.07,22.7 87.07,22.23 87.16,22.14 87.29,22.14 87.38,22.23 87.38,22.43 87.45,22.51 87.61,22.51 87.68,22.44 87.68,22.23 87.77,22.14 87.9,22.14 87.99,22.23 87.99,22.53 87.79,22.73 87.79,22.86 87.88,22.95 88.01,22.95 88.29,22.67 88.29,22.23 88.38,22.14 88.51,22.14 88.6,22.23 88.6,22.73 88.68,22.81 88.81,22.81 88.9,22.72 88.9,22.23 88.99,22.14 89.2,22.14 89.5,22.44 89.5,22.71 89.27,22.94 89.02,22.94 v5(88.92,23.03) 88.94,23.04 v4(89.14,23.29)
DDR_CHA_EN: length 5
  TOP w0.127: v2(109.78,43.67) 110.22,43.22 RC499.2 111.21,43.22 RC501.2
  IN1 w0.061: v2(109.78,43.67) 108.79,43.67 107.94,44.52 107.36,44.52 v4(107.34,44.54)
  IN3 w0.061: v4(107.34,44.54) 107.09,44.3 v5(107.09,44.28)
DDR_CHB_EN: length 7.8
  TOP w0.127: v2(109.38,44.06) 109.38,44.75 v1(109.52,44.89) 109.71,45.08 RC500.2 110.49,45.23 RC502.2
  IN1 w0.061: v4(105.49,45.34) 105.75,45.08 107.78,45.08 108.52,44.34 108.52,44.14 108.75,43.91 109.23,43.91 v2(109.38,44.06)
  IN3 w0.061: v5(105.14,45.32) 105.46,45.32 v4(105.49,45.34)
DDR_PG: length 253.7
  TOP w0.127: RE457.2 255.43,54.97 255.38,54.92 254.47,54.92 254.46,54.93 254.11,54.58 252.89,54.58 252.63,54.31 252.63,50.97 252.88,50.72 254.52,50.72 254.79,50.45 254.79,49.45 255.43,48.81 255.43,48.03 255.85,47.61 v1(255.85,45.69) 255.85,45.47 v2(255.43,45.05)
  IN1 w0.061: v4(48.4,26.16) 48.4,26.4 49.35,27.35 49.97,27.35 50.23,27.09 51.56,27.09 52.22,26.43 52.22,22.25 52.67,21.81 52.67,16.59 v4(52.7,16.55) ; v2(255.43,45.05) 255.2,45.05 v4(254.87,45.38)
  IN2 w0.061: v4(254.87,45.38) 253.46,45.38 252.72,44.63 250.6,44.63 249.4,43.44 237.95,43.44 224.02,29.51 221.61,29.51 219.57,27.47 218.2,27.47 215.19,24.46 208.6,24.46 205.79,27.26 197.59,27.26 197.1,27.74 190.13,27.74 178.07,15.69 153.71,15.69 153.44,15.95 147.68,15.95 143.45,20.19 140.56,20.19 139.94,20.81 130.17,20.81 128.95,22.02 126.42,22.02 125.98,21.58 122.72,21.58 122.14,20.99 113.09,20.99 110.08,17.98 105.55,17.98 104.64,17.06 100.64,17.06 99.91,16.34 97.49,16.34 97.04,15.89 91.71,15.89 91.21,16.39 52.87,16.39 v4(52.7,16.55)
  IN3 w0.061: v5(48.03,26.16) v4(48.4,26.16)
DDR_VTT_CNTL: length 9.6
  BOTTOM w0.076: 64.68,32.39 65.37,33.07 65.37,33.51 65.57,33.72 65.78,33.72 66.09,34.03 UCPU1.C35
  BOTTOM w0.127: UC9.2 60.09,30.01 60.39,29.72 RC383.1 60.68,29.78 60.68,30.57 v1(60.73,30.63) 60.97,30.87 63.16,30.87 64.68,32.39
DDR_XDP_SMBCLK: length 175.6
  TOP w0.127: v2(120.35,31.66) 119.56,31.66 119.01,31.11 118.16,31.11 116.95,29.91 116.95,23.87 117.75,23.07 117.75,21 117.88,20.87 117.88,19.91 118.64,19.15 118.64,15.97 118.33,15.67 v1(118.33,15.52) 118.3,15.49 v2(118.3,14.92) ; v6(51.64,75.54) 51.68,75.58 51.69,75.58 51.82,75.71 52.21,75.71 54.14,73.78 54.14,72.87 53.98,72.7 JXDP1.53
  IN1 w0.061: v4(118.32,14.57) 118.32,14.89 v2(118.3,14.92) ; v4(120.7,31.66) v2(120.35,31.66) ; v4(46.76,43.31) 46.98,43.53 46.98,43.67 46.85,43.8 46.85,47.28 46.6,47.53 43.94,47.53 43.8,47.39 43.8,47.26 v4(44.02,47.04)
  IN3 w0.061: v6(51.64,75.54) 51.44,75.74 51.31,75.74 50.28,74.71 49.54,74.71 49.24,75.01 41.59,75.01 40.18,73.6 40.18,72.41 39.67,71.9 39.67,68.98 40.44,68.22 40.44,66.67 40.17,66.4 40.17,60.18 40.79,59.56 40.79,57.38 39.6,56.2 39.6,53.62 40.31,52.91 40.31,52.29 40.96,51.64 41.59,51.64 42.15,51.08 42.32,51.08 43.84,49.56 43.84,47.22 v4(44.02,47.04) ; v4(46.76,43.31) 46.93,43.14 46.93,41.72 48.18,40.47 49.09,40.47 51.32,38.24 51.89,38.24 52.68,37.44 52.68,36.47 57.31,31.85 57.31,26.05 57.47,25.89 57.47,22.27 57.94,21.79 57.94,21.7 58.01,21.63 58.1,21.4 58.54,20.97 58.54,14.85 60.48,12.91 95.73,12.91 96.05,13.23 100.1,13.23 100.42,12.91 109.29,12.91 109.7,13.32 112.43,13.32 113.09,13.98 117.99,13.98 118.13,14.13 118.13,14.38 v4(118.32,14.57) ; v4(120.7,31.66) 120.76,31.72 v5(120.76,32.28)
  BOTTOM w0.127: RC489.1 122.24,32.62 QC1.1 ; QC1.1 121.11,32.62 v5(120.76,32.28) ; QC1.1 121.36,32.89 RC388.2
DDR_XDP_SMBDAT: length 174.2
  TOP w0.127: v6(51.64,76.12) 51.8,75.96 52.31,75.96 54.4,73.88 54.4,72.86 54.58,72.68 JXDP1.51 ; v2(119.09,31.66) 119.09,31.54 118.91,31.37 118.05,31.37 116.7,30.01 116.7,23.77 117.5,22.97 117.5,20.74 v1(117.54,20.71) 117.63,20.62 117.63,19.8 118.38,19.04 118.38,16.08 117.79,15.49 v2(117.79,14.92)
  IN1 w0.061: v2(117.79,14.92) 117.77,14.89 v4(117.77,14.58) ; v4(43.47,47.02) 43.57,47.12 43.57,47.54 43.75,47.71 46.68,47.71 47.04,47.36 47.04,43.87 47.17,43.74 47.17,43.44 v4(47.3,43.31) ; v4(119.64,31.66) v2(119.09,31.66)
  IN3 w0.061: v4(47.3,43.31) 47.12,43.13 47.12,41.8 48.26,40.66 49.17,40.66 51.4,38.42 51.97,38.42 52.87,37.52 52.87,36.55 57.49,31.93 57.49,26.13 57.65,25.97 57.65,22.35 57.88,22.12 57.88,22.12 58.1,21.9 58.26,21.51 58.72,21.05 58.72,14.93 60.55,13.1 95.66,13.1 95.97,13.42 100.18,13.42 100.5,13.1 109.21,13.1 109.62,13.51 112.35,13.51 113.01,14.17 117.91,14.17 117.95,14.21 117.95,14.41 v4(117.77,14.58) ; v4(43.47,47.02) 43.65,47.2 43.65,49.48 42.24,50.89 42.07,50.89 41.51,51.46 40.88,51.46 40.12,52.21 40.12,52.84 39.42,53.54 39.42,56.28 40.6,57.46 40.6,59.48 39.98,60.1 39.98,66.48 40.25,66.75 40.25,68.14 39.49,68.9 39.49,71.98 39.99,72.49 39.99,73.68 41.51,75.19 49.32,75.19 49.62,74.9 50.2,74.9 51.23,75.93 51.44,75.93 v6(51.64,76.12) ; v4(119.64,31.66) 119.68,31.62 v5(120.03,31.62)
  BOTTOM w0.127: RC387.2 RC488.1 119.27,31.62 v5(120.03,31.62)
DEBUG_TX: length 9.8
  TOP w0.127: v6(234.96,70.3) 235.04,70.38 235.04,71.02 234.3,71.76 RE93.2 RE97.2 234.9,72.68 v1(235.22,72.99)
  BOTTOM w0.127: JDEG1.9 233.13,71.68 232.5,71.05 232.5,69.75 232.83,69.42 234.75,69.42 234.96,69.64 v6(234.96,70.3)
DISPOFF#: length 17.9
  TOP w0.127: v2(35.61,75.81) 35.69,75.74 RV16.1 35.76,75.19 RV83.2 35.55,74.45 35.42,74.32 35.42,73.52 36.1,72.84 v2(36.18,72.84)
  IN1 w0.061: v4(39.53,73.32) 39.31,73.1 37.17,73.1 36.91,72.84 v2(36.18,72.84) ; v2(37.48,77.64) 36.42,77.64 35.75,76.97 35.75,75.95 v2(35.61,75.81)
  IN3 w0.061: v5(40.45,75.62) 40.45,74.65 39.53,73.74 v4(39.53,73.32)
  BOTTOM w0.127: v5(40.45,75.62) 42.28,75.62 44.03,77.37 JEDP1.31
DMIC_CLK: length 331.1
  TOP w0.127: v2(117.19,11.51) 117.28,11.6 117.28,13.04 119.72,15.47 120.2,15.47 121.58,16.85 121.58,17.95 123.63,20.01 124.32,20.01 124.58,20.28 134.86,20.28 136.07,19.07 139.05,19.07 139.4,18.72 139.4,18.46 139.55,18.32 v6(139.56,18.32) 139.56,17.9 139.38,17.72 139.38,17.13 139.71,16.8 146.42,16.8 152.58,14.93 180.11,14.93 182.66,17.48 193.72,17.48 197.13,20.88 197.13,22.12 v1(197.33,22.31) 198.69,23.68 198.69,23.8 198.93,24.05 199.06,24.05 202.4,27.39 206.08,27.39 208.52,24.95 208.52,24.57 208.89,24.2 212.3,24.2 v2(212.36,24.26) ; v2(276.72,22.94) 276.9,23.12 277.16,23.12 RA23.1
  IN1 w0.061: v2(117.19,11.51) 117.3,11.41 117.3,11.22 v4(117.12,11.04) ; v2(212.36,24.26) 212.45,24.17 213.15,24.17 213.6,24.62 216.39,24.62 219.9,28.12 221.37,28.12 222.11,27.38 228.98,27.38 233.78,22.57 239.04,22.57 239.52,22.1 253.69,22.1 257.67,26.08 260.4,26.08 262.65,28.33 274.61,28.33 277.65,25.29 277.65,23.45 277.37,23.17 276.95,23.17 v2(276.72,22.94)
  IN3 w0.061: v5(37.53,75.72) 37.45,75.64 37.45,72.6 38.07,71.98 38.07,66.5 37.59,66.02 37.59,58.22 37.82,57.99 37.82,55.68 37.99,55.51 37.99,53.15 38.28,52.86 38.28,51.43 39.28,50.42 41.07,50.42 42.33,49.17 42.33,47.3 42.67,46.96 42.67,44.49 42.96,44.2 42.96,42.55 43.73,41.78 44.95,41.78 47.12,39.62 48.86,39.62 49.88,38.59 49.88,37.23 54.86,32.25 54.86,28.54 55.69,27.72 55.69,21.68 54.14,20.14 54.14,17.65 61.22,10.57 117.15,10.57 117.3,10.71 117.3,10.86 v4(117.12,11.04)
  BOTTOM w0.127: v6(139.56,18.32) 139.39,18.48 139.39,18.59 139.61,18.8 DV6.1 139.61,19.09 139.39,19.31 139.39,19.51 RV66.2 ; v5(37.53,75.72) 37.53,75.77 37.27,76.03 35.04,76.03 33.93,77.15 33.93,77.34 34.03,77.44 JEDP1.6
DMIC_CLK0: length 2.8
  BOTTOM w0.127: RC565.2 109.35,41.2 UCPU1.CP24
DMIC_CLK_UA1: length 3.5
  TOP w0.127: UA1.5 280.06,24.62 280.01,24.67 279.82,24.67 279.53,24.38 279.53,23.41 279.23,23.12 278.59,23.12 RA23.2
DMIC_DATA0: length 3.5
  BOTTOM w0.127: UCPU1.CN24 108.43,40.97 108.8,40.61 111.64,40.61 RC566.2
DMIC_DATA12: length 330.5
  TOP w0.127: v2(276.72,23.58) 276.92,23.37 277.15,23.37 RA21.1 ; v2(212.36,23.87) 212.28,23.95 208.78,23.95 208.27,24.46 208.27,24.84 205.98,27.13 202.5,27.13 v1(199.04,23.66) 197.7,22.33 197.7,22.18 197.38,21.86 197.38,20.78 193.83,17.23 182.76,17.23 180.21,14.67 152.54,14.67 146.38,16.54 139.61,16.54 139.13,17.02 139.13,17.75 138.98,17.9 v6(138.98,18.32) 139.01,18.32 139.15,18.46 139.15,18.61 138.95,18.81 135.97,18.81 134.76,20.02 124.69,20.02 124.42,19.75 123.74,19.75 121.83,17.85 121.83,16.75 120.3,15.22 119.82,15.22 117.54,12.93 117.54,11.59 v2(117.61,11.51)
  IN1 w0.061: v2(276.72,23.58) 276.94,23.36 277.29,23.36 277.46,23.53 277.46,25.21 274.53,28.14 262.73,28.14 260.48,25.89 257.75,25.89 253.77,21.91 239.44,21.91 238.96,22.39 233.71,22.39 228.91,27.19 222.03,27.19 221.36,27.86 221.27,27.86 221.25,27.83 220.08,27.83 216.68,24.43 213.68,24.43 213.23,23.98 212.47,23.98 v2(212.36,23.87) ; v2(117.61,11.51) 117.49,11.39 117.49,11.21 v4(117.65,11.04)
  IN3 w0.061: v5(37.14,75.73) 37.26,75.62 37.26,72.52 37.88,71.9 37.88,66.58 37.4,66.1 37.4,58.14 37.63,57.92 37.63,55.6 37.81,55.43 37.81,53.07 38.09,52.79 38.09,51.35 39.2,50.24 40.99,50.24 42.14,49.09 42.14,47.22 42.48,46.88 42.48,44.42 42.78,44.12 42.78,42.47 43.65,41.59 44.87,41.59 47.04,39.43 48.78,39.43 49.7,38.51 49.7,37.15 54.68,32.17 54.68,28.46 55.5,27.64 55.5,21.76 53.95,20.21 53.95,17.57 61.14,10.38 117.23,10.38 117.49,10.64 117.49,10.88 v4(117.65,11.04)
  BOTTOM w0.127: v6(138.98,18.32) 139.14,18.48 139.14,18.57 138.92,18.79 DV7.1 138.92,19.09 139.14,19.31 139.14,19.52 RV67.2 ; v5(37.14,75.73) 37.1,75.77 34.94,75.77 33.67,77.04 33.67,77.38 33.63,77.43 JEDP1.5
DMIC_DATA_UA1: length 3.5
  TOP w0.127: RA21.2 278.6,23.37 279.13,23.37 279.27,23.52 v7(279.27,24.01) 279.27,24.48 279.71,24.92 279.98,24.92 280.08,25.02 UA1.4
DPSNK1_DDC_CLK: length 6.4
  IN3 w0.076: v5(31.31,55.8) 30.87,55.8 30.67,56 29.49,56 29.32,56.17 28.7,56.17 28.06,55.52 28.06,55.26 27.54,54.74 27.54,54.27 v5(27.48,54.22)
  BOTTOM w0.127: v5(31.31,55.8) 31.5,56 RT93.1 RT82.1
DPSNK_RBIAS: length 6.6
  IN3 w0.061: v5(31.49,47.23) 31.49,46.79 31.05,46.35 30.26,46.35 29.94,46.67 29.94,47.29
  IN3 w0.076: v5(27.48,49.67) 27.91,49.25 28.36,49.25 29.94,47.67 29.94,47.29
  BOTTOM w0.127: v5(31.49,47.23) 31.49,47.23 RT23.1
DPSRC_RBIAS: length 0.7
  IN1 w0.076: v4(24,55.11) v5(24.23,54.87)
  IN3 w0.076: v5(24.23,54.87) v4(24,55.11)
EC_TOUCHPAD_INTR#: length 114.1
  IN1 w0.061: 268.95,48.36 268.95,48.33 269.12,48.15 v2(269.21,48.15) ; 268.95,48.36 268.95,48.37 268.88,48.37 268.37,48.88 268.37,49.71 268.95,50.29 v4(269.24,50.29) ; 268.95,48.36 v4(268.94,48.35) ; v2(263.44,56.41) 263.19,56.41 v4(263.04,56.25)
  IN3 w0.061: v4(269.24,50.29) 269.24,50.44 265.51,54.17 263.48,54.17 263.02,54.64 263.02,56.23 v4(263.04,56.25) ; v5(197.88,18.7) 197.88,19.45 198.22,19.8 200.04,19.8 200.4,19.43 207.85,19.43 209.61,21.19 209.61,23.61 212.42,26.41 219.13,26.41 219.38,26.16 236.28,26.16 238.78,23.65 261.43,23.65 263.07,25.29 263.88,25.29 268.33,29.75 268.33,32.2 269.63,33.5 269.63,34.82 270.75,35.94 270.75,46.87 269.27,48.35 v4(268.94,48.35)
  BOTTOM w0.127: v5(197.88,18.7) Q3.3
EC_TP_DISABLE#: length 109.4
  TOP w0.127: UE1.N12 271.44,51.21 v2(271.37,51.14)
  IN1 w0.061: v2(271.37,51.14) 269.6,49.37 269.6,48.03 269.47,47.9 268.86,47.9 268.61,48.14 v2(268.55,48.14) 268.55,47.86 v4(268.46,47.77)
  IN3 w0.061: v5(196.06,20.44) 196.06,19.63 196.26,19.42 197.4,19.42 197.89,19.92 200.09,19.92 200.46,19.55 207.8,19.55 209.49,21.25 209.49,23.66 212.37,26.54 219.18,26.54 219.43,26.28 236.33,26.28 238.83,23.78 261.38,23.78 263.02,25.41 263.83,25.41 268.21,29.8 268.21,32.25 269.51,33.55 269.51,34.87 270.63,35.99 270.63,46.79 269.65,47.77 v4(268.46,47.77)
  BOTTOM w0.127: RP13.1 195.52,19.89 v5(196.06,20.44) 196.34,20.72 Q13.6
EC_TP_I2C_CLK: length 134.4
  TOP w0.127: v2(274.89,62.36) 274.97,62.28 RE468.1
  IN1 w0.061: v4(274.64,62.08) 274.64,62.1 274.89,62.35 v2(274.89,62.36)
  IN3 w0.061: v5(193.01,21.1) 192.91,20.78 192.75,20.67 192.02,20.67 191.58,20.46 191.25,20.13 191.25,18.18 191.74,17.69 200.71,17.69 201.23,18.22 208.39,18.22 211.46,21.29 212.19,21.29 213.94,23.04 217.4,23.04 217.77,22.67 222.64,22.67 226.05,19.26 235.47,19.26 236.57,18.15 248.41,18.15 249.86,19.6 264.59,19.6 266.88,21.9 270.85,21.9 272.71,23.76 272.71,25.85 273.46,26.6 273.46,31.27 275.05,32.85 275.05,37.63 276.68,39.26 276.68,40.65 274.74,42.59 274.74,47.3 275.21,47.77 275.21,54.61 274.65,55.17 274.65,62 274.64,62.01 v4(274.64,62.08)
EC_TP_I2C_DAT: length 133
  TOP w0.127: v2(276.15,59.59) 276.16,59.59 RE467.1
  IN1 w0.061: v2(276.15,59.59) 275.94,59.81 v4(275.94,59.86)
  IN3 w0.061: v5(192.44,21.1) 192.43,21.07 191.89,20.81 191.47,20.61 191.06,20.2 191.06,18.1 191.66,17.5 200.78,17.5 201.31,18.03 208.47,18.03 211.54,21.1 212.27,21.1 214.02,22.85 217.32,22.85 217.69,22.48 222.56,22.48 225.97,19.07 235.39,19.07 236.5,17.97 248.49,17.97 249.93,19.41 264.67,19.41 266.96,21.71 270.92,21.71 272.9,23.68 272.9,25.77 273.65,26.52 273.65,31.19 275.23,32.78 275.23,37.55 276.86,39.18 276.86,40.73 274.93,42.67 274.93,47.22 275.4,47.69 275.4,54.69 274.84,55.25 274.84,59.77 274.92,59.86 v4(275.94,59.86)
EDP_AUXN: length 56.9
  IN1 w0.074: v4(42.81,73.02) 43.05,73.26 v2(43.05,73.4)
  IN3 w0.074: v5(84.05,58.12) 83.94,58.23 83.94,58.98 76.19,66.73 74.01,66.73 68.69,72.05 63.99,72.05 62.57,70.63 60.85,70.63 60.5,70.29 53.14,70.29 50.24,73.18 49,73.18 48.48,73.7 42.99,73.7 42.81,73.52 v4(42.81,73.02)
  BOTTOM w0.076: UCPU1.AH4 81.57,54.05 81.57,55.53 81.76,55.72 82.81,55.72 83.89,56.8 83.89,57.21 RV96.1 83.92,57.63 83.92,57.99 v5(84.05,58.12)
EDP_AUXN_R: length 8.3
  TOP w0.112: v2(42.38,76.64) 42.6,76.42 42.6,74.98 43.18,74.4 43.18,74.19 CV17.2
  IN1 w0.074: v2(42.38,76.64) 42.38,76.65 42.56,76.83 42.56,77.13 42.79,77.36 43.59,77.36 44.21,77.98 44.68,77.98 44.86,78.16 44.86,78.27 v4(44.75,78.38)
  IN3 w0.074: v4(44.75,78.38) 44.94,78.19 44.94,77.42 v5(44.83,77.31)
  BOTTOM w0.112: JEDP1.33 v5(44.83,77.31)
EDP_AUXP: length 56.9
  IN1 w0.074: v2(43.57,73.4) 43.39,73.22 v4(43.39,73.02)
  IN3 w0.074: v5(83.63,58.12) 83.74,58.23 83.74,58.89 76.11,66.53 73.93,66.53 68.61,71.85 64.07,71.85 62.66,70.43 60.93,70.43 60.58,70.09 53.05,70.09 50.16,72.98 48.92,72.98 48.4,73.5 43.08,73.5 43.01,73.44 43.01,73.35 43.1,73.26 43.32,73.26 43.39,73.18 v4(43.39,73.02)
  BOTTOM w0.076: v5(83.63,58.12) 83.76,57.99 83.76,57.66 RV97.1 83.73,57.24 83.73,56.87 82.74,55.89 81.69,55.89 81.41,55.6 81.41,54.96 80.97,54.52 80.97,54.11 81.05,54.03 81.2,54.03 81.27,54.1 UCPU1.AH3
EDP_AUXP_R: length 8.3
  TOP w0.112: CV18.2 43.39,74.19 43.39,74.51 v7(43.02,74.89) 42.8,75.11 42.8,76.5 v2(42.95,76.65)
  IN1 w0.074: v2(42.95,76.65) 42.76,76.83 42.76,77.05 42.88,77.16 43.67,77.16 44.29,77.78 44.77,77.78 45.06,78.07 45.06,78.16 v4(45.28,78.38)
  IN3 w0.074: v4(45.28,78.38) 45.14,78.24 45.14,77.39 v5(45.23,77.31)
  BOTTOM w0.112: JEDP1.34 v5(45.23,77.31)
EDP_BIA_PWM: length 231.5
  TOP w0.127: v2(35.87,68.87) 35.91,68.91 37.43,68.91 37.75,69.22 DV3.3 ; v2(126.49,26.85) 126.29,26.85 123.18,23.73 123.18,20.87 v1(122.32,20.01) 120.7,18.39 120.7,17.25 120.32,16.87 v2(120.32,16.79)
  IN1 w0.061: v2(35.87,68.87) v4(36.18,69.18) ; v4(120.25,16.3) 120.32,16.37 v2(120.32,16.79) ; v4(126.71,27.11) 126.71,27.07 v2(126.49,26.85)
  IN2 w0.061: v4(32.45,72.7) 31.85,72.11 31.85,68.74 32.73,67.86 32.73,67.41 31.54,66.22 31.54,65.28 31.06,64.79 31.06,64.15 30.39,63.48 30.39,59.58 28.73,57.92 28.73,47.22 29.11,46.84 29.11,45.63 25.91,42.42 22.17,42.42 21.59,41.85 21.59,41.18 22.17,40.6 22.17,35.58 19.71,33.12 19.71,32.18 18.14,30.62 18.14,25.03 18.39,24.78 18.39,24.77 18.86,24.3 18.86,20.45 21.14,18.16 21.14,16.88 23.34,14.69 25.14,14.69 26.78,13.05 35.22,13.05 37.91,10.36 48.31,10.36 48.91,10.95 53.5,10.95 53.67,11.12 55.09,11.12 55.67,10.54 110.22,10.54 110.22,10.54 112.23,10.54 115.85,14.17 119.31,14.17 120.24,15.1 120.24,16.29 v4(120.25,16.3) ; v4(126.71,27.11) 126.74,27.11 127.01,27.77 127.01,33.88 126.66,34.23 126.66,36.52 121.39,41.78 119.5,41.78 114.34,46.94 113.62,46.94 112.26,48.3 110.6,48.3 110.3,48 108.28,48 107.76,48.52 107.76,48.89 v4(106.89,49.75)
  IN3 w0.061: v5(105.79,49.43) 106.58,49.43 v4(106.89,49.75) ; v4(32.45,72.7) 32.03,72.28 32.03,72.05 32.27,71.81 33.55,71.81 v4(36.18,69.18)
