# Allegro board LAG441PR10-1221_GCR.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_DP2_CTRL_DATA: length 105.9
  TOP w0.127: RT94.2 25.98,57.12 v2(26.05,57.18)
  IN1 w0.061: v4(104.91,61.26) 104.82,61.26 104.24,60.69 102.63,60.69 100.52,62.81 85.81,62.81 81.82,66.8 70.39,66.8 69.98,66.39 68.68,66.39 68.39,66.1 64.06,66.1 62.28,67.5 61.45,68.66 60.43,69.37 59.7,69.64 59.7,69.64 57.75,70.03 55.85,70.88 54.74,71.68 54.39,72.03 53.28,72.03 52.67,72.64 51.05,72.64 50.17,73.51 49.61,73.51 48.73,74.39 42.69,74.39 41.99,73.69 37.23,73.69 36.84,73.3 34.08,73.3 33.58,72.8 33.58,71.11 32.26,69.79 32.26,68.14 31.29,67.18 31.29,65.52 31.29,65.52 31.29,65.36 29.23,63.3 28.97,63.3 27.98,62.3 27.7,62.3 26.92,61.52 26.78,61.17 25.98,60.38 25.98,57.24 v2(26.05,57.18)
  IN3 w0.061: v5(105.52,61.28) 104.92,61.28 v4(104.91,61.26)
  BOTTOM w0.076: RC7.2 106.29,58.48 106.29,56.41 105.86,55.98 105.86,54.58 UCPU1.CH3
  BOTTOM w0.127: v5(105.52,61.28) 105.49,61.25 105.49,61.21 105.47,61.18 105.47,59.67 106.44,58.7 RC7.2
CPU_DP2_HPD: length 119.7
  TOP w0.127: v1(108.63,50.97) 108.22,51.39 v2(108.22,51.63) 108.46,51.87 RC6.1
  IN1 w0.061: v4(86.84,61.05) 87.13,60.76 88.11,60.76 88.89,59.99 91.26,59.99 91.89,60.62 96.39,60.62 97,60.01 v4(97,59.9) ; v4(107.93,51.89) 107.96,51.89 v2(108.22,51.63)
  IN2 w0.061: v4(107.93,51.89) 107.7,51.89 106.65,52.94 106.65,53.6 110.7,57.65 110.7,59.06 110.15,59.61 105.94,59.61 105.76,59.79 102.97,59.79 102.68,59.5 102.27,59.5 101.95,59.82 97.98,59.82 97.76,59.6 97.3,59.6 v4(97,59.9)
  IN3 w0.061: v4(86.84,61.05) 86.64,61.26 84.18,61.26 79.94,65.49 78.63,65.49 76.55,67.58 74.37,67.58 69.05,72.9 63.64,72.9 62.23,71.49 59.97,71.49 v5(59.75,71.27) ; v5(107.75,52.19) 107.75,52.07 v4(107.93,51.89) ; v5(31.17,64.67) 30.58,64.07 30.58,63.31 31.74,62.14 31.74,59.12 31.76,59.1 31.76,56.58 31.24,56.06 30.92,56.06 30.8,56.18 29.53,56.18 29.38,56.32 28.62,56.32 27.81,55.52 v5(27.81,55.37)
  BOTTOM w0.076: UT2.Y6 v5(27.81,55.37)
  BOTTOM w0.127: v5(31.17,64.67) 31.57,65.07 36.36,65.07 36.82,64.6 59.3,64.6 59.98,65.28 59.98,71.04 v5(59.75,71.27)
CPU_DP2_N0: length 56.9
  IN1 w0.074: v4(77.14,56.39) 77.16,56.39 77.3,56.53 77.3,56.6 77.17,56.73 68.18,56.73 67.8,56.35 62.73,56.35 62.11,55.72 60,55.72 57.96,57.76 57.5,57.91 57.08,58.07 56.82,58.14 56.81,58.14 56.47,58.22 54.47,58.22 51.91,55.67 50.01,55.67 48.47,54.14 38.15,54.14 33.67,49.66 32.96,49.66 32.74,49.87 32.01,49.87 31.55,50.34 31.55,50.67 31.45,50.77 31.34,50.77 31.28,50.7 31.28,50.52 31.21,50.45 31.08,50.45 31.01,50.52 v4(31.01,50.91)
  IN3 w0.074: v4(77.14,56.39) 77.17,56.35 77.17,56.07 v5(77.19,56.05) ; v4(31.01,50.91) 30.89,51.05 v5(30.41,51.1)
  BOTTOM w0.076: UCPU1.AC4 77.91,54.12 77.91,54.46 77.82,54.59 77.82,54.84 77.89,54.96 77.89,55.12 77.78,55.34 77.31,55.82 77.31,55.93 v5(77.19,56.05)
CPU_DP2_N0_C: length 2
  BOTTOM w0.076: CT28.1 29.62,51.31 29.21,51.31 28.99,51.1 28.99,50.96 29.06,50.89 29.06,50.78 28.97,50.69 28.72,50.69 28.64,50.76 UT2.AC15
CPU_DP2_N1: length 54.5
  IN1 w0.074: v4(32.42,49.45) 32.64,49.45 32.71,49.38 32.71,49.17 32.79,49.09 33.53,49.09 38.28,53.84 48.67,53.84 50.22,55.39 52.03,55.39 54.59,57.94 56.45,57.94 57,57.8 57.78,57.51 57.89,57.43 59.88,55.44 62.22,55.44 62.83,56.05 70.8,56.05 71.09,56.34 71.81,56.34 72.21,55.94 73.58,55.94 74.06,56.42 76.19,56.42 76.69,55.91 78.05,55.91 78.35,56.21 78.35,56.34 v4(78.21,56.48)
  IN3 w0.074: v5(32.09,49.63) v4(32.42,49.45) ; v5(78.21,56.15) v4(78.21,56.48)
  BOTTOM w0.076: UCPU1.AC1 78.37,55.48 78.37,55.8 78.29,55.87 77.95,55.87 77.88,55.95 77.88,56.12 77.96,56.2 78.16,56.2 v5(78.21,56.15)
CPU_DP2_N1_C: length 3.7
  BOTTOM w0.076: 29.01,49.9 29.01,50.06 28.88,50.19 28.59,50.19 28.53,50.12 28.53,50.04 28.59,49.97 UT2.AC17
  BOTTOM w0.112: CT30.1 31.32,49.45 29.46,49.45 29.01,49.9
CPU_DP2_N2: length 57.2
  IN1 w0.074: v4(79.16,53.66) 79.55,54.17 79.55,55.08 78.98,55.64 78.47,55.64 78.25,55.43 76.47,55.43 76.05,55.86 74.97,55.86 74.16,55.05 73.52,55.05 73.33,55.24 71.33,55.24 71.01,55.56 63.03,55.56 62.41,54.94 59.7,54.94 57.58,57.07 56.86,57.34 56.36,57.46 54.78,57.46 52.22,54.9 50.48,54.9 48.91,53.33 38.51,53.33 33.63,48.45 32.27,48.45 31.88,48.84 31.13,48.84 v4(31.03,48.95)
  IN3 w0.074: v4(31.03,48.95) v5(30.41,48.89) ; v5(79.4,53.43) v4(79.16,53.66)
CPU_DP2_N2_C: length 2
  BOTTOM w0.076: 29.81,48.87 29.65,48.71 29.5,48.71 29.18,49.03 29.04,49.03 28.92,49.15 28.92,49.18 28.85,49.26 28.55,49.26 28.48,49.19 28.48,49.12 28.55,49.05 UT2.AC19
  BOTTOM w0.112: CT32.1 29.81,48.87
CPU_DP2_N3: length 55.8
  IN1 w0.074: v4(78.7,55.07) 78.57,54.94 76.29,54.94 75.85,55.37 75.17,55.37 74.36,54.57 73.32,54.57 73.12,54.76 71.12,54.76 70.81,55.07 63.25,55.07 62.63,54.45 59.52,54.45 57.35,56.62 56.86,56.83 56.78,56.86 56.3,56.99 55.51,56.99 55.29,56.99 54.98,56.99 52.4,54.41 50.75,54.41 49.01,52.67 45.12,52.67 44.54,52.09 43.62,52.09 43.39,52.32 42.14,52.32 41.75,51.92 41.75,51.44 41.14,50.82 36.74,50.82 33.59,47.67 31.98,47.67 31.57,47.27 31.23,47.27 v4(31.06,47.44)
  IN3 w0.074: v4(31.06,47.44) 30.48,47.44 v5(30.41,47.52) ; v4(78.7,55.07) 78.79,54.99 79.05,54.99 79.39,55.33 v5(79.39,55.38)
  BOTTOM w0.112: UCPU1.AE1 79.39,55.38 v5(79.39,55.38)
CPU_DP2_N3_C: length 2.2
  BOTTOM w0.076: CT34.1 29.65,47.33 29.49,47.33 29.23,47.6 29.23,47.79 28.98,48.04 28.98,48.27 28.9,48.35 28.63,48.35 28.57,48.29 28.57,48.21 UT2.AC21
CPU_DP2_P0: length 56.8
  IN1 w0.074: v4(31.01,51.47) 31.01,51.44 31.47,50.97 31.53,50.97 31.75,50.75 31.75,50.43 32.1,50.07 32.83,50.07 33.04,49.86 33.59,49.86 38.07,54.34 48.39,54.34 49.92,55.87 51.83,55.87 54.38,58.43 56.5,58.43 56.86,58.33 56.88,58.33 57.14,58.26 57.57,58.1 58.07,57.93 60.08,55.92 62.03,55.92 62.65,56.55 67.72,56.55 68.1,56.93 77.25,56.93 77.5,56.68 77.5,56.51 77.6,56.41 v4(77.67,56.41)
  IN3 w0.074: v5(77.57,56.05) 77.57,56.3 v4(77.67,56.41) ; v5(30.41,51.66) 30.53,51.52 v4(31.01,51.47)
  BOTTOM w0.076: UCPU1.AC3 78.27,54.04 78.35,53.97 78.45,53.97 78.53,54.04 78.53,54.23 78.4,54.36 78.16,54.36 78.08,54.44 78.08,54.51 77.99,54.64 77.98,54.8 78.05,54.92 78.05,55.15 77.92,55.44 77.47,55.89 77.47,55.96 v5(77.57,56.05)
CPU_DP2_P0_C: length 1.9
  BOTTOM w0.076: CT27.1 29.64,51.48 29.14,51.48 28.77,51.11 28.48,51.11 UT2.AB15
CPU_DP2_P1: length 54.5
  IN1 w0.074: v4(32.42,48.89) 33.61,48.89 38.36,53.64 48.76,53.64 50.3,55.19 52.11,55.19 54.67,57.74 56.42,57.74 56.94,57.61 57.69,57.33 57.77,57.28 59.8,55.24 62.31,55.24 62.92,55.85 70.89,55.85 71.17,56.14 71.72,56.14 72.13,55.74 73.67,55.74 74.15,56.22 76.1,56.22 76.61,55.71 78.13,55.71 78.55,56.13 78.55,56.3 v4(78.72,56.47)
  IN3 w0.074: v5(78.72,56.14) v4(78.72,56.47) ; v5(32.09,49.07) v4(32.42,48.89)
  BOTTOM w0.076: v5(78.72,56.14) 78.54,55.95 78.54,55.24 UCPU1.AC2
CPU_DP2_P1_C: length 3.7
  BOTTOM w0.076: UT2.AB17 28.5,49.77 28.86,49.77
  BOTTOM w0.112: 28.86,49.77 29.38,49.25 31.32,49.25 CT29.1
CPU_DP2_P2: length 57.2
  IN1 w0.074: v4(31.03,48.39) 31.03,47.99 31.1,47.91 31.28,47.91 31.38,48.01 31.38,48.54 31.48,48.64 31.8,48.64 32.19,48.25 33.71,48.25 38.59,53.13 48.99,53.13 50.56,54.7 52.3,54.7 54.87,57.26 56.33,57.26 56.8,57.15 57.46,56.9 59.62,54.74 62.49,54.74 63.11,55.36 70.92,55.36 71.24,55.04 73.24,55.04 73.44,54.85 74.25,54.85 75.05,55.65 75.96,55.65 76.39,55.23 78.34,55.23 78.55,55.44 78.9,55.44 79.34,55 79.34,54.49 v4(79.16,54.31)
  IN3 w0.074: v5(79.4,54.08) v4(79.16,54.31) ; v4(31.03,48.39) v5(30.41,48.33)
CPU_DP2_P2_C: length 1.9
  BOTTOM w0.076: UT2.AB19 28.44,48.85 28.85,48.85 28.87,48.87 29.11,48.87 29.43,48.54 29.61,48.54 29.81,48.35
  BOTTOM w0.112: CT31.1 29.81,48.35
CPU_DP2_P3: length 55.8
  IN1 w0.074: v4(31.06,46.88) 31.24,47.06 31.65,47.06 32.06,47.47 33.67,47.47 36.82,50.62 41.22,50.62 41.95,51.35 41.95,51.84 42.23,52.12 43.31,52.12 43.54,51.89 44.62,51.89 45.2,52.47 49.1,52.47 50.83,54.2 52.48,54.2 55.07,56.79 55.29,56.79 55.51,56.79 56.27,56.79 56.71,56.67 56.78,56.64 57.24,56.45 59.43,54.25 62.71,54.25 63.34,54.87 70.72,54.87 71.04,54.56 73.04,54.56 73.23,54.36 74.44,54.36 75.25,55.17 75.77,55.17 76.2,54.74 78.51,54.74 v4(78.71,54.54)
  IN3 w0.074: v4(78.71,54.54) 78.99,54.82 79.3,54.82 v5(79.4,54.73) ; v4(31.06,46.88) 30.48,46.88 v5(30.41,46.96)
CPU_DP2_P3_C: length 2.2
  BOTTOM w0.076: UT2.AB21 28.46,47.93 28.86,47.93 29.07,47.72 29.07,47.53 29.42,47.17 29.61,47.17 CT33.1
CPU_ID: length 12.3
  TOP w0.127: CE116.1 256.65,60.03 RE533.2 256.61,59.86 256.22,59.47 v2(256.22,58.49) v1(254.63,58.49) ; v2(261.43,58.1) 261.63,58.1 262.08,57.65 262.99,57.65 UE1.F2
  IN1 w0.061: v2(256.22,58.49) 256.85,57.86 258.58,57.86 259.09,58.37 259.31,58.37 259.59,58.08 261.42,58.08 v2(261.43,58.1)
CPU_POPIRCOMP: length 1.5
  TOP w0.305: RC106.1 v2(97.7,39.08)
  IN1 w0.305: v4(97.63,38.76) 97.7,38.83 v2(97.7,39.08)
  IN3 w0.305: v5(97.4,38.99) v4(97.63,38.76)
CPU_XDP_PRDY#: length 26
  TOP w0.127: v2(72.14,64.76) v1(72.14,65.42) 72.14,66.9 70.75,68.29 70.75,72.43 70.34,72.84 68.63,72.84 68.38,72.59 JXDP1.5
  IN1 w0.061: v4(72.49,64.77) 72.15,64.77 v2(72.14,64.76)
  IN3 w0.061: v5(76.73,59.68) 76.98,59.93 77.22,59.93 77.66,60.37 77.66,60.89 76.53,62.02 76.53,63.38 75.3,64.61 72.65,64.61 v4(72.49,64.77)
  BOTTOM w0.076: v5(76.73,59.68) 76.64,59.59 76.13,59.59 75.92,59.38 75.92,57.56 75.71,57.35 75.71,55.5 UCPU1.W1
CPU_XDP_PREQ#: length 25.5
  IN1 w0.061: v2(68.98,72.26) 68.98,69.91 69.4,69.49 69.4,68.75 v4(69.15,68.49)
  IN3 w0.061: v4(69.15,68.49) 69.19,68.49 72.07,65.62 72.07,64.73 72.35,64.44 75.29,64.44 76.41,63.33 76.41,61.97 77.39,60.99 77.39,60.49 v5(77.41,60.48)
  BOTTOM w0.076: 77.12,60.02 77.12,59.71 76.85,59.44 76.19,59.44 76.11,59.36 76.11,57.37 v1(76.1,57.36) 75.88,57.14 75.88,55.74 76.11,55.51 76.11,55.1 75.83,54.82 UCPU1.W2
  BOTTOM w0.127: RC230.2 77.52,61.61 77.52,60.58 v5(77.41,60.48) 77.41,60.31 77.12,60.02
CPU_XDP_TCK: length 15.2
  TOP w0.127: v2(73.34,55.48) v3(73.34,58.29)
  IN1 w0.061: v2(73.34,55.48) 73.67,55.48 v4(73.76,55.39)
  IN3 w0.061: v5(71.98,56.25) 72.12,56.39 72.76,56.39 v4(73.76,55.39) 74.05,55.1 74.05,52.56 v5(73.52,52.03)
  BOTTOM w0.076: RC244.2 71.47,61.35 71.47,60.79 RC228.1 71.16,60.37 71.7,59.82 71.7,56.53 v5(71.98,56.25)
CPU_XDP_TDI: length 12.3
  TOP w0.127: v2(74.47,55.92) 74.47,56.36 v3(74.17,56.66)
  IN1 w0.061: v4(74.23,55.68) 74.23,55.69 v2(74.47,55.92)
  IN3 w0.061: v5(74.74,55.71) 74.23,55.71 v4(74.23,55.68) 74.23,55.39 74.85,54.77 74.85,53.94 74.89,53.91 74.89,52.47 v5(74.44,52.03)
  BOTTOM w0.076: v5(74.74,55.71) 74.74,57.66 74.7,57.7 74.7,59.39 75.23,59.91 75.23,60.35 RC229.1 74.81,60.76 74.81,61.51 RC240.2
CPU_XDP_TDO: length 12.5
  TOP w0.127: v2(76.23,60.21) v3(76.23,59.37)
  IN1 w0.061: v4(76.53,60.51) v2(76.23,60.21)
  IN3 w0.061: v5(76.95,60.47) 76.91,60.51 v4(76.53,60.51)
  BOTTOM w0.076: RC242.2 76.95,61.66 77.29,61.32 77.29,60.8 76.97,60.47 v5(76.95,60.47) 76.95,60.24 76.45,59.75 76.07,59.75 75.75,59.43 75.75,57.81 75.53,57.59 75.53,55.33 75.56,55.29 75.56,54.84 75.5,54.78 75.5,54.66 75.59,54.57 75.59,54.22 75.52,54.15 75.52,53.89 75.67,53.74 75.98,53.74 76.29,53.43 UCPU1.Y5
CPU_XDP_TMS: length 13.7
  TOP w0.127: v3(71.77,54.49) 72.5,54.49 73.51,53.49 v2(73.51,52.77)
  IN1 w0.061: v2(73.51,52.77) 73.51,52.67 v4(73.27,52.44)
  IN3 w0.061: v5(72.65,56.12) 73.38,55.39 73.38,55.24 73.6,55.02 73.6,52.76 v5(73.52,52.68) 73.51,52.68 v4(73.27,52.44)
  BOTTOM w0.076: RC239.2 72.74,61.35 72.74,60.72 72.49,60.47 RC231.1 72.43,60.22 72.11,59.9 72.11,56.99 72.65,56.45 v5(72.65,56.12)
CPU_XDP_TRST#: length 9.7
  TOP w0.127: v2(77.99,51.87) 78.26,51.87 v3(78.64,52.25)
  IN1 w0.061: v2(77.99,51.87) 77.91,51.87 v4(77.67,52.11)
  IN3 w0.061: v4(77.67,52.11) 77.59,52.03 v5(77.21,52.03)
  BOTTOM w0.076: RC217.2 80.36,57.25 80.36,56.17 80.34,55.97 79.83,55.27 79.77,55.03 79.82,54.89 79.84,54.63 79.75,54.36 79.88,54.07 79.8,53.79 79.69,53.69 79.69,53.23 79.44,52.97 78.91,52.97 78.26,52.33 78.01,52.33 77.71,52.03 v5(77.21,52.03)
  BOTTOM w0.127: RC232.1 RC217.2
CPVEE: length 8.6
  TOP w0.102: v1(290.74,17.93) 290.68,17.99 CA10.1
  TOP w0.203: UA1.25 286.81,21.82 286.9,21.72 286.9,21.39 v6(286.68,21.16)
  TOP w0.305: v6(291.39,19.29) 291.3,19.2 CA10.1
  BOTTOM w0.305: v6(286.68,21.16) 287.5,20.34 288.75,20.34 289.22,19.87 290.81,19.87 v6(291.39,19.29)
CR_EN: length 3.3
  TOP w0.127: RR14.2 RR13.2 290.52,38.66 v1(289.74,37.88) 289.72,37.86 UR2.3
CS_CORE1: length 55.2
  TOP w0.127: v1(44.79,60.29) v2(44.79,61.58) 44.79,61.69 44.55,61.93 PR917.1
  IN1 w0.127: v2(44.79,61.58) 45.07,61.86 v4(45.07,61.88)
  IN1 w0.203: v4(78.41,69.21) 77.93,69.7 77.93,71.94 75.74,74.12 75.36,74.12 v4(74.66,74.83)
  IN3 w0.127: v4(45.07,61.88) 45.07,61.86 v5(44.79,61.58)
  IN3 w0.203: v5(64.43,61.64) 64.43,61.34 63.99,60.9 62.86,60.9 62.47,60.5 55.61,60.5 55.2,60.91 54.31,60.91 53.1,62.12 52.35,62.12 51.23,63.25 50.73,63.25 50.72,63.25 45.62,63.25 45.4,63.04 45.4,62.48 45.27,62.35 45.27,62.08 v4(45.07,61.88) ; v5(74.54,75.44) 74.66,75.32 v4(74.66,74.83) ; v5(79.88,68.57) 79.06,68.57 v4(78.41,69.21)
  BOTTOM w0.203: v5(79.88,68.57) 79.88,67.87 76.19,64.18 66.97,64.18 65.82,63.04 65.82,62.4 65.13,61.7 64.49,61.7 v5(64.43,61.64) ; PU1000.12 v5(74.54,75.44)
CS_CORE2: length 78.7
  TOP w0.127: PR918.1 43.79,62.17 v1(44.08,61.88) 44.37,61.59 v2(44.37,61.59)
  IN1 w0.127: v4(44.58,62.02) 44.58,62.01 44.58,61.8 v2(44.37,61.59)
  IN1 w0.203: v4(86.82,65.25) 86.93,65.25 87.26,64.92 101.99,64.92 103.33,66.25 108.5,66.25 110.1,67.85 111.17,67.85 v4(111.92,68.6)
  IN3 w0.127: v4(44.58,62.02) 44.58,61.8 v5(44.39,61.62)
  IN3 w0.203: v4(44.58,62.02) 44.58,62.13 45.02,62.58 45.02,63.19 45.43,63.59 51.4,63.59 52.49,62.5 53.25,62.5 54.52,61.24 55.25,61.24 55.72,60.77 62.36,60.77 62.85,61.26 v5(63.82,61.26) ; v5(86.07,65.27) 86.09,65.25 v4(86.82,65.25) ; v5(111.21,69.95) 111.21,69.5 111.92,68.79 v4(111.92,68.6)
  BOTTOM w0.127: v5(44.39,61.62) 44.38,61.63 PU900.4
  BOTTOM w0.203: PU1001.12 v5(111.21,69.95) ; v5(86.07,65.27) 86.04,65.3 81.04,65.3 77.86,65.3 76.41,63.85 67.12,63.85 66.15,62.88 66.15,62.26 65.26,61.37 64.72,61.37 64.61,61.26 v5(63.82,61.26)
CS_GT: length 16.5
  TOP w0.127: PR921.1 43.03,61.86 v5(43.19,61.69) 43.77,61.69 44.33,61.14 v1(44.33,57.74) 44.33,56.54 v2(44.33,56.54)
  IN1 w0.061: v4(43.18,61.34) 43.18,61.68 v5(43.19,61.69) ; v2(44.33,56.54) v4(44.76,56.54)
  IN3 w0.061: v5(44.82,54.18) 45.44,54.8 45.44,54.91 45.63,55.1 45.63,55.67 v4(44.76,56.54) ; v5(43.2,61.69) 43.2,61.67 43.18,61.66 v4(43.18,61.34)
  BOTTOM w0.127: v5(43.2,61.69) 43.19,61.7 43.19,61.7 PU900.1 ; v5(44.82,54.18) 44.82,53.7 44.5,53.38 43.12,53.38 42.99,53.26 PU1100.12
CS_SA: length 137.5
  TOP w0.127: PR924.1 42.43,62.64 v1(42.43,61.66) 42.43,60.9 v2(42.33,60.8)
  TOP w0.203: v6(79.79,69.66) 79.36,69.23 78.48,69.23 77.96,69.75 77.96,71.75 75.35,74.36 73.8,74.36 73.47,74.69 73.47,76.21 73.8,76.54 78.98,76.54 79.31,76.21 86.72,76.21 88.01,74.92 88.01,73.68 90.77,70.92 94.9,70.92 96.68,72.7 97.23,73.37 97.94,75.08 99.14,76.28 102.81,76.28 103.26,76.74 120.54,76.74 120.82,76.45 131.66,76.45 131.91,76.19 v2(131.91,66.26)
  IN1 w0.061: v2(131.91,66.26) v4(131.91,66.66)
  IN1 w0.127: v4(42.42,61.22) 42.43,61.21 42.43,60.9 v2(42.33,60.8)
  IN3 w0.127: v4(42.42,61.22) 42.44,61.22 42.47,61.19 v5(42.47,60.89)
  IN3 w0.203: v4(131.91,66.66) 131.8,66.54 130.86,66.54 v5(130.53,66.87)
  BOTTOM w0.127: v5(130.53,66.87) 130.52,66.86 PU1101.10
  BOTTOM w0.203: v6(79.79,69.66) 79.41,69.29 79.41,67.91 76.01,64.51 66.81,64.51 65.47,63.16 65.47,62.51 65,62.04 64.1,62.04 63.1,61.04 61.74,61.04 60.8,60.1 59.68,60.1 59.2,60.58 59.2,61.99 58.71,62.48 42.81,62.48 42.34,62 PU900.48 42.37,60.89 v5(42.47,60.89)
CSSUMA: length 8
  TOP w0.102: v2(45.97,61.31) 45.52,61.31 v1(45.34,61.49) 45.16,61.66 45.16,61.84 44.98,62.02 44.98,63.29 PR917.2
  TOP w0.127: PR918.2 PR917.2
  IN1 w0.061: v4(46.25,61.5) 46.06,61.31 v2(45.97,61.31)
  IN3 w0.061: v5(48.2,58.87) 47.89,58.87 46.25,60.52 v4(46.25,61.5)
CSSUMB: length 9.4
  TOP w0.127: PR921.2 43.03,63.37 43.12,63.28 v2(43.38,63.28)
  IN1 w0.061: v4(44.62,62.8) 44.33,63.09 43.55,63.09 43.38,63.26 v2(43.38,63.28)
  IN3 w0.061: v5(48.44,58.49) 48.16,58.21 47.46,58.21 44.15,61.52 44.15,62.08 44.62,62.54 v4(44.62,62.8)
CSSUMC: length 9.5
  TOP w0.127: PR924.2 42.26,63.62 v2(42.6,63.28)
  IN1 w0.061: v4(44.1,62.77) 43.46,62.77 43.25,62.98 42.9,62.98 v2(42.6,63.28)
  IN3 w0.061: v5(48.44,58.09) 47.41,58.09 44.03,61.47 44.03,62.13 44.21,62.3 44.21,62.67 v4(44.1,62.77)
DAT_SMB: length 5.3
  TOP w0.127: v2(38.81,17.47) 38.71,17.37 38.59,17.37 38.47,17.49 38.47,18.83 38.84,19.2 39.58,19.2 PR196.1
  IN1 w0.061: v4(39.15,17.47) v2(38.81,17.47)
  IN3 w0.061: v5(38.81,17.47) v4(39.15,17.47)
  BOTTOM w0.127: v5(38.81,17.47) 38.4,17.89 JBATT1.5
DAT_TP_SIO_I2C_CLK: length 4
  TOP w0.127: UE1.C12 271.68,59.61 272.11,60.04 272.4,60.04 273.38,61.02 273.38,61.21 274.17,61.99 RE468.2
DBC_EN: length 20.1
  TOP w0.127: RV17.1 117.45,28.45 v2(117.32,28.32)
  IN1 w0.061: v2(117.32,28.32) 117.12,28.12 v4(116.65,28.12)
  IN2 w0.061: v4(116.65,28.12) 115.61,29.16 114.61,29.16 108.53,35.24 107.18,35.24 v4(105.58,36.84)
  IN3 w0.089: v5(105.21,36.74) 105.48,36.74 v4(105.58,36.84)
  BOTTOM w0.102: UCPU1.CE28 103.78,38.2 103.44,37.86 103.44,36.95 103.69,36.7 105.17,36.7 v5(105.21,36.74)
DBC_EN_R: length 23.3
  TOP w0.127: RV88.1 RV17.2 118.03,27.74 117.65,27.36 v3(117.65,27.08) 117.65,23.98 118.21,23.42 v2(118.21,21.37)
  IN1 w0.061: v2(118.21,21.37) 118.2,21.35 v4(117.79,21.35)
  IN3 w0.061: v4(117.79,21.35) 117.82,21.33 120.1,21.33 120.73,20.69 v5(122.87,20.69)
  BOTTOM w0.127: v5(122.87,20.69) 122.87,20.44 123.06,20.25 131.24,20.25 JCAM1.1
DCIN1_EN: length 325
  TOP w0.102: v2(271.43,53.22) 271.44,53.21 UE1.L12
  IN1 w0.061: v4(24.58,22.1) 21.5,22.1 20.15,23.45 17.57,23.45 15.37,25.65 15.37,35.56 14.84,36.09 14.84,36.46 13.92,37.38 13.92,38.61 12.65,39.88 12.65,43.74 13.9,45 13.9,47.61 15.81,49.52 15.81,58.12 v2(15.44,58.49) ; v2(271.43,53.22) v4(271.43,52.87)
  IN2 w0.061: v4(24.58,22.1) 24.58,19.45 26.39,17.64 27.48,17.64 28.12,17 29.44,17 29.45,17 37.02,17 37.76,16.26 40.07,16.26 40.53,16.71 46.11,16.71 49.16,13.67 52.32,13.67 52.81,14.16 53.43,14.16 53.58,14.31 56.98,14.31 58.05,13.23 96.72,13.23 97.18,13.69 100.86,13.69 101.07,13.89 103.64,13.89 103.95,13.59 109.39,13.59 113.95,18.15 122.98,18.15 123.45,18.63 126.77,18.63 128.55,17.9 131.69,17.9 133.48,16.11 133.48,13.93 133.88,13.53 152.45,13.53 152.71,13.27 179.14,13.27 182.68,16.82 200.95,16.82 202.55,18.42 211.85,18.42 212.17,18.74 217.21,18.74 237.9,39.43 253.43,39.43 254.59,40.59 255.61,40.59 256.26,41.24 262.25,41.24 264.17,43.16 266.14,43.16 267.24,44.26 268.47,44.26 271.43,47.21 v4(271.43,52.87)
DCIN2_EN: length 365.1
  TOP w0.102: v2(264.79,53.74) 264.79,53.76 UE1.K4
  TOP w0.127: 19.15,76.78 17.86,75.49 17.86,70.38 17.63,70.15 PR126.1 ; 19.15,76.78 20.26,77.88 v2(21.96,77.88) ; 19.15,76.78 v1(19.14,76.78)
  IN1 w0.061: v2(264.79,53.74) 264.83,53.7 v4(265.21,53.7) ; v4(22.1,77.48) 21.96,77.62 v2(21.96,77.88)
  IN2 w0.061: v4(265.21,53.7) 265.83,53.08 268.55,53.08 269.02,52.61 269.02,51.76 268.52,51.25 268.52,48.88 267.62,47.99 267.62,45.81 265.74,43.92 263.83,43.92 263.25,43.35 257.3,43.35 257.03,43.62 253.91,43.62 250.88,40.6 238.17,40.6 217.54,19.97 212.5,19.97 211.59,19.06 202.11,19.06 200.64,17.58 182.55,17.58 178.87,13.91 152.97,13.91 152.71,14.18 146.91,14.18 144.2,16.88 133.6,16.88 131.95,18.54 128.68,18.54 126.9,19.26 123.19,19.26 122.72,18.79 113.69,18.79 109.12,14.22 104.21,14.22 103.9,14.53 100.75,14.53 100.55,14.33 97.31,14.33 97.18,14.46 89.62,14.46 89.09,13.93 80.59,13.93 79.96,14.57 75.52,14.57 74.82,13.87 58.31,13.87 57.23,14.95 53.32,14.95 53.17,14.8 52.55,14.8 52.06,14.3 49.42,14.3 46.37,17.36 40.51,17.36 39.25,18.62 37.95,18.62 37.68,18.35 34.54,18.35 28.63,24.26 28.63,29.42 28.92,29.71 28.92,34.92 31,36.99 31,39.2 33,41.21 33,43.03 35.28,45.31 35.28,45.88 35.73,46.33 35.73,48.81 35.99,49.07 35.99,53.16 36.27,53.44 36.27,54.03 37.1,54.87 37.1,61.93 38.3,63.13 38.64,63.13 39,63.49 39,65.04 39.2,65.25 39.2,66.66 39.55,67.01 40.8,67.01 41.12,67.33 41.12,69.03 42.4,70.31 42.4,70.96 41.41,71.95 38.73,71.95 36.31,74.38 36.31,75.25 35.55,76.02 34.56,76.02 34.31,76.26 v4(34.31,77.68)
  IN3 w0.061: v4(22.1,77.48) 23.06,77.48 23.96,78.38 33.97,78.38 34.31,78.03 v4(34.31,77.68)
DDR_A0_ZQ0: length 3.8
  BOTTOM w0.127: UD4.B3 69.97,18.77 70.3,18.45 70.3,16.47 70.16,16.34 RD20.1
DDR_A0_ZQ1: length 5
  BOTTOM w0.127: UD4.B4 69.97,19.56 70.3,19.23 70.3,18.9 70.49,18.71 70.64,18.71 70.98,18.37 70.98,16.9 70.72,16.64 RD19.1
DDR_A1_ZQ0: length 4
  TOP w0.127: RD1.1 60.04,16.72 60.55,17.23 60.55,18.37 60.87,18.69 UD2.B3
DDR_A1_ZQ1: length 5.1
  TOP w0.127: RD2.1 59.48,16.86 59.9,17.27 59.9,18.37 60.09,18.56 60.24,18.56 60.55,18.86 60.55,19.17 60.87,19.49 UD2.B4
DDR_A_CA1_0: length 35
  IN3 w0.076: v5(77.31,33.72) 77.66,33.37 77.66,32.57 77.38,32.29 77.38,31.1 77.05,30.78 77.05,20.05 72.92,15.91 66.61,15.91 64.5,16.23 64.49,16.23 63.92,16.41 v5(61.52,18.23)
  BOTTOM w0.076: RD21.1 60.95,16.73 61.53,17.31 61.53,18.23 v5(61.52,18.23)
DDR_A_CA1_1: length 33.7
  IN3 w0.076: v5(62.17,18.23) 62.58,19.15 62.71,19.27 62.88,19.27 63.27,19.16 63.52,19.08 63.73,18.99 64.3,18.99 64.54,18.92 64.67,18.79 64.87,18.79 65.05,18.97 65.09,19.09 65.27,19.27 65.52,19.27 65.83,18.97 65.83,18.12 66.75,17.2 72.47,17.2 75.51,20.25 75.51,31.94 75.75,32.17 v5(75.75,33.44)
  BOTTOM w0.076: UCPU1.W36 75.48,33.44 v5(75.75,33.44) ; v5(62.17,18.23) 62.16,18.23 62.16,17.18 61.51,16.53 RD23.1
DDR_A_CA1_2: length 34.4
  IN3 w0.076: v5(62.82,18.23) 64.12,16.94 64.42,16.94 64.51,16.85 64.51,16.63 64.6,16.55 64.73,16.55 64.82,16.64 64.82,16.85 64.91,16.94 65.03,16.94 65.12,16.85 65.12,16.61 65.21,16.52 65.34,16.52 65.43,16.6 65.43,16.85 65.52,16.94 65.68,16.94 65.77,16.85 65.77,16.6 65.85,16.53 66.28,16.53 66.55,16.26 72.83,16.26 76.68,20.11 76.68,25.2 76.49,25.39 76.49,25.58 76.68,25.77 76.68,25.96 76.49,26.15 76.49,26.34 76.68,26.53 76.68,26.72 76.49,26.91 76.49,27.1 76.68,27.3 76.68,27.48 76.49,27.68 76.49,27.86 76.68,28.06 76.68,28.25 76.49,28.44 76.49,28.63 76.68,28.82 76.68,29.01 76.49,29.2 76.49,29.39 76.68,29.58 76.68,29.77 76.49,29.96 76.49,30.15 76.68,30.34 76.68,30.59 76.52,30.75 76.52,32.61 v5(76.66,32.75)
  BOTTOM w0.076: v5(62.82,18.23) 62.82,16.48 62.63,16.29 RD25.1
DDR_A_CA1_3: length 35.9
  IN3 w0.076: v5(77.31,34.37) 77.08,33.83 77.05,33.66 77,33.02 76.97,32.74 76.88,31.02 76.88,20.1 72.87,16.08 66.61,16.08 64.53,16.39 63.81,16.89 62.57,18.13 62.57,18.27 v5(62.82,19.03)
  BOTTOM w0.076: v5(62.82,19.03) 62.52,18.73 62.52,16.74 62.07,16.29 RD27.1 ; v5(77.31,34.37) UCPU1.AB34
DDR_A_CA1_4: length 36
  IN3 w0.076: v5(76.66,33.4) 76.78,33.4 76.85,33.33 76.85,33.15 76.77,33.08 76.5,33.08 76.36,32.93 76.36,30.71 76.29,30.65 76.29,20.15 72.57,16.43 66.67,16.43 65.99,17.11 65.69,17.11 65.6,17.2 65.6,17.51 65.52,17.59 65.36,17.59 65.27,17.5 65.27,17.2 65.18,17.11 64.24,17.11 64.11,17.24 64.11,17.58 64.05,17.65 63.71,17.65 63.13,18.22 63.13,18.42 63.21,18.5 63.91,18.5 63.99,18.59 63.99,18.71 63.91,18.8 63.24,18.8 v5(63.21,18.77)
  BOTTOM w0.076: RD29.1 63.16,15.45 63.16,18.72 v5(63.21,18.77) UD4.M3
DDR_A_CA1_5: length 34.5
  IN3 w0.076: v5(67.37,19.03) 67.37,18.85 67.28,18.76 67.05,18.76 66.97,18.85 66.97,19.26 67.08,19.37 68.52,19.37 68.74,19.59 69,19.59 69.15,19.74 69.32,19.74 69.49,19.56 69.78,19.56 70.09,19.26 70.24,19.26 70.32,19.18 70.32,18.72 70.4,18.65 71.23,18.65 71.53,18.94 71.53,19.2 71.44,19.28 71.15,19.28 71.07,19.37 71.07,19.49 71.15,19.58 71.41,19.58 71.48,19.66 71.48,20.25 71.57,20.34 72.06,20.34 72.16,20.44 72.31,20.44 72.56,20.19 72.68,20.19 72.77,20.28 72.77,20.41 72.49,20.69 72.49,20.81 72.58,20.9 72.71,20.9 72.99,20.62 73.11,20.62 73.2,20.71 73.2,20.84 72.92,21.13 72.92,21.26 73,21.35 73.13,21.35 73.42,21.05 73.55,21.05 73.64,21.14 73.64,21.28 73.33,21.58 73.33,21.7 73.42,21.79 73.54,21.79 73.85,21.49 73.98,21.49 74.07,21.57 74.07,21.7 73.69,22.08 73.69,22.21 73.78,22.3 73.9,22.3 74.28,21.92 74.41,21.92 74.5,22.01 74.5,22.13 74.01,22.62 74.01,22.82 74.31,23.12 74.31,23.49 74.01,23.79 74.01,24.02 74.31,24.32 74.31,33.22 74.38,33.3 74.38,33.51 74.26,33.64 74.26,33.81 74.38,33.94 74.38,34.5 74.53,34.65 74.68,34.65 74.79,34.54 v5(74.79,34.37)
  BOTTOM w0.076: RD31.1 67.37,17.71 67.66,18.01 67.66,18.11 67.67,18.11 67.67,18.36 67.66,18.36 67.66,18.74 v5(67.37,19.03)
DDR_A_CA1_6: length 34.5
  IN3 w0.076: v5(76.66,34.7) 76.58,34.78 76.45,34.78 76.38,34.7 76.38,34.12 75.95,33.69 75.64,33.69 75.53,33.8 75.28,33.8 75.2,33.72 75.2,33.49 75.44,33.25 75.44,32.3 75.21,32.07 75.21,22.94 75.12,22.85 74.95,22.85 74.87,22.77 74.87,22.64 74.96,22.55 75.21,22.55 75.28,22.47 75.28,22.31 75.12,22.14 75.12,22.03 75.26,21.89 75.26,21.68 75.19,21.61 74.97,21.61 74.88,21.51 74.88,21.39 74.97,21.31 75.2,21.31 75.28,21.22 75.28,21.09 75.2,21 74.93,21 74.85,20.92 74.85,20.78 74.93,20.7 75.19,20.7 75.26,20.63 75.26,20.42 72.34,17.5 72.09,17.5 71.91,17.68 71.67,17.68 71.48,17.5 66.75,17.5 66.63,17.61 66.63,17.86 66.74,17.97 67.5,17.97 67.62,18.09 67.62,19.12 67.71,19.2 67.94,19.2 68.02,19.13 v5(68.02,19.03)
  BOTTOM w0.076: v5(68.02,19.03) 68.37,18.68 68.37,18.11 68.49,17.99 RD33.1
DDR_A_CA1_7: length 32.6
  IN3 w0.076: v5(75.44,34.7) 75.54,34.7 75.63,34.61 75.63,34.44 75.55,34.36 75.13,34.36 74.89,34.11 74.65,34.11 74.55,34.01 74.55,33.23 74.47,33.16 74.47,24.27 74.23,24.03 74.23,23.78 74.47,23.54 74.47,23.07 74.22,22.81 74.22,22.63 74.65,22.2 74.65,21.94 74.18,21.47 74.18,21.34 74.38,21.14 74.38,21.01 74.29,20.92 74.16,20.92 73.96,21.13 73.84,21.13 73.75,21.04 73.75,20.91 73.95,20.71 73.95,20.58 73.86,20.49 73.73,20.49 73.53,20.7 73.41,20.7 73.32,20.61 73.32,20.48 73.52,20.28 73.52,20.15 73.43,20.06 73.3,20.06 73.09,20.27 72.98,20.27 72.89,20.18 72.89,20.04 73.09,19.84 73.09,19.72 73,19.63 72.87,19.63 72.43,20.07 72.3,20.07 72.21,19.98 72.21,19.85 72.65,19.41 72.65,19.29 72.56,19.2 72.44,19.2 72.07,19.56 71.94,19.56 71.85,19.47 71.85,19.35 72.22,18.98 72.22,18.86 72.13,18.77 72.01,18.77 71.85,18.92 71.74,18.92 71.3,18.48 70.02,18.48 69.94,18.55 69.94,18.66 70.08,18.79 70.08,18.99 70,19.07 69.84,19.07 69.75,18.98 69.75,18.86 69.67,18.78 69.19,18.78 69.09,18.88 68.93,18.88 68.84,18.78 68.51,18.78 68.41,18.88 68.24,18.88 68.13,18.78 67.87,18.78 67.79,18.7 67.79,18.31 67.86,18.23 v5(68.02,18.23)
  BOTTOM w0.076: v5(68.02,18.23) 67.93,18.14 RD35.1
DDR_A_CA1_8: length 33.8
  IN3 w0.076: v5(74.79,33.72) 74.71,33.65 74.71,33.39 74.78,33.33 74.89,33.33 75.11,33.12 75.11,32.46 75.02,32.37 74.72,32.37 74.64,32.29 74.64,24.22 74.41,23.99 74.41,23.82 74.64,23.59 74.64,23.02 74.43,22.81 74.43,22.63 74.8,22.26 74.8,21.88 74.38,21.46 74.38,21.35 74.53,21.2 74.53,20.94 74.42,20.83 74.42,20.75 74.73,20.45 74.73,20.32 74.64,20.23 74.51,20.23 74.23,20.51 74.1,20.51 74.01,20.42 74.01,20.29 74.29,20.01 74.29,19.89 74.2,19.8 74.08,19.8 73.8,20.08 73.67,20.08 73.58,19.99 73.58,19.86 73.86,19.58 73.86,19.46 73.77,19.37 73.65,19.37 73.37,19.65 73.24,19.65 73.15,19.56 73.15,19.43 73.43,19.15 73.43,19.03 73.34,18.94 73.22,18.94 72.94,19.22 72.81,19.22 72.72,19.13 72.72,19 73,18.72 73,18.59 72.91,18.5 72.78,18.5 72.5,18.79 72.38,18.79 72.29,18.7 72.29,18.57 72.53,18.33 72.53,18.2 72.44,18.11 72.31,18.11 71.83,18.59 71.65,18.59 71.43,18.37 71.43,17.95 71.34,17.86 71.21,17.86 71.12,17.94 71.12,18.19 71.04,18.28 70.91,18.28 70.82,18.19 70.82,17.93 70.74,17.85 70.61,17.85 70.53,17.93 70.53,18.19 70.45,18.27 70.31,18.27 70.22,18.17 70.22,17.97 70.11,17.86 69.68,17.86 69.59,17.95 69.59,18.12 69.72,18.24 69.72,18.51 69.63,18.6 69.28,18.6 69.09,18.41 68.92,18.41 68.72,18.61 68.23,18.61 68.17,18.55 68.17,18.43 68.28,18.33 68.28,18.21 68.34,18.15 68.59,18.15 v5(68.67,18.23)
  BOTTOM w0.076: RD37.1 69.05,17.86 v5(68.67,18.23)
DDR_A_CA1_9: length 33.7
  IN3 w0.076: v5(69.32,18.23) 69.4,18.15 69.4,18.05 69.34,17.99 69.16,17.99 69.05,18.1 68.91,18.1 68.79,17.99 67.79,17.99 67.7,17.9 67.7,17.75 67.78,17.67 71.38,17.67 71.6,17.89 71.6,18.27 71.69,18.36 71.84,18.36 71.94,18.26 71.94,17.86 72.1,17.71 72.33,17.71 74.88,20.26 74.88,20.51 74.68,20.7 74.68,21.55 74.96,21.82 74.96,22.32 74.69,22.59 74.69,22.81 74.9,23.02 74.96,23.02 75.05,23.11 75.05,23.23 74.96,23.32 74.89,23.32 74.8,23.41 74.8,23.53 74.9,23.63 74.96,23.63 75.05,23.72 75.05,23.84 74.96,23.93 74.89,23.93 74.8,24.02 74.8,24.14 74.9,24.24 74.96,24.24 75.05,24.33 75.05,24.45 74.96,24.54 74.89,24.54 74.8,24.62 74.8,24.75 74.9,24.85 74.96,24.85 75.05,24.94 75.05,25.06 74.96,25.15 74.89,25.15 74.8,25.23 74.8,25.36 74.9,25.46 74.96,25.46 75.05,25.55 75.05,25.67 74.96,25.76 74.89,25.76 74.8,25.84 74.8,25.97 74.9,26.07 74.96,26.07 75.05,26.15 75.05,26.28 74.96,26.37 74.89,26.37 74.8,26.45 74.8,26.58 74.9,26.68 74.96,26.68 75.05,26.76 75.05,26.89 74.96,26.98 74.89,26.98 74.8,27.06 74.8,27.19 74.9,27.28 74.96,27.28 75.05,27.37 75.05,27.5 74.96,27.59 74.89,27.59 74.8,27.67 74.8,27.8 74.9,27.89 74.96,27.89 75.05,27.98 75.05,28.11 74.96,28.2 74.89,28.2 74.8,28.28 74.8,28.41 74.9,28.5 74.96,28.5 75.05,28.59 75.05,28.72 74.96,28.81 74.89,28.81 74.8,28.89 74.8,29.02 74.9,29.11 74.96,29.11 75.05,29.2 75.05,29.33 74.96,29.42 74.89,29.42 74.8,29.5 74.8,29.63 74.9,29.72 74.96,29.72 75.05,29.81 75.05,29.94 74.96,30.03 74.89,30.03 74.8,30.11 74.8,30.24 74.9,30.33 74.96,30.33 75.05,30.42 75.05,30.55 74.96,30.64 74.89,30.64 74.8,30.72 74.8,30.85 74.9,30.94 74.96,30.94 75.05,31.03 75.05,31.16 74.96,31.25 74.89,31.25 74.8,31.33 74.8,31.46 74.9,31.55 74.96,31.55 75.05,31.64 75.05,31.77 74.96,31.86 74.89,31.86 74.8,31.94 74.8,32.07 74.91,32.18 75.09,32.18 75.27,32.37 75.27,33.19 75.04,33.42 75.04,34.01 75.21,34.18 75.39,34.18 75.44,34.13 v5(75.44,34.05)
  BOTTOM w0.076: RD39.1 69.32,15.71 v5(69.32,18.23)
DDR_A_CA2_0: length 34
  TOP w0.076: UD2.R2 v2(69.32,17.71) 69.54,17.49 RD41.1
  IN1 w0.076: v2(69.32,17.71) 69.32,17.47 69.4,17.39 69.51,17.39 69.6,17.48 69.6,17.71 69.69,17.8 69.82,17.8 69.91,17.71 69.91,17.49 70,17.4 72.02,17.4 76.88,22.27 76.88,23.57 76.77,23.69 76.77,23.9 76.91,24.04 76.91,29.33 76.12,30.12 76.12,30.27 76.21,30.36 76.55,30.36 76.64,30.45 76.64,30.57 76.55,30.66 76.21,30.66 76.12,30.75 76.12,30.88 76.21,30.97 76.55,30.97 76.64,31.06 76.64,31.18 76.55,31.27 76.21,31.27 76.12,31.36 76.12,31.49 76.21,31.58 76.55,31.58 76.64,31.67 76.64,31.79 76.55,31.88 76.21,31.88 76.12,31.97 76.12,32.1 76.21,32.19 76.55,32.19 76.64,32.28 76.64,32.4 76.55,32.49 76.21,32.49 76.12,32.58 76.12,32.71 76.21,32.8 76.55,32.8 76.64,32.89 76.64,33.01 76.55,33.1 76.21,33.1 76.13,33.18 76.13,33.32 76.22,33.41 76.61,33.41 76.95,33.75 76.95,33.87 76.85,33.97 76.85,34.1 76.94,34.19 77.06,34.19 77.16,34.09 77.29,34.09 77.97,34.77 77.97,34.91 77.9,34.97 77.9,35.13 78.09,35.31 78.09,35.76 78.18,35.85 78.42,35.85 78.5,35.76 78.5,35.52 v4(78.49,35.51)
  IN3 w0.076: v5(78.26,35.74) v4(78.49,35.51)
DDR_A_CA2_1: length 33.2
  TOP w0.076: UD2.P2 v2(68.67,17.85) 68.98,17.54 RD43.1
  IN1 w0.076: v4(77.58,35.51) 77.45,35.64 77.28,35.64 76.76,35.12 76.76,34.53 76.38,34.14 76.38,34.01 76.45,33.93 76.45,33.81 76.36,33.72 76.24,33.72 76.16,33.8 76.03,33.8 75.82,33.58 75.82,29.99 76.6,29.21 76.6,24.17 76.34,23.9 76.34,23.69 76.58,23.45 76.58,23.34 76.49,23.25 76.34,23.25 76.24,23.35 76.11,23.35 76.02,23.27 76.02,23.14 76.27,22.9 76.27,22.78 76.18,22.69 76.04,22.69 75.81,22.92 75.68,22.92 75.6,22.84 75.6,22.5 75.69,22.4 76,22.4 76.09,22.32 76.09,22.19 76,22.1 75.69,22.1 75.6,22.01 75.6,21.79 75.46,21.66 75.46,21.53 75.53,21.47 75.53,21.34 75.44,21.25 75.31,21.25 75.25,21.32 75.12,21.32 75.03,21.23 75.03,21.1 75.1,21.04 75.1,20.91 75.01,20.82 74.88,20.82 74.82,20.89 74.69,20.89 74.6,20.8 74.6,20.67 74.67,20.6 74.67,20.48 74.58,20.39 74.45,20.39 74.39,20.45 74.26,20.45 74.17,20.36 74.17,20.24 74.23,20.17 74.23,20.05 74.14,19.96 74.02,19.96 73.95,20.02 73.83,20.02 73.74,19.93 73.74,19.81 73.8,19.74 73.8,19.62 73.71,19.53 73.58,19.53 73.52,19.59 73.4,19.59 73.31,19.5 73.31,19.38 73.37,19.31 73.37,19.19 73.28,19.1 73.15,19.1 73.09,19.16 72.96,19.16 72.87,19.07 72.87,18.94 72.94,18.88 72.94,18.76 72.85,18.67 72.72,18.67 72.66,18.73 72.53,18.73 72.44,18.64 72.44,18.51 72.49,18.47 72.49,18.31 72.42,18.23 72.29,18.23 72.23,18.3 72.1,18.3 71.96,18.16 71.83,18.16 71.76,18.08 71.76,17.81 71.67,17.72 71.54,17.72 71.45,17.81 71.45,17.96 71.36,18.05 70.15,18.05 70.07,18.13 68.77,18.13 68.67,18.04 v2(68.67,17.85)
  IN3 w0.076: v5(77.35,35.74) v4(77.58,35.51)
DDR_A_CA2_2: length 33.9
  TOP w0.076: RD45.1 67.86,17.31 68.02,17.47 v2(68.02,17.85) UD2.N2
  IN1 w0.076: v4(78.49,36.16) 78.32,36.33 78.03,36.33 77.94,36.23 77.94,35.38 77.67,35.12 77.51,35.12 77.31,35.31 77.17,35.31 76.93,35.08 76.93,34.85 77.06,34.72 77.06,34.52 76.67,34.13 76.67,33.7 76.53,33.56 76.1,33.56 75.97,33.43 75.97,30.06 76.76,29.27 76.76,24.1 76.52,23.87 76.52,23.72 76.73,23.51 76.73,22.33 72.48,18.08 72.1,18.08 71.91,17.89 71.91,17.75 71.73,17.57 71.37,17.57 71.28,17.66 71.28,17.79 71.18,17.88 71.06,17.88 70.97,17.8 70.97,17.71 70.88,17.62 70.76,17.62 70.67,17.71 70.67,17.79 70.57,17.88 70.45,17.88 70.36,17.8 70.36,17.71 70.27,17.62 70.17,17.62 70.08,17.71 70.08,17.87 69.98,17.97 69.04,17.97 68.94,17.87 68.94,17.7 69.01,17.62 69.01,17.49 68.91,17.39 68.63,17.39 68.55,17.47 68.55,17.62 68.47,17.69 68.33,17.69 68.25,17.61 68.25,17.47 68.16,17.39 67.65,17.39 67.56,17.48 67.56,17.59 67.81,17.85 v2(68.02,17.85)
  IN3 w0.076: v5(78.26,36.39) v4(78.49,36.16)
DDR_A_CA2_3: length 32.9
  TOP w0.076: v2(68.02,19.03) 68.32,18.74 68.32,17.6 68.42,17.5 RD47.1
  IN1 w0.076: v4(76.05,35.87) 76.05,35.98 75.87,36.16 75.75,36.16 75.56,35.97 75.56,35.83 75.67,35.72 75.67,35.43 75.43,35.19 74.97,35.19 74.85,35.07 74.85,34.58 74.92,34.5 74.92,33.57 74.85,33.49 74.47,33.11 74.47,32.53 74.88,32.11 74.88,29.62 75.68,28.82 75.68,25.83 75.07,25.22 75.07,25.06 75.16,24.97 75.3,24.97 75.39,24.88 75.39,24.75 75.3,24.66 75.16,24.66 75.07,24.57 75.07,24.45 75.16,24.36 75.3,24.36 75.39,24.27 75.39,24.14 75.3,24.05 75.16,24.05 75.07,23.96 75.07,23.63 74.56,23.11 74.56,22.99 74.65,22.89 74.65,22.77 74.56,22.68 74.44,22.68 74.34,22.77 74.22,22.77 74.13,22.68 74.13,22.56 74.22,22.46 74.22,22.33 74.13,22.24 74.01,22.24 73.91,22.34 73.78,22.34 73.69,22.25 73.69,22.12 73.79,22.03 73.79,21.9 73.7,21.81 73.58,21.81 73.48,21.91 73.35,21.91 73.26,21.82 73.26,21.69 73.36,21.6 73.36,21.47 73.27,21.38 73.14,21.38 73.05,21.48 72.92,21.48 72.83,21.39 72.83,21.26 72.93,21.17 72.93,21.04 72.84,20.95 72.71,20.95 72.62,21.05 72.49,21.05 72.33,20.88 72.33,20.67 72.24,20.59 72.03,20.59 71.95,20.5 71.95,20.37 72.04,20.28 72.21,20.28 72.33,20.16 72.33,19.83 71.81,19.31 71.68,19.31 71.48,19.5 71.36,19.5 71.27,19.41 71.27,19.29 71.46,19.09 71.46,18.96 71.22,18.72 70.62,18.72 70.54,18.79 68.57,18.79 68.33,19.03 v2(68.02,19.03)
  IN3 w0.076: v5(76.44,35.74) v4(76.05,35.87)
DDR_A_CA2_4: length 31.8
  TOP w0.076: RD49.1 67.31,17.57 67.7,17.96 67.7,18.7 UD2.M3 v2(67.62,19.29)
  IN1 w0.076: v4(75.29,35.51) 75.17,35.51 74.94,35.74 74.94,36.49 74.63,36.79 74.08,36.79 73.98,36.69 73.98,36.35 74.08,36.25 74.56,36.25 74.64,36.16 74.64,36.03 74.55,35.94 74.23,35.94 74.14,35.85 74.14,35.67 74.22,35.59 74.53,35.59 74.7,35.42 74.7,34.51 74.77,34.44 74.77,33.63 74.7,33.56 74.7,33.55 74.31,33.17 74.31,32.46 74.73,32.05 74.73,29.56 75.53,28.76 75.53,25.89 74.92,25.28 74.92,23.69 71.38,20.15 71.38,19.78 71.04,19.45 70.51,19.45 70.36,19.29 70.06,19.29 69.77,19.58 68.8,19.58 68.51,19.29 v2(67.62,19.29)
  IN3 w0.076: v4(75.29,35.51) v5(75.53,35.74)
DDR_A_CA2_5: length 34.5
  TOP w0.076: RD51.1 62.84,16.77 63.17,17.11 63.17,18.74 v2(63.22,18.78) UD2.F3
  IN1 w0.076: v2(63.22,18.78) 63.06,18.62 63.06,17.95 63.79,17.22 72.06,17.22 77.06,22.23 77.06,29.4 76.82,29.64 76.82,33.39 77.89,34.46 v4(78.19,34.46)
  IN3 w0.076: v5(77.96,34.7) v4(78.19,34.46)
DDR_A_CA2_6: length 35.8
  TOP w0.076: v2(62.82,19.03) 62.49,18.71 62.49,17.56 61.72,16.79 RD53.1
  IN1 w0.076: v4(77.58,36.16) 76.62,35.2 76.54,34.8 76.54,34.68 76.48,34.46 75.66,33.64 75.66,29.93 76.45,29.14 76.45,24.25 76.15,23.95 76.15,23.61 75.44,22.9 75.44,21.86 72.07,18.48 71.51,18.22 70.45,18.22 70.24,18.3 68.68,18.3 67.87,18.07 67.72,17.99 67.65,17.92 67.42,17.78 66.34,17.39 64.65,17.39 63.64,17.71 63.28,18.06 63.23,18.17 63.23,18.31 63.27,18.39 63.36,18.56 63.43,18.64 63.46,18.73 63.46,18.88 63.34,18.99 63.27,19.02 63.22,19.03 v2(62.82,19.03)
  IN3 w0.076: v5(77.35,36.39) v4(77.58,36.16)
DDR_A_CA2_7: length 35
  TOP w0.076: RD55.1 62.28,16.83 62.84,17.39 62.84,18.22 v2(62.82,18.23)
  IN1 w0.076: v4(76.67,36.16) 76.55,35.73 76.42,35.26 76.38,35.01 76.38,34.69 76.33,34.53 75.51,33.7 75.51,29.87 76.3,29.08 76.3,24.31 76,24.01 76,23.68 75.29,22.97 75.29,21.92 71.98,18.61 71.51,18.38 70.48,18.38 70.32,18.46 68.66,18.46 67.89,18.26 67.63,18.14 67.58,18.09 67.44,17.98 66.32,17.56 64.68,17.56 64.58,17.66 64.46,17.94 64.36,18.34 64.13,18.57 63.63,19.01 63.43,19.16 63.15,19.27 62.72,19.27 62.58,19.14 62.58,18.96 62.6,18.87 62.61,18.86 v2(62.82,18.23)
  IN3 w0.076: v5(76.44,36.39) v4(76.67,36.16)
DDR_A_CA2_8: length 34.6
  TOP w0.076: RD57.1 61.16,16.79 62.17,17.8 v2(62.17,18.23)
  IN1 w0.076: v2(62.17,18.23) 62.35,18.41 62.46,18.41 62.55,18.32 62.55,18.13 63.62,17.06 72.1,17.06 77.21,22.17 77.21,29.46 76.99,29.68 76.99,33.34 77.11,33.46 77.23,33.46 77.36,33.33 77.49,33.33 77.58,33.42 77.58,33.54 77.44,33.67 77.44,33.79 77.6,33.95 77.73,33.95 v4(77.96,33.73)
  IN3 w0.076: v5(77.96,33.4) v4(77.96,33.73)
DDR_A_CA2_9: length 33.6
  TOP w0.076: v2(61.52,18.23) 61.52,17.72 61.16,17.36 61.16,17.21 60.6,16.65 RD59.1
  IN1 w0.076: v4(77.96,32.42) 77.85,32.31 77.85,21.85 72.51,16.51 62.79,16.51 61.52,17.78 v2(61.52,18.23)
  IN3 w0.076: v5(77.96,32.75) v4(77.96,32.42)
DDR_A_CKE0: length 41.4
  IN3 w0.076: v5(74.14,33.4) 74.05,33.31 74.05,32.5 73.78,32.23 73.78,32.05 73.87,31.96 73.91,31.96 73.99,31.89 73.99,31.77 73.9,31.69 73.7,31.69 73.61,31.59 73.61,31.47 73.7,31.38 73.9,31.38 73.99,31.29 73.99,31.17 73.9,31.08 73.7,31.08 73.61,30.98 73.61,30.86 73.7,30.77 73.9,30.77 73.99,30.68 73.99,30.56 73.9,30.47 73.71,30.47 73.62,30.37 73.62,30.25 73.7,30.16 73.9,30.16 73.99,30.07 73.99,29.95 73.9,29.86 73.72,29.86 73.61,29.75 73.61,29.63 73.69,29.55 73.9,29.55 73.99,29.46 73.99,29.34 73.9,29.25 73.7,29.25 73.61,29.16 73.61,29.03 73.7,28.94 73.9,28.94 73.99,28.85 73.99,28.73 73.93,28.67 73.9,28.67 73.78,28.55 73.78,28.42 73.88,28.33 73.91,28.33 73.99,28.24 73.99,28.12 73.93,28.06 73.9,28.06 73.79,27.94 73.79,27.82 73.89,27.72 73.91,27.72 73.99,27.63 73.99,27.51 73.93,27.45 73.9,27.45 73.79,27.33 73.79,27.21 73.89,27.11 73.91,27.11 73.99,27.02 73.99,26.9 73.93,26.84 73.88,26.84 73.77,26.73 73.77,26.6 73.88,26.5 73.91,26.5 73.99,26.42 73.99,26.29 73.93,26.23 73.67,26.23 73.56,26.13 73.56,25.97 73.65,25.89 73.91,25.89 73.99,25.81 73.99,25.68 73.9,25.59 73.23,25.59 73.14,25.5 73.14,25.23 73.22,25.15 73.33,25.15 73.46,25.29 73.9,25.29 73.99,25.2 73.99,25.07 73.9,24.98 73.62,24.98 73.52,24.89 73.52,24.76 73.61,24.68 73.9,24.68 73.99,24.59 73.99,24.46 73.69,24.16 73.69,24.07 73.57,23.95 73.57,23.78 73.98,23.36 73.98,23.24 73.88,23.14 73.76,23.14 73.29,23.61 73.16,23.61 73.07,23.52 73.07,23.39 73.63,22.84 73.63,22.71 73.54,22.62 73.42,22.62 73.22,22.81 73.1,22.81 73.01,22.72 73.01,22.6 73.33,22.27 73.33,22.15 73.25,22.06 73.09,22.06 72.64,22.52 72.48,22.52 72.41,22.44 72.41,22.3 72.91,21.8 72.91,21.64 72.8,21.53 72.66,21.53 72.37,21.82 72.24,21.82 72.15,21.73 72.15,21.61 72.48,21.28 72.48,21.16 72.38,21.05 72.27,21.05 71.93,21.39 71.81,21.39 71.72,21.3 71.72,21.18 72.02,20.87 72.02,20.76 71.94,20.68 71.82,20.68 71.31,21.19 71.18,21.19 71.09,21.1 71.09,20.97 71.31,20.76 71.31,20.51 71.05,20.26 70.51,20.26 70.35,20.1 70.04,20.1 69.96,20.01 69.96,19.97 69.87,19.88 69.74,19.88 69.65,19.96 69.65,20.01 69.57,20.1 69.35,20.1 69.22,20.23 69.22,20.37 69.07,20.52 68.93,20.52 68.76,20.35 68.58,20.35 68.41,20.52 68.28,20.52 68.07,20.31 68.07,20.16 68.42,19.82 68.42,19.64 68.33,19.55 67.02,19.55 66.84,19.37 66.67,19.37 66.45,19.59 65.14,19.59 64.77,19.22 v5(64.77,19.03)
  BOTTOM w0.076: RD65.1 64.3,17.99 64.42,18.11 64.42,18.3 64.77,18.66 v5(64.77,19.03)
DDR_A_CKE1: length 42.5
  IN3 w0.076: v5(73.53,32.18) 73.46,32.1 73.46,28.9 73.63,28.73 73.63,26.79 73.49,26.65 73.49,26.27 73.3,26.09 73.08,26.09 72.98,25.99 72.98,25.09 73.53,24.54 73.53,24.13 73.22,23.82 72.82,23.82 72.72,23.71 72.72,23.56 72.92,23.36 72.92,22.96 72.64,22.67 72.17,22.67 72,22.5 72,22.2 71.91,22.11 71.62,22.11 71.45,21.94 71.45,21.86 71.35,21.76 70.79,21.76 70.69,21.86 70.69,21.95 70.6,22.04 70.47,22.04 70.39,21.95 70.39,21.71 70.3,21.63 70.17,21.63 70.08,21.72 70.08,21.95 69.99,22.04 69.86,22.04 69.78,21.95 69.78,21.74 69.69,21.65 69.45,21.65 69.37,21.73 69.37,21.89 69.28,21.99 64.92,21.99 64.56,22.35 63.65,22.35 63.56,22.44 63.56,22.68 63.47,22.77 63.34,22.77 63.25,22.68 63.25,22.44 63.16,22.35 63.04,22.35 62.95,22.44 62.95,22.68 62.86,22.77 62.73,22.77 62.64,22.68 62.64,22.44 62.55,22.35 62.43,22.35 62.34,22.44 62.34,22.68 62.25,22.77 62.12,22.77 62.03,22.68 62.03,22.44 61.94,22.35 61.82,22.35 61.73,22.44 61.73,22.68 61.64,22.77 61.51,22.77 61.42,22.68 61.42,22.44 61.34,22.35 61.21,22.35 61.12,22.44 61.12,22.68 61.03,22.77 60.9,22.77 60.81,22.68 60.81,22.44 60.73,22.35 59.72,22.35 59.62,22.25 59.62,22.09 59.71,22 64.22,22 64.37,21.86 64.37,21.28 64.28,21.19 64.28,20.89 64.37,20.79 64.37,20.51 64.31,20.45 64.31,20.21 64.7,19.83 v5(64.77,19.83)
  BOTTOM w0.076: v5(64.77,19.83) 64.36,19.42 64.09,19.42 63.82,19.16 63.82,18.16 63.74,18.08 RD67.1 ; UCPU1.U37 74.1,32.75 v5(73.53,32.18)
DDR_A_CKE2: length 41.7
  TOP w0.076: RD69.1 66.19,17.69 65.77,18.11 65.77,19.24 v2(65.82,19.29) UD2.K3
  IN1 w0.076: v2(65.82,19.29) 65.76,19.23 65.58,19.23 65.51,19.3 65.51,19.57 65.6,19.66 65.89,19.66 65.98,19.57 66.17,19.57 66.32,19.72 66.49,19.72 66.79,19.42 66.96,19.42 67.1,19.56 67.53,19.56 67.65,19.69 67.82,19.69 67.94,19.56 68.33,19.56 68.41,19.64 68.41,19.98 68.31,20.08 68.02,20.08 67.94,20.16 67.94,20.3 68.02,20.39 68.13,20.39 68.26,20.52 68.44,20.52 68.6,20.35 68.76,20.35 68.9,20.5 69.11,20.5 69.23,20.38 69.23,20.2 69.33,20.09 70.35,20.09 70.55,20.29 70.69,20.29 70.8,20.18 70.97,20.18 71.28,20.49 71.28,20.67 71.36,20.75 71.53,20.75 71.62,20.84 71.62,20.96 71.57,21.02 71.57,21.14 71.67,21.24 71.78,21.24 71.83,21.19 71.97,21.19 72.06,21.28 72.06,21.52 72.19,21.65 72.19,21.85 72.3,21.96 72.63,21.96 74.03,23.35 74.03,23.6 74.12,23.68 74.47,23.68 74.55,23.77 74.55,23.9 74.46,23.99 74.12,23.99 74.03,24.08 74.03,24.21 74.12,24.29 74.53,24.29 74.61,24.38 74.61,24.51 74.52,24.6 74.12,24.6 74.03,24.69 74.03,24.81 74.12,24.9 74.53,24.9 74.61,24.99 74.61,25.12 74.52,25.21 74.21,25.21 74.13,25.29 74.13,25.4 74.27,25.55 74.71,25.55 74.89,25.73 74.89,25.84 74.98,25.93 75.13,25.93 75.22,26.02 75.22,26.15 75.13,26.23 74.98,26.23 74.89,26.32 74.89,26.45 74.98,26.54 75.13,26.54 75.22,26.63 75.22,26.76 75.13,26.84 74.98,26.84 74.89,26.93 74.89,27.06 74.98,27.15 75.13,27.15 75.22,27.24 75.22,27.37 75.13,27.45 74.98,27.45 74.89,27.54 74.89,27.67 74.98,27.76 75.13,27.76 75.22,27.85 75.22,27.98 75.13,28.06 74.98,28.06 74.89,28.15 74.89,28.28 74.98,28.37 75.13,28.37 75.22,28.46 75.22,28.59 75.13,28.67 74.98,28.67 74.89,28.76 74.89,28.96 74.81,29.04 74.7,29.04 74.57,28.91 74.57,28.79 74.44,28.66 74.28,28.66 74.15,28.79 74.15,28.91 74.49,29.25 74.49,29.37 74.26,29.6 74.26,29.73 74.46,29.94 74.46,30.07 74.37,30.16 74.26,30.16 74.04,29.95 73.92,29.95 73.78,30.08 73.78,30.2 73.84,30.27 73.84,30.39 73.93,30.48 74.31,30.48 74.4,30.57 74.4,30.7 74.31,30.79 73.93,30.79 73.84,30.88 73.84,31 73.93,31.09 74.32,31.09 74.41,31.19 74.41,31.31 74.33,31.4 73.93,31.4 73.84,31.49 73.84,31.61 73.93,31.7 74.33,31.7 74.42,31.79 74.42,31.92 74.33,32.01 73.93,32.01 73.84,32.1 73.84,32.36 73.63,32.56 73.63,32.69 73.73,32.78 73.84,32.78 73.98,32.93 73.98,33.05 73.85,33.18 73.85,33.3 73.94,33.39 74.07,33.39 74.33,33.66 74.33,33.91 74.43,34.01 74.43,34.24 74.13,34.53 74.13,34.79 74.28,34.93 v4(74.37,34.93)
  IN3 w0.076: v5(74.14,34.7) v4(74.37,34.93)
DDR_A_CKE3: length 42.5
  TOP w0.076: v2(66.07,19.83) 66.4,19.5 66.4,18.13 66.75,17.78 RD71.1
  IN1 w0.076: v2(66.07,19.83) 65.99,19.91 65.99,20.21 66.22,20.44 66.39,20.44 66.48,20.52 66.48,20.75 66.39,20.84 66.22,20.84 66.11,20.95 66.11,21.11 66.28,21.29 66.45,21.29 66.57,21.16 69.18,21.16 69.44,20.9 70.38,20.9 70.59,21.11 70.85,21.11 70.99,20.97 71.17,20.97 71.52,21.32 71.52,21.51 71.42,21.61 71.3,21.61 71.23,21.69 71.23,21.84 71.31,21.91 71.47,21.91 71.66,22.11 72.57,22.11 73.87,23.42 73.87,25.36 74.21,25.7 74.64,25.7 74.73,25.79 74.73,25.91 74.64,26 74.15,26 74.06,26.09 74.06,26.22 74.15,26.31 74.64,26.31 74.73,26.4 74.73,26.52 74.64,26.61 74.15,26.61 74.06,26.7 74.06,26.83 74.15,26.92 74.64,26.92 74.73,27.01 74.73,27.13 74.64,27.22 74.15,27.22 74.06,27.31 74.06,27.44 74.15,27.53 74.64,27.53 74.73,27.62 74.73,27.74 74.64,27.83 74.15,27.83 74.06,27.92 74.06,28.05 74.15,28.14 74.64,28.14 74.73,28.23 74.73,28.35 74.64,28.44 74.15,28.44 74.06,28.53 74.06,28.66 73.9,28.82 73.9,28.95 74.24,29.28 74.24,29.41 74.15,29.5 74.02,29.5 73.68,29.16 73.56,29.16 73.47,29.25 73.47,29.38 73.81,29.71 73.81,29.84 73.72,29.93 73.59,29.93 73.25,29.59 73.13,29.59 73.05,29.67 73.05,30.17 73.12,30.24 73.6,30.24 73.69,30.33 73.69,30.46 73.59,30.55 73.13,30.55 73.05,30.63 73.05,30.78 73.12,30.85 73.6,30.85 73.69,30.94 73.69,31.07 73.59,31.16 73.12,31.16 73.05,31.24 73.05,31.39 73.12,31.46 73.6,31.46 73.69,31.55 73.69,31.68 73.59,31.77 73.13,31.77 73.05,31.85 73.05,32 73.12,32.07 73.6,32.07 73.69,32.16 73.69,32.28 73.59,32.38 73.15,32.38 73.05,32.48 73.05,32.61 73.12,32.68 73.21,32.68 73.3,32.77 73.3,32.89 73.21,32.99 73.15,32.99 73.05,33.09 73.05,33.22 73.12,33.29 73.12,33.29 73.2,33.38 73.2,33.51 73.04,33.67 73.04,33.82 73.21,33.99 73.38,33.99 73.8,33.57 74.03,33.57 74.18,33.73 74.18,34.2 74.11,34.28 v4(73.91,34.28)
  IN3 w0.076: v5(74.14,34.05) v4(73.91,34.28)
DDR_A_CLK0: length 36.1
  IN3 w0.076: v5(74.62,36.39) 74.49,36.27 74.39,36.27 74.21,36.1 74.21,35.58 74.46,35.34 74.6,35.26 74.82,35.17 75,35.1 75.2,35.03 75.24,35.02 75.46,35.06 75.97,35.27 76.16,35.27 76.72,34.98 76.9,34.8 76.9,34.62 76.7,34.21 76.37,33.84 76.04,33.2 76.04,32.02 75.82,31.8 75.82,20.12 72.59,16.89 66.74,16.89 65.66,17.97 65.66,18.79 v5(65.42,19.03)
  BOTTOM w0.076: RD75.1 65.07,15.63 65.07,18.68 v5(65.42,19.03)
DDR_A_CLK1: length 34.5
  TOP w0.076: RD79.1 65.27,15.63 65.27,17.6 65.11,17.76 65.11,18.38 65.42,18.68 v2(65.42,19.03)
  IN1 w0.076: v4(73.47,36.16) 73.65,36.16 73.79,36.01 73.79,35.4 73.93,35.26 73.93,34.76 73.49,34.31 73.1,34.31 72.73,33.94 72.73,29.52 73.75,28.49 73.75,25.68 73.53,25.46 73.53,23.52 72.43,22.42 71.53,22.42 71.34,22.23 70.51,22.23 70.35,22.07 70.35,21.94 70.17,21.76 69.92,21.76 69.74,21.94 69.74,22.07 69.65,22.16 69.5,22.16 69.32,22.33 69.32,22.52 69.23,22.61 69.1,22.61 69.01,22.52 69.01,22.13 68.84,21.96 68.59,21.96 68.4,22.14 68.4,22.52 68.31,22.61 68.19,22.61 68.1,22.52 68.1,22.15 67.92,21.97 67.67,21.97 67.49,22.15 67.49,22.52 67.4,22.61 67.27,22.61 67.18,22.52 67.18,22.16 67,21.98 66.74,21.98 66.57,22.15 66.57,22.55 66.48,22.65 66.36,22.65 66.27,22.56 66.27,22.33 66.09,22.16 65.32,22.16 65.18,22.02 65.18,19.58 65.33,19.43 65.33,19.13 v2(65.42,19.03)
  IN3 w0.076: v5(73.7,36.39) v4(73.47,36.16)
DDR_A_CLK#0: length 35.1
  IN3 w0.076: v5(65.42,18.23) 65.51,18.14 65.51,17.91 66.68,16.74 72.66,16.74 75.98,20.05 75.98,31.74 76.19,31.95 76.19,33.16 76.5,33.75 76.83,34.12 77.06,34.58 77.06,34.86 76.82,35.1 76.2,35.42 75.94,35.42 75.42,35.2 75.23,35.18 75.23,35.18 74.88,35.31 74.67,35.39 74.55,35.46 74.36,35.65 74.36,36.03 74.45,36.12 74.69,36.12 74.78,36.03 74.78,35.82 74.7,35.74 v5(74.62,35.74)
  BOTTOM w0.076: RD77.1 65.22,15.62 65.22,18.03 v5(65.42,18.23)
DDR_A_CLK#1: length 33.7
  TOP w0.076: RD81.1 65.43,15.63 65.43,17.66 65.27,17.82 65.27,18.08 v2(65.42,18.23)
  IN1 w0.076: v2(65.42,18.23) 65.4,18.25 65.27,18.83 65.17,18.93 65.17,19.37 65.03,19.52 65.03,22.08 65.25,22.31 66.03,22.31 66.12,22.4 66.12,22.62 66.29,22.8 66.55,22.8 66.73,22.62 66.73,22.21 66.81,22.13 66.93,22.13 67.03,22.23 67.03,22.58 67.21,22.76 67.46,22.76 67.64,22.58 67.64,22.21 67.73,22.12 67.85,22.12 67.95,22.21 67.95,22.58 68.12,22.76 68.38,22.76 68.56,22.58 68.56,22.2 68.65,22.11 68.78,22.11 68.86,22.19 68.86,22.58 69.04,22.76 69.29,22.76 69.47,22.58 69.47,22.4 69.56,22.31 69.71,22.31 69.89,22.13 69.89,22 69.98,21.91 70.11,21.91 70.19,22 70.19,22.13 70.45,22.38 71.28,22.38 71.46,22.57 72.37,22.57 73.38,23.58 73.38,25.52 73.6,25.74 73.6,28.43 72.57,29.46 72.57,34.01 73.03,34.47 73.42,34.47 73.78,34.82 73.78,35.2 v4(73.47,35.51)
  IN3 w0.076: v4(73.47,35.51) v5(73.7,35.74)
DDR_A_CS#0: length 46.2
  TOP w0.076: RD61.1 64.51,17.53 v2(64.78,17.8)
  IN1 w0.076: v4(65.09,17.92) 65.09,17.81 65.17,17.73 65.86,17.73 65.93,17.79 65.93,17.91 66.01,17.99 66.2,17.99 66.26,17.92 66.41,17.92 66.5,18.01 66.5,18.12 66.45,18.17 66.44,18.27 66.54,18.45 66.54,18.68 66.65,18.79 67,18.79 67.08,18.86 67.08,19.17 67.17,19.27 67.3,19.27 67.38,19.18 67.38,18.91 67.46,18.83 67.53,18.83 67.6,18.76 67.6,18.66 67.69,18.56 67.82,18.56 67.9,18.64 67.9,18.71 67.98,18.79 68.1,18.79 68.12,18.81 68.31,18.81 68.5,18.63 70.45,18.63 70.53,18.55 71.48,18.55 72.79,19.86 72.79,20.02 72.64,20.17 72.64,20.32 72.75,20.43 72.88,20.43 73.03,20.29 73.16,20.29 73.25,20.38 73.25,20.5 73.1,20.65 73.1,20.77 73.19,20.86 73.31,20.86 73.46,20.71 73.58,20.71 73.67,20.8 73.67,20.93 73.53,21.08 73.53,21.2 73.62,21.29 73.74,21.29 73.89,21.15 74.02,21.15 74.11,21.24 74.11,21.36 73.96,21.51 73.96,21.64 74.05,21.73 74.17,21.73 74.34,21.56 74.46,21.56 74.55,21.65 74.55,21.78 74.39,21.94 74.39,22.07 74.48,22.16 74.61,22.16 74.76,22 74.89,22 74.98,22.09 74.98,22.21 74.82,22.37 74.82,22.5 74.98,22.66 74.98,23.1 75.7,23.81 75.7,24.19 75.79,24.28 75.82,24.28 75.92,24.37 75.92,24.5 75.84,24.58 75.79,24.58 75.7,24.68 75.7,24.81 75.77,24.88 75.82,24.88 75.92,24.98 75.92,25.11 75.84,25.19 75.79,25.19 75.7,25.28 75.7,25.4 75.99,25.7 75.99,28.95 75.19,29.75 75.19,33.3 75.24,33.35 75.24,34.31 75.35,34.41 75.45,34.41 75.56,34.31 75.68,34.31 75.77,34.4 75.77,34.51 75.56,34.72 75.56,34.88 75.98,35.29 76.15,35.29 76.29,35.44 76.29,35.65 76.38,35.75 76.38,35.98 76.31,36.06 76.31,36.28 76.41,36.38 76.41,36.54 76.32,36.63 v4(76.05,36.63) ; v4(65.09,17.92) v2(64.78,17.8) ; v4(65.09,17.92) 65.17,17.99 65.72,17.99 65.82,18.1 65.82,18.25 65.51,18.56 65.51,18.73 65.83,19.04 66.01,19.04 66.19,18.86 66.4,18.86 66.58,19.03 v2(66.72,19.03)
  IN3 w0.076: v4(65.09,17.92) 65.09,17.62 64.91,17.43 64.51,17.43 64.36,17.58 64.36,18.69 v5(64.32,18.73) ; v4(76.05,36.63) v5(75.98,36.3)
  BOTTOM w0.076: v5(75.98,36.3) 76.23,36.05 78.87,36.05 UCPU1.AE32 ; UD4.L3 v5(64.32,18.73)
