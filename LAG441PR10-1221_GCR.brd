# Allegro board LAG441PR10-1221_GCR.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
WWAN_PEWAKE#_R: length 1.4
  TOP w0.127: UN4.4 259.61,42.71 RN81.1
WWAN_PWR_OFF#_R: length 3.4
  TOP w0.127: RN9.1 RN7.2 CN18.1 258.91,33.17 v5(258.91,32.2) 258.49,32.2 v1(258.41,32.29)
  IN1 w0.061: v5(258.91,32.2) 258.88,32.18 v4(258.57,32.18)
  IN3 w0.061: v5(258.91,32.2) 258.88,32.18 v4(258.57,32.18)
WWAN_RADIO_DIS#: length 61.3
  TOP w0.102: RE129.1 273.75,59.01 272.29,57.55 272.08,57.55 271.74,57.21 UE1.F12
  TOP w0.127: v1(260.9,32.75) 260.48,32.75 v2(260.26,32.53) 260.26,31.9 260.4,31.75 QN8.3 ; RE129.1 274.4,59.01 v2(274.41,59)
  IN1 w0.061: v4(259.78,44.22) 260.03,43.97 271.31,43.97 275.32,47.98 275.32,49.99 276.61,51.28 277.22,51.28 280.06,54.12 280.06,58.57 279.61,59.02 278.62,59.02 277.84,58.24 276.41,58.24 275.99,58.66 274.75,58.66 v2(274.41,59) ; v4(260.68,32.53) v2(260.26,32.53)
  IN3 w0.061: v4(260.68,32.53) 263.31,32.53 264.72,33.94 264.72,34.55 264.53,34.74 264.53,35.97 264.9,36.35 264.9,41.09 262.05,43.94 260.05,43.94 v4(259.78,44.22)
WWAN_RADIO_DIS#_R: length 1.6
  TOP w0.127: v2(259.71,32.12) 259.71,31.95 259.52,31.75 QN8.4
  IN1 w0.061: v2(259.71,32.12) v4(259.36,32.12)
  IN3 w0.061: v5(259.4,31.61) 259.4,32.08 v4(259.36,32.12)
WWAN_SUSCLK: length 1.7
  TOP w0.127: v2(274.31,30.72) 274.29,30.73 CN21.1
  IN1 w0.061: v2(274.31,30.72) 274.53,30.94 v4(274.53,31.34)
  IN3 w0.061: v5(274.41,30.99) 274.41,31.21 v4(274.53,31.34)
WWAN_WAKE#: length 40.6
  TOP w0.102: UE1.M13 272.65,52.41 274.11,50.95 v2(274.38,50.95)
  IN1 w0.061: v2(263.24,23.28) 263.32,23.35 265.47,23.35 v4(265.81,23.01) ; v2(274.38,50.95) 274.52,50.95 v4(274.83,51.25)
  IN3 w0.061: v4(265.81,23.01) 266.57,23.76 270.96,23.76 272.16,24.96 272.16,29.84 272.35,30.03 272.35,31.13 273.2,31.98 273.2,34.59 273.29,34.68 273.29,41.83 273.85,42.39 273.85,47.05 274.83,48.02 v4(274.83,51.25)
WWAN_WAKE#_R: length 10.7
  TOP w0.127: RN92.2 262.3,25.13 v1(262.3,24.01) 262.3,23.22 262.76,22.75 263.85,22.75 264.38,23.28 QN7.4 264.97,23.28 v2(265.22,23.02)
  IN1 w0.061: v2(265.22,23.02) 264.88,23.02 v4(264.84,22.98)
  IN3 w0.061: v4(264.84,22.98) 265.2,22.98 v5(265.23,23.01)
  BOTTOM w0.127: JNGFF1.23 263.15,23.21 263.35,23.01 v5(265.23,23.01)
XCLK_BIASREF: length 2.2
  BOTTOM w0.076: UCPU1.CJ1 106.24,56.05 106.59,56.39 RC402.1
XDP_BPM#0: length 17.6
  TOP w0.127: v2(69.89,66.03) 69.89,66.25 69.61,66.53 69.61,67.01 RC245.1
  IN1 w0.061: v2(69.89,66.03) 70.14,66.03 v4(70.22,66.12)
  IN3 w0.061: v4(70.22,66.12) 70.22,65.63 72.08,63.78 75.02,63.78 75.75,63.05 75.75,61.53 75.39,61.17 75.39,60.41 v5(74.99,60.01)
  BOTTOM w0.076: UCPU1.U1 74.48,55.41 74.48,56.94 74.57,57.03 74.57,57.61 74.48,57.7 74.48,59.44 74.99,59.95 v5(74.99,60.01)
XDP_BPM#1: length 19.5
  TOP w0.127: RC246.1 68.05,67.07 69.02,67.07 69.22,66.88 69.22,66.39 v2(68.93,66.09)
  IN1 w0.061: v2(68.93,66.09) 69.26,66.09 v4(69.36,65.99)
  IN3 w0.061: v5(74.62,59.92) 74.62,59.92 74.63,59.92 74.67,59.96 74.67,60.36 75.07,60.75 75.07,61.3 75.46,61.69 75.46,62.93 74.9,63.49 71.96,63.49 69.45,65.99 v4(69.36,65.99)
  BOTTOM w0.076: UCPU1.U2 74.27,54.98 74.27,56.94 74.42,57.09 74.42,57.49 74.21,57.7 v1(74.21,59.58) 74.54,59.92 v5(74.62,59.92)
XDP_BPM#2_R: length 2.4
  TOP w0.127: v2(74.85,54.13) 74.85,54.57 T50.1
  IN1 w0.061: v4(74.51,53.73) 74.85,54.07 v2(74.85,54.13)
  IN3 w0.061: v5(74.51,54.08) v4(74.51,53.73)
XDP_BPM#3_R: length 4.1
  BOTTOM w0.076: T51.1 74.11,57.29 74.11,54.67 74.21,54.58 74.21,53.93 74.51,53.62 UCPU1.U4
XDP_DBRESET#: length 3.3
  TOP w0.127: JXDP1.48 55.48,68.94 54.43,67.89 CC87.1 53.96,67.29 RC248.1
XDP_ITP_PMODE: length 35.8
  TOP w0.127: v2(54.9,65.13) 54.79,65.24 RC125.2 54.79,66.06 RC249.2
  IN1 w0.061: v2(54.9,65.13) v4(55.31,64.96)
  IN3 w0.061: v5(75.77,59.84) 75.78,59.83 75.78,59.78 75.63,59.63 70.16,59.63 69.93,59.4 67.8,59.4 66.81,60.4 66.81,60.8 66.19,61.42 66.03,61.58 66.03,63.93 65.24,64.73 64.34,64.73 62.36,66.71 62.01,66.71 61.79,66.93 59.84,66.93 59.57,66.66 58.43,66.66 57.8,67.29 56.84,67.29 55.31,65.77 v4(55.31,64.96)
  BOTTOM w0.076: UCPU1.W4 75.75,53.43 75.35,53.83 75.35,54.2 75.44,54.29 75.44,54.51 75.35,54.6 75.35,54.84 75.41,54.91 75.41,55.2 75.35,55.26 75.35,58.53 v1(75.44,58.62) 75.53,58.71 75.53,59.57 75.71,59.74 75.71,59.77 v5(75.77,59.84)
XDP_OBS0: length 9
  TOP w0.127: RC245.2 68.26,67.77 66.9,67.77 66.78,67.66 65.89,67.66 65.63,67.91 v2(65.63,68.07) ; JXDP1.21 63.58,72.07 v2(63.14,71.62)
  IN1 w0.061: v2(65.63,68.07) 65.63,68.32 65.62,68.33 65.62,69.22 65.23,69.61 65.23,69.79 64.72,70.29 63.98,70.29 63.14,71.14 v2(63.14,71.62)
XDP_OBS1: length 8.1
  TOP w0.127: v2(62.77,71.61) 62.77,71.8 62.98,72.01 JXDP1.23 ; v2(65.28,68.09) 65.28,67.91 65.78,67.4 RC246.2
  IN1 w0.061: v2(65.28,68.09) 65.28,68.64 65.46,68.82 65.46,69.21 65.11,69.56 65.11,69.74 64.67,70.17 63.93,70.17 62.77,71.33 v2(62.77,71.61)
XDP_PIN1: length 4.5
  TOP w0.127: JXDP1.1 69.58,70.93 70.4,70.11 RC253.2
XDP_PRSENT#: length 2.2
  TOP w0.127: RC225.2 RC243.1 51.66,68.12 51.56,68.22 51.56,68.7 51.88,69.02 JXDP1.60
XDP_PWRBTN#: length 10.9
  TOP w0.127: RC247.2 RC519.1 60.83,67.01 CC88.1 60.83,67.67 61.85,68.68 v2(61.85,68.81)
  IN1 w0.061: v2(57.56,72.31) 57.58,72.29 57.58,71.96 v4(57.6,71.93) ; v4(61.64,69.08) 61.64,69.02 v2(61.85,68.81)
  IN3 w0.061: v5(61.27,68.87) 61.43,68.87 v4(61.64,69.08) ; v5(57.17,71.91) 57.2,71.93 v4(57.6,71.93)
  BOTTOM w0.127: v5(57.17,71.91) 57.48,71.61 60.45,71.61 61.27,70.79 v5(61.27,68.87)
XDP_RST#: length 4.6
  TOP w0.127: RC523.1 54.22,66.63 RC249.1 RC226.2 55.43,67.95 56.08,68.6 JXDP1.46
XDP_TCK0: length 30.4
  TOP w0.127: JXDP1.57 52.77,72.27 v2(52.77,74.69)
  IN1 w0.061: v4(66.73,69.18) 66.97,69.41 66.97,69.86 66.01,70.82 64.78,70.82 64.69,70.72 64.16,70.72 63.7,71.18 63.7,71.83 63.34,72.19 60.65,72.19 60.2,72.64 59.81,72.77 59.58,72.81 59.2,72.81 58.6,73.09 58.14,73.24 56.2,73.24 55.24,74.21 54.33,74.21 53.74,74.8 52.87,74.8 v2(52.77,74.69)
  IN3 w0.061: v5(71.16,61.05) v5(70.52,61.05) 70.52,62.95 66.79,66.68 66.79,68.15 67.06,68.41 67.06,68.86 v4(66.73,69.18)
XDP_TCK1: length 5.8
  TOP w0.127: JXDP1.55 53.38,71.97 53.08,71.67 52.74,71.67 50.68,69.61 50.68,68.03 RC238.2
XDP_TDI: length 31.6
  TOP w0.127: JXDP1.56 53.08,69.69 54.39,71 57,71 57.13,70.87 57.31,70.87 58.02,70.87 63.78,70.87 v2(64.1,71.19)
  IN1 w0.061: v2(64.1,71.19) 64.1,71.08 64.27,70.91 64.61,70.91 64.7,71 66.36,71 67.33,70.03 v4(67.33,69.87)
  IN3 w0.061: v5(75.68,61.05) 76.04,61.41 76.04,63.17 75.14,64.07 72.2,64.07 71.69,64.57 71.69,65.46 69.81,67.34 69.3,67.34 68.6,68.04 68.6,68.68 68.42,68.86 68.42,69.42 67.98,69.87 v4(67.33,69.87)
  BOTTOM w0.076: RC229.2 75.67,61.04 v5(75.68,61.05)
XDP_TDO: length 37
  TOP w0.127: v2(51.94,68.31) 51.99,68.26 53.97,68.26 54.28,68.57 JXDP1.52
  IN1 w0.061: v4(51.65,68.62) 51.94,68.34 v2(51.94,68.31)
  IN3 w0.061: v4(51.65,68.62) 51.78,68.76 59.79,68.76 59.97,68.57 61.36,68.57 61.66,68.28 62.1,68.28 62.5,67.88 62.81,67.88 63.16,68.23 63.16,68.65 64.74,70.23 67.88,70.23 68.61,69.5 68.61,68.94 68.79,68.76 68.79,68.12 69.38,67.53 69.89,67.53 71.88,65.54 71.88,64.65 72.28,64.26 75.22,64.26 76.22,63.25 76.22,61.14 v5(76.31,61.05) 76.37,60.99 v5(76.95,60.99)
XDP_TMS: length 26.7
  TOP w0.127: JXDP1.58 52.48,68.89 52.8,68.57 53.6,68.57 53.84,68.8 v2(53.87,68.8)
  IN1 w0.061: v2(53.87,68.8) 54,68.78 54.35,68.62 54.37,68.61 54.57,68.48 55.23,68.06 55.8,67.48 56.02,67.32 56.18,67.32 v4(56.2,67.31)
  IN3 w0.061: v4(56.2,67.31) 56.38,67.49 59.77,67.49 60.14,67.12 61.87,67.12 62.09,66.9 62.44,66.9 64.42,64.92 65.31,64.92 66.22,64.01 66.22,61.65 67,60.88 67,60.47 67.88,59.59 69.85,59.59 70.39,60.13 70.63,60.13 71.56,61.06 v5(71.74,61.06) 72.32,61.06 v5(72.38,61)
XDP_TRST#: length 35.5
  TOP w0.127: v2(64.49,71.2) 64.49,71.08 63.92,70.5 58.02,70.5 57,70.5 56.85,70.65 54.69,70.65 53.68,69.64 JXDP1.54
  IN1 w0.061: v4(69.04,69.02) 68.9,69.16 68.9,69.34 68.56,69.67 68.56,70.22 67.49,71.29 64.58,71.29 v2(64.49,71.2)
  IN3 w0.061: v5(78.71,60.48) 78.78,60.55 78.78,61.54 75.41,64.91 73.26,64.91 69.15,69.02 v4(69.04,69.02)
  BOTTOM w0.127: RC236.2 RC232.2 79.68,58.23 79.23,58.68 79.06,58.68 v1(78.95,58.78) 78.95,58.84 78.62,59.18 78.62,60.39 v5(78.71,60.48)
XTAL24_IN: length 5
  BOTTOM w0.102: 108.33,57.26 108.33,56.84 107.63,56.14 107.63,55.19 107.73,55.09 107.73,54.83 107.29,54.39 107.29,54.04 UCPU1.CK3
  BOTTOM w0.127: RC375.1 108.33,57.26
XTAL24_IN_R: length 4.1
  BOTTOM w0.127: CC6.1 RC59.1 ; RC59.1 RC375.2 ; RC59.1 108.17,59.76 108.17,59.87 108,60.04 108,61.12 108.13,61.25 108.31,61.25 108.89,60.67 YC1.3
XTAL24_OUT: length 4.3
  BOTTOM w0.102: 107.77,57.22 107.77,56.71 107.28,56.22 107.28,55.29 106.93,54.94 UCPU1.CK2
  BOTTOM w0.127: RC376.1 107.77,57.22
XTAL24_OUT_R: length 4.3
  BOTTOM w0.127: RC376.2 107.77,59.58 RC59.2 ; CC7.1 RC59.2 ; RC59.2 107.75,61.44 YC1.1
XTAL_25_IN: length 2.6
  BOTTOM w0.076: UT2.D22 19.69,47.46 19.69,47.09 19.01,46.41 18.45,46.41 18.28,46.24 RT72.1
XTAL_25_IN_R: length 2.2
  BOTTOM w0.127: RT72.2 18.26,45.42 CT38.1 18.26,44.33 17.75,43.81 YT1.1
XTAL_25_OUT: length 1.6
  BOTTOM w0.076: UT2.D23 19.84,47.15 19.84,47.03 18.85,46.03 RT24.2
XTAL_25_OUT_R: length 3.5
  BOTTOM w0.127: YT1.3 18.84,43.01 CT37.1 RT24.1
N203838: length 2.9
  TOP w0.127: v1(49.01,18.7) 49.34,19.03 PR602.2
  TOP w0.254: PR602.2 49.34,20.91 49.46,21.03 49.46,21.43 PC604.1
N204012: length 2.2
  TOP w0.127: v1(46.49,20.38) PC605.1
  TOP w0.508: PR603.2 46.49,22.4 PC605.1
N16430096: length 3.3
  TOP w0.203: PR224.2 24.95,14.52 v1(25.37,14.95) 25.59,15.17 27,15.17 27.14,15.31 PU200.25
N16636697: length 0.9
  BOTTOM w0.508: PC1420.2 106.64,22.47 PR1404.2
N16837016: length 1.5
  BOTTOM w0.254: PC505.1 113.64,26.96 PR501.1 112.94,26.33 PR510.2
N16935323: length 7.4
  TOP w0.254: PR180.1 16.9,42.62 PU101.3 18.62,42.21 PD102.1 19.12,41.62 19.32,41.81 PC137.1 19.6,41.81 PR192.1 PR181.2 22.01,41.81 v1(22.19,41.63) 22.88,40.94 PQ129.1
N16935337: length 1.9
  TOP w0.127: PQ130.2 27.43,44.16 26.96,43.69 PR1204.1
N16935355: length 3.5
  TOP w0.254: PR182.2 15.98,43.49 PC136.1 15.98,43.39 PR180.2 15.98,41.93 PR186.1 16.33,41.87 16.58,41.62 PD102.2
N16935372: length 2.8
  TOP w0.127: PU101.4 20.41,42.62 PR178.2 PR193.1 21.98,42.59 PC138.1
N16935378: length 1.6
  TOP w0.127: PR182.1 17.18,44.26 17.83,43.62 PU101.1
N16935575: length 1.2
  TOP w0.127: PR187.2 22.85,44.35 22.98,44.48 PU102.1
N16935577: length 4.5
  TOP w0.127: PR187.1 22.91,42.64 PC142.1 24.46,42.64 PR179.2 24.51,42.72 24.92,43.14 24.92,43.24 25.2,43.53 PR188.1 25.27,43.6 PD103.2
N16935624: length 8.7
  TOP w0.127: PR179.1 24.65,43.74 PD103.1 24.65,45.72 ; PU102.3 23.96,45.48 24.2,45.72 24.65,45.72 ; v1(28.41,47.75) 28.08,47.42 PQ130.1 27.15,45.69 PR183.2 PR190.1 25.43,45.74 PC140.1 24.65,45.72
N16935644: length 4.6
  TOP w0.127: PR184.2 20.18,45.41 PC141.1 20.28,45.51 PR194.1 21.57,45.51 21.6,45.48 PU102.4 22.55,45.48 v1(23.51,46.44)
N16935923: length 3.4
  TOP w0.127: PQ129.2 23.09,40.29 PR199.1 22.12,40 v1(21.83,39.71)
N17013446: length 4
  TOP w0.127: v1(26.41,9.14) 25.93,9.62 PR223.2
  TOP w0.254: PQ205.2 25.85,11.18 PR227.1 25.88,10.26 PR223.2
N17091541: length 3.1
  TOP w0.127: PC1426.1 13.16,55.57 PR174.2 13.47,56.57 13.75,56.85 PQ124.2
N17091543: length 8.3
  TOP w0.127: PR160.2 PR163.1 15.17,54.42 15.04,54.42 14.78,54.16 14.78,53.79 14.6,53.61 PQ122.2 14.35,53.61 13,54.96 12.01,54.96 11.73,55.24 11.73,57.05 12.18,57.5 PQ124.1
N17093022: length 1.9
  TOP w0.127: PR154.1 15.43,45.1 PR158.2 15.2,44.9 PQ120.2
N17095689: length 8.1
  TOP w0.127: v1(15.99,74.95) 16.46,74.47 PQ110.1 15.2,73.95 PQ108.2 14.63,71.97 14.5,71.84 14.5,70.67 14.67,70.5 PR124.1 15.38,70.08 15.38,69.85 15.74,69.49 PR122.2
N17095691: length 4.6
  TOP w0.127: PC1425.1 17.26,73.5 PQ110.2 15.81,71.25 PR133.2
N17096830: length 1.8
  TOP w0.127: PQ107.2 14.81,59.72 PR121.2 15.44,59.82 PR118.1
N17207943: length 2.6
  BOTTOM w0.127: PC314.1 200.94,56.79 v1(200.61,57.12)
  BOTTOM w0.508: PC314.1 200.27,55.94 PR309.2
N17207958: length 2.7
  BOTTOM w0.127: PR300.2 201.92,47.43 v1(202.12,47.63)
  BOTTOM w0.508: PR300.2 200.3,47.43 PC305.2
N17829734: length 4
  BOTTOM w0.127: PU500.10 114.71,24.82 114.9,25.01 115.58,25.01 115.89,25.32 PR504.1 115.89,25.86 PR502.2 115.41,26.33 PR501.2
N17837552: length 1.2
  BOTTOM w0.127: PR507.2 111.77,20.87 111.35,20.87 PC500.1
N18204399: length 4.3
  TOP w0.127: PQ109.5 16.84,63.51 17.08,63.75 17.79,63.75 17.98,63.56 17.98,63.2 18.16,63.02 PR127.2 PR1431.2 18.52,64.51 PR132.1
N18206236: length 4.5
  TOP w0.127: PR1432.2 8.5,43.71 9.45,43.71 9.57,43.58 PR172.1 9.63,43.27 PR167.2 10.27,44.33 10.78,44.83 PQ123.5
N18468637: length 5.5
  TOP w0.127: PUB2.2 28,38.61 27.57,38.18 PDB4.1 PDB5.1 27.2,35.91 v1(27.41,35.71) 28.24,35.71 PRB41.1
N18468639: length 2.8
  TOP w0.127: PUB2.1 28.04,39.26 27.76,39.54 v1(27.76,39.85) 27.76,40.09 27.96,40.29 PRB39.2
N18468715: length 1.4
  TOP w0.127: PRB42.1 31.04,37.96 PUB2.4
N18468749: length 2
  TOP w0.127: PDB4.2 25.5,39.12 PRB36.2 PRB46.2
N18468757: length 3.2
  TOP w0.127: PRB47.2 PRB37.2 24.73,36.94 PDB5.2 v1(25.5,35.68)
N18718370: length 1.1
  TOP w0.127: PQ1501.2 28.57,57.13 PR1507.2
N18718373: length 1.1
  TOP w0.127: PR1508.1 28.33,54.94 PQ1501.1
N18719563: length 2.2
  TOP w0.127: v1(21.79,62.57) PR1509.2 21.79,63.94 PQ1502.2
N18719565: length 1.1
  TOP w0.127: PR1510.1 20.39,65.08 PQ1502.1
N18759659: length 18.1
  BOTTOM w0.254: PR701.1 126.01,42.02 125.5,41.51 PU700.8
  BOTTOM w0.508: PQ1506.1 128.48,36.95 126.53,36.95 126.16,36.58 PR1511.1 125.76,36.58 125.33,36.15 125.33,36.14 124.87,35.69 PR703.1 PR702.1 123.82,35.69 122.91,36.6 v1(122.91,37.27) 122.91,38.49 123.8,39.39 125.46,39.39 126.05,39.98 PR701.1
N18767948: length 6.4
  TOP w0.127: PC1503.1 80.94,75.47 PR1512.2 82.36,74.43 82.93,73.86 v2(83.43,73.86)
  IN1 w0.061: v2(85.19,71.6) 85.19,72.19 83.52,73.86 v2(83.43,73.86)
N18767950: length 6.5
  TOP w0.127: PU1500.3 84.48,75.02 PD1503.1 v1(86.18,75.27) 86.66,74.78 PC1502.1 86.66,73.17 PR1513.2 86.7,72.95 PR1514.1
N18767961: length 3.9
  TOP w0.127: PR1500.2 82.16,71.74 PC1501.1 82.4,72.86 PU1500.6 83.43,72.44 PR1504.1
N18768069: length 7.4
  TOP w0.127: PC1505.1 39.33,28.29 PR1516.1 39.03,28.59 v1(38.07,28.59) 37.24,28.59 PR1517.1 PR1518.1 37.02,29.78 PD1502.1 38.64,31.39 PU1501.3
N18768083: length 4.1
  TOP w0.127: v1(40.47,32.45) 40.31,32.29 PC1504.1 40.27,31.39 PR1515.2 39.43,31.4 PR1505.1 39.38,32.14 38.64,32.88 PU1501.4
N18768087: length 3.3
  TOP w0.127: PR1502.2 36.93,36.12 PC1500.1 37.64,34.66 PU1501.6
N19584540: length 2.8
  TOP w0.127: RT51.1 RT52.1 24.03,67.29 RT56.1
  IN1 w0.061: v2(24.04,67.31) 24.04,67.31 v4(24.17,66.99)
  IN3 w0.061: v4(24.17,66.99) 24.23,67.05 v5(24.23,67.43)
  BOTTOM w0.127: v5(24.23,67.43) 24.22,67.42 UT1.F10
N19588867: length 3
  TOP w0.127: RT62.1 24.03,74.47 RT58.1 RT57.1
  IN1 w0.061: v2(23.9,75) 23.9,74.96 v4(24.36,74.5)
  IN3 w0.061: v5(24.06,74.75) 24.12,74.75 v4(24.36,74.5)
  BOTTOM w0.127: v5(24.06,74.75) 24.04,74.75 23.73,74.46 UT5.F10
N20151644: length 20.6
  IN1 w0.254: v2(26.26,23.69) 26.51,23.94 26.51,26.29 25.58,27.22 24.14,27.22 23.2,28.16 23.2,29.31 22.04,30.46 22.04,35.18 21.63,35.59 21.63,37.04 20.52,38.15 20.52,39.11 v4(20.33,39.3)
  IN3 w0.254: v5(20.73,38.96) v4(20.33,39.3)
  BOTTOM w0.254: v5(20.73,38.96) 20.86,38.96 21.07,39.17 PR200.2
N20151664: length 20.6
  IN1 w0.254: v2(27.15,23.69) 26.9,23.95 26.9,26.46 25.8,27.56 24.29,27.56 23.55,28.3 23.55,29.44 22.36,30.63 22.36,35.31 21.95,35.73 21.95,37.17 20.84,38.28 20.84,39.13 v4(21.03,39.33)
  IN3 w0.254: v5(20.73,39.47) v4(21.03,39.33)
  BOTTOM w0.254: PR200.3 20.26,39.17 20.56,39.47 v5(20.73,39.47)
N27076067: length 0.9
  TOP w0.254: PR231.2 PC243.1
N29202294: length 0.8
  BOTTOM w0.508: PC1410.2 PR1416.2
N29724347: length 1.9
  BOTTOM w0.127: v1(117.77,41.33) 118.3,41.87 RC538.2
  BOTTOM w0.305: CC238.1 118.3,43.01 RC538.2
N29724438: length 2.8
  BOTTOM w0.127: QC2.1 114.08,49.9 RC539.2 113.55,49.61 113.38,49.45 113.38,48.39 v1(113.24,48.25)
N30248348: length 16.9
  TOP w0.102: v1(36.11,16.6) 35.86,16.36 35.66,16.36 v2(35.62,16.4)
  TOP w0.203: PR221.1 v2(35.62,16.4)
  IN1 w0.203: v2(35.62,16.4) 35.8,16.4 37.57,18.18 37.57,18.65 38.38,19.45 38.38,20.84 40.5,22.97 41.14,22.97 43.41,25.23 43.41,25.85 43.87,26.32 44.44,26.32 v4(44.6,26.48)
  IN3 w0.203: v4(44.6,26.48) 44.6,26.48 v5(44.93,26.48)
  BOTTOM w0.203: PR211.2 44.93,27.06 v5(44.93,26.48)
N30249106: length 16.5
  TOP w0.203: PR222.1 35.62,15.72 v2(35.3,16.03)
  IN1 w0.203: v2(35.3,16.03) 35.76,16.03 35.8,16.07 35.94,16.07 37.9,18.04 37.9,18.51 38.71,19.31 38.71,20.71 40.64,22.64 41.28,22.64 43.74,25.1 43.74,25.72 44.01,25.99 44.49,25.99 v4(44.59,25.88)
  IN3 w0.203: v4(44.59,25.88) 44.59,25.88 v5(44.93,25.88)
  BOTTOM w0.203: PR211.3 v5(44.93,25.88)
N30252391: length 2.8
  TOP w0.127: v1(36.18,20.25) 35.51,19.58 PR210.2
  TOP w0.508: PC230.2 PR210.2
N30253802: length 2.8
  TOP w0.254: PR233.2 PR234.2 28.67,11.94 PC244.1 28.62,12.88 PR230.2
N30258320: length 1.5
  TOP w0.127: PC225.1 32.54,22.5 v1(32.89,22.85)
N30277718: length 1.7
  TOP w0.127: v1(19.4,18.93) PR208.1
N35113641: length 11.9
  TOP w0.127: v1(11.33,65.49) 11.47,65.35 PQ102.1 12.69,66.25 12.6,66.34 PR115.1 13.06,67.1 v2(13.35,67.1) 13.4,67.15 PC110.2
  IN1 w0.061: v2(13.35,67.1) 13.31,67.29 v4(13.41,67.44)
  IN3 w0.061: v4(13.41,67.44) v5(13.76,67.08)
  BOTTOM w0.127: v5(13.76,67.08) 13.75,67.07 13.75,66.19 14.13,65.8 14.77,65.8 15.15,65.42 15.15,64.53 15.02,64.41 14.64,64.41 13.44,63.2 PQ100.4
N35119332: length 13.3
  TOP w0.127: v2(13.26,62.12) 13.26,62.17 12.83,62.6 PQ103.1 11.73,61.64 PR112.1 11.45,61.93 11.47,61.94 PC111.2 PR105.2 10.49,62.26 v1(10.49,61.38)
  IN1 w0.061: v2(13.26,62.12) 13.02,61.88 v4(13.02,61.87)
  IN3 w0.061: v5(13.35,61.87) v4(13.02,61.87)
  BOTTOM w0.127: v5(13.35,61.87) 14.01,61.87 14.13,61.74 14.13,56.25 13.88,56 PQ101.4
N35124847: length 1.7
  TOP w0.127: PQ107.1 12.53,60.57 12.37,60.72 PR112.2
N35126885: length 2.8
  TOP w0.127: PQ109.6 17.49,62.87 17.23,62.6 16.03,62.6 15.36,61.93 PR113.2
N35129437: length 1.6
  TOP w0.127: PR119.2 15.84,65.26 16.11,64.98 PQ109.3 PQ109.2
N35130312: length 1.9
  TOP w0.127: PQ103.2 14.85,62.51 PR113.1 PR101.2
N35131434: length 8.9
  TOP w0.127: v2(12.61,49.43) 12.69,49.51 PQ117.1 12.34,50.88 11.91,50.45 PC123.2 v2(10.64,50.45)
  IN1 w0.061: v2(12.16,52.51) 12.15,52.51 10.64,51 v2(10.64,50.45) ; v2(12.61,49.43) 12.22,49.04 v4(12.2,49.04)
  IN3 w0.061: v5(12.55,49.04) v4(12.2,49.04)
  BOTTOM w0.127: v5(12.55,49.04) 13.16,49.04 13.5,49.38 PQ115.4
N35132002: length 18.3
  TOP w0.127: v2(10.51,45.61) 10.51,46.16 PR150.1 8.73,46.43 v1(8.5,46.19) 7.85,45.54 7.85,42.61 8.83,41.62 9.82,41.62 10.38,41.06 11.8,41.06 13.1,39.77 13.82,39.77 14.29,40.24 PC124.2 14.29,41.09 PR148.2 14.71,41.5 PQ118.1
  IN1 w0.061: v2(10.51,45.61) 10.66,45.47 v4(10.97,45.47)
  IN3 w0.076: v5(10.54,45.32) v4(10.97,45.47)
N35132051: length 2.6
  TOP w0.127: PQ118.2 12.95,43.41 PR151.1 PR144.2 11.4,42.82 v1(11.23,43)
N35132981: length 1.5
  TOP w0.127: PQ120.1 12.04,45.55 PR150.2
N35133273: length 2
  TOP w0.127: PQ123.2 8.54,44.83 PR155.2 8.42,44.63 8.87,44.18 PQ123.3
N35133295: length 2
  TOP w0.127: PQ123.6 11.39,45.48 12.05,44.82 PR151.2
N36145369: length 2.2
  TOP w0.127: PQ102.2 14.29,64.85 15.28,65.84 PR100.2 15.85,65.84 PR110.1
N36146502: length 3.2
  TOP w0.127: v1(18.4,70.78) 18.4,70.06 PR116.2 17.77,69.02 17.94,68.84 PQ105.3 PQ105.2
N36147287: length 2.5
  TOP w0.127: PQ105.5 16.59,67.37 16.59,66.87 16.46,66.74 PR123.1 16.94,66.38 PR120.2
N36148115: length 1.9
  TOP w0.127: PQ117.2 14.58,50.23 15.13,50.79 PR149.1 PR146.2
N36148155: length 1.9
  TOP w0.127: PQ119.2 12.39,48.01 PR153.2 12.21,47.36 PQ119.3
N36148188: length 1.7
  TOP w0.127: PR161.1 15.59,48.91 PR157.2 15.31,48.3 15.01,48.01 PQ119.5
N36161939: length 1.9
  TOP w0.127: PR152.2 13.08,53.7 PQ122.1
N40373298: length 0.7
  BOTTOM w0.127: RD17.1 68.9,29.76 68.9,30.06 CD67.2
N40373501: length 0.9
  BOTTOM w0.127: RD3.1 CD20.2
N40376778: length 2.4
  TOP w0.127: RD9.1 56.98,28.47 56.27,27.76 v1(56.27,27.07)
  TOP w0.381: RD9.1 57.05,28.52 CD46.2
N40928090: length 5.9
  TOP w0.127: v1(11.57,67.04) 11.62,67.04 PR115.2 12.98,68.4 13.69,68.4 13.98,68.69 PQ108.1
N43237751: length 1.7
  TOP w0.127: PR125.1 15.14,68.45 14.77,68.81 PQ111.1
N43238317: length 1.2
  TOP w0.127: PQ111.2 12.87,70.7 PR131.2
N43294004: length 1
  TOP w0.127: PQ126.1 10.56,49.61 PR165.1
N43294007: length 1.2
  TOP w0.127: PR170.2 8.94,48.08 9.58,47.45 PQ126.2
N46621397: length 2.3
  TOP w0.127: PR933.2 PC906.1 44.87,65.5 v1(44.3,64.93)
N46621964: length 1.9
  TOP w0.127: PR940.2 PC908.1 47.22,66.16 v1(47.51,66.45)
N46635193: length 0.9
  TOP w0.127: PR945.2 PC914.1
N49105313: length 1.9
  TOP w0.127: PR128.2 17.06,71.06 PR126.2 17.32,71.84 PQ110.3
N49107876: length 1.9
  TOP w0.127: PQ124.3 15.01,57.57 PR166.2 15.44,57.17 15.34,57.07 PR169.2
N49135368: length 3.6
  TOP w0.127: PR117.2 37.7,66.73 PQ104.5 37.7,67.61 37.72,67.62 PR111.1
N49135372: length 2.4
  TOP w0.127: PR106.1 36.08,67.82 PR102.2 36.22,67.96 PR111.2 36.8,67.68 37.05,67.43 PQ104.6
N49135382: length 3.2
  TOP w0.127: PQ114.2 PQ114.3 36.45,58.82 PR139.2 37.62,58.06 v1(37.29,57.73)
N49135384: length 2.9
  TOP w0.127: PR137.2 34.01,61.12 PR143.2 34.28,60.85 PQ114.6 35.03,62.01 PQ106.4
N49135442: length 1
  TOP w0.127: PR114.1 38.12,64.56 38.35,64.79 PQ104.3
N49135489: length 5
  TOP w0.127: PQ114.5 35.68,60.52 35.31,60.15 PR143.1 34.06,59.37 PR141.2 34.36,59.35 34.59,59.12 34.59,58.43 v1(35.18,57.84)
N49135666: length 1.6
  TOP w0.127: PQ113.2 PQ113.3 38.8,67.86 38.77,67.89 PR138.2
N49135672: length 1.7
  TOP w0.127: PR142.1 PR140.2 40.19,65.48 40.13,65.54 PQ113.5
N49135678: length 3.9
  TOP w0.127: PR142.2 40.96,64.15 PQ112.1 ; PR142.2 41.85,65.07 41.55,65.37 41.52,65.37 41.22,65.67 40.93,65.67 40.78,65.82 PQ113.6 ; PR142.2 PR136.2
N49135704: length 4
  TOP w0.127: PR129.1 38.23,60.92 38.65,61.34 38.65,61.87 38.83,62.05 38.83,62.49 39.08,62.75 40.3,62.75 40.55,62.5 PQ112.6
N49135720: length 1.8
  TOP w0.127: PR134.2 41.16,63.72 41.09,63.65 40.41,63.65 PQ112.2
N49135818: length 1.4
  TOP w0.127: PQ106.3 35.03,64.2 34.84,64.39 34.1,64.39 PR130.1
N49135824: length 1.1
  TOP w0.127: PQ104.2 37.7,64.79 37.64,64.73 37.64,64.58 PR109.2
N49135828: length 1.4
  TOP w0.127: PQ106.2 35.68,64.28 35.1,64.86 PR117.1
N49135838: length 2
  TOP w0.127: PR135.2 35.31,62.57 35.68,62.2 PQ106.5
N52199990: length 2.6
  TOP w0.127: v1(35.34,37.84) PC412.1
  TOP w0.508: PC412.1 35.9,39.27 PR402.2
N52199996:
  vias: v1(295.68,65.07)
N52200555: length 1.5
  TOP w0.127: PR409.2 299.24,64.09 v1(299.48,63.85)
N52348207: length 2.8
  TOP w0.127: PR401.2 38.84,43.38 v1(38.38,43.84)
  TOP w0.508: PC400.2 38.84,41.55 PR401.2
N52995153: length 7.8
  BOTTOM w0.254: PU700.3 124.5,37.22 123.99,36.71 PR702.2 123.41,37.18 123.41,38.28 123.94,38.8 127.18,38.8 PQ700.1
N52995185: length 1.3
  BOTTOM w0.203: PU700.2 125,36.97 124.99,36.96 124.99,36.84 PR703.2
N52995203: length 4.3
  BOTTOM w0.127: PR704.2 PR706.1 128.71,40.09 128.28,39.66 127.58,39.66 PQ700.2
N53169467: length 2.3
  BOTTOM w0.203: PC700.2 124.34,42.02 PR701.2 125.14,41.69 125,41.56 PU700.7
N53310942: length 1.9
  TOP w0.127: v1(309.09,9.76) 309.34,9.51 RB21.2
  TOP w0.254: RB40.2 309.35,8.72 RB21.2
N53311038: length 9.4
  TOP w0.127: v1(314.22,8.26) QB5.2 312.6,5.24 312.3,4.95 CB18.1 RB25.1 312.3,3.63 313.12,2.82 DB5.1 312.61,2.18 RB24.1 RB23.1
N53311178: length 3.6
  TOP w0.127: RB22.2 308.52,2.86 308.27,3.11 QB6.6 307.54,3.4 v1(307.05,2.9)
N56822254: length 1
  IN1 w0.076: v4(25.16,65.85) 25.11,65.85 v2(24.83,65.96)
  IN3 w0.076: v4(25.16,65.85) 25.22,65.91 v5(25.22,66.42)
N56822270: length 0.8
  IN1 w0.061: v4(28.06,66.92) 28.03,66.89 27.58,66.87 v2(27.58,66.87)
  IN3 w0.061: v5(27.73,66.92) v4(28.06,66.92)
N56822627: length 1.7
  TOP w0.127: TC1.1 26.5,66.53 v2(26.5,66.96)
  IN1 w0.061: v2(26.5,66.96) 27.01,66.96 v4(27.06,66.92)
  IN3 w0.061: v5(26.73,66.92) v4(27.06,66.92)
N56822629: length 0.7
  IN1 w0.061: v4(26.39,67.51) 26.37,67.54 v2(26.04,67.54)
  IN3 w0.061: v4(26.39,67.51) 26.49,67.42 v5(26.73,67.42)
N56856077: length 2.1
  TOP w0.127: RT55.1 27.8,67.39 v2(27.89,67.47) 28.17,67.19 v1(28.36,67.19)
  IN1 w0.061: v4(28.51,67.25) 28.29,67.47 v2(27.89,67.47)
  IN3 w0.061: v5(28.22,67.42) 28.37,67.42 28.51,67.28 v4(28.51,67.25)
  BOTTOM w0.127: UT1.F1 v5(28.22,67.42)
N56913159: length 3.3
  TOP w0.127: RN26.2 RN28.2 204.46,47.58 v6(204.21,47.82) v1(203.55,47.82)
  BOTTOM w0.127: JNGFF2.69 204.42,47.61 v6(204.21,47.82)
N56955777: length 3.7
  TOP w0.127: v1(224.23,13.86) 224.83,13.26 226.03,13.26 CK12.1
  TOP w0.254: RK10.1 CK12.1
N56956040: length 2.4
  TOP w0.254: UK1.21 229.53,13.84 229.14,13.45 v1(228.94,13.45) 228.45,13.45 RK10.2
N57579497: length 5.5
  TOP w0.127: v1(268.05,32.21) 268.58,31.68 v2(268.58,31.67) 268.77,31.48 RN114.1
  IN1 w0.061: v4(268.84,32.18) 268.58,31.91 v2(268.58,31.67)
  IN3 w0.061: v5(269.13,32.56) 268.84,32.28 v4(268.84,32.18)
  BOTTOM w0.127: JNGFF1.38 266.9,32.34 267.15,32.58 269.1,32.58 v5(269.13,32.56)
N57661434: length 5.6
  TOP w0.254: RA7.2 RA2.2 292.39,27.31 RA4.1 292.42,26.85 CA4.1 292.45,26.27 CA6.1 CA1.1 292.66,25.1 292.91,24.85 v1(293.28,24.85) 293.65,24.85 294.3,25.49 RA8.1
N57663406: length 3.3
  TOP w0.203: UA1.32 286.55,24.62 288.26,24.62 v1(288.66,24.22) 289.11,23.77 CA7.1
N57663450: length 4.3
  TOP w0.203: CA13.1 287.6,27.36 v1(286.87,28.1) 285.89,28.1 285.3,27.51 UA1.38
N57663469: length 6.8
  TOP w0.203: UA1.39 284.9,27.85 v1(285.18,28.12) 285.38,28.12 285.71,28.45 287.2,28.45 287.54,28.11
  TOP w0.508: RA12.2 289.58,27.17 CA15.2 289.27,27.77 288.93,28.11 287.54,28.11
N58709056: length 3.4
  TOP w0.127: QE10.1 254.38,53.92 v1(254.65,54.18) 254.77,54.31 RE172.2 255.69,54.35 RE477.2
N58709139: length 0.7
  TOP w0.127: RE180.2 256.77,58.74 CE30.1
N58727680: length 3.5
  TOP w0.127: RE98.1 RE99.1 225.13,69.85 v6(225.63,70.34)
  BOTTOM w0.127: v6(225.63,70.34) JESPI1.8
N59164860: length 4
  TOP w0.127: v1(105.33,67.73) 105.33,65.94 105.53,65.75 RE198.1 RE199.2 105.49,65.13 105.25,64.88 QE4.3
N60395557: length 2.9
  TOP w0.127: RE213.2 QE11.1 253.37,51.78 v1(254.35,52.76)
N61623149: length 1.4
  TOP w0.102: U6.12 200.1,32.49 C50.1
N61623319: length 1.4
  TOP w0.102: U6.10 200.02,31.69 C51.1
N61986536: length 6.3
  TOP w0.127: v2(197.04,72.47) 197.14,72.37 UN3.3 ; v2(194.16,69.42) 194.16,70.1 v1(193.76,70.49)
  IN1 w0.061: v2(194.16,69.42) 194.16,70.5 195.92,72.27 196.84,72.27 v2(197.04,72.47)
N61986579: length 3
  TOP w0.127: UN3.6 198.13,71.89 198.96,71.06 200.21,71.06 200.38,70.9 LN10.2
N61986581: length 2.1
  TOP w0.127: LN9.2 199,70.62 197.73,71.89 UN3.5
N62005758: length 3.9
  BOTTOM w0.127: v1(197.64,69.77) 198.63,69.77 199.27,69.12 RS5.2 RS10.1 199.35,68.27 U16.B2
N63010433: length 3.4
  TOP w0.127: v1(229.41,49.64) R209.2 229.7,48.11 R210.1 230.1,47.49 230.03,47.43 U17.4
N63010478: length 2.5
  TOP w0.127: U17.3 230.03,42.97 R208.2 230.01,42.33 v1(230.45,41.89)
N63223478: length 0.8
  TOP w0.127: CZ28.1 45.63,38.16 RZ32.1
N63306822: length 2.9
  TOP w0.127: v1(221.42,51.83) 221.42,51.59 222.24,50.78 C60.1
  TOP w0.254: U19.6 222.51,50.75 C60.1
N63708406: length 2.3
  BOTTOM w0.127: CS1.2 290.99,30 v1(291.45,29.55) 292.01,29.55 RS2.1
N63957445: length 12.6
  TOP w0.127: v1(292.1,17.96) 292.1,18.09 292.61,18.6 v2(292.96,18.6)
  TOP w0.203: v6(287.36,25.1) 287.27,25.02 UA1.33
  TOP w0.381: v2(292.96,18.6) RA10.1
  IN1 w0.254: v2(292.96,18.6) v4(292.96,18.97)
  IN3 w0.254: v4(292.96,18.97) v5(292.96,19.34)
  BOTTOM w0.254: v5(292.96,19.34) 292.66,19.64 292.66,21.81 290.68,23.79 288.66,23.79 v6(287.36,25.1)
N64482855: length 1.7
  TOP w0.127: T1.1 81.02,51.39 v2(80.89,51.39)
  IN1 w0.061: v4(81.14,51.15) 81.04,51.25 v2(80.89,51.39)
  IN3 w0.076: v5(80.91,51.38) v4(81.14,51.15)
N64482857: length 1.5
  TOP w0.127: v2(80.86,51.77) 80.48,52.15 T2.1
  IN1 w0.061: v4(81.2,51.74) 81.17,51.77 v2(80.86,51.77)
  IN3 w0.076: v5(80.91,52.03) v4(81.2,51.74)
N64522458: length 2.8
  BOTTOM w0.076: UCPU1.W37 75.44,31.91
  BOTTOM w0.127: 75.44,31.91 75.44,31.05 T3.1
N64522460: length 4.1
  TOP w0.127: T4.1 75.54,36.42 v2(75.53,36.4)
  IN1 w0.076: v2(75.53,36.4) 75.53,36.39 v4(75.29,36.16)
  IN3 w0.076: v5(75.53,36.39) v4(75.29,36.16)
N64536849: length 3.4
  TOP w0.127: v2(76.21,37.5) 76.94,38.22 T5.1
  IN1 w0.076: v4(76.67,37.46) 76.26,37.46 v2(76.21,37.5)
  IN3 w0.076: v5(76.44,37.69) v4(76.67,37.46)
N64536851: length 5.8
  BOTTOM w0.076: 79.64,31.91 79.64,32.34 79.52,32.46 79.52,33.25 79.7,33.42 79.94,33.42 80.13,33.61 80.13,33.88 79.93,34.08 79.62,34.08 79.17,34.53 UCPU1.AE34
  BOTTOM w0.127: 79.64,31.91 79.64,31.69 78.84,30.89 T6.1
N64536853: length 9.4
  TOP w0.127: T7.1 99.43,28.75 v2(99.59,28.91)
  IN1 w0.061: v2(99.59,28.91) 100.41,29.72 100.41,33.51 99.41,34.5 99.41,35.09 98.98,35.52 98.98,35.84 99.3,36.16 v4(99.46,36.16)
  IN3 w0.076: v5(99.22,36.39) v4(99.46,36.16)
N64602818: length 4.4
  BOTTOM w0.127: v1(113.18,46.2) 113.96,46.2 114.88,47.12 QC3.2 114.88,47.92 113.79,49.02 RC539.1
N64745820: length 4.2
  TOP w0.127: v1(82.14,37.98) 82.27,38.11 82.27,39.16 81.97,39.46 v2(81.44,39.46) 80.97,39.93 80.97,40.04 80.59,40.42 RC435.2
  IN1 w0.061: v4(81.43,39.11) v2(81.44,39.46)
  IN3 w0.061: v5(81.45,39.46) v4(81.43,39.11)
N64745822: length 3
  TOP w0.127: v2(81.89,39) 81.83,38.94 v1(81.04,38.94) 80.86,38.94 80.53,39.27 RC434.2
  IN1 w0.061: v4(81.89,39.45) 81.89,39.45 v2(81.89,39)
  IN3 w0.076: v5(81.91,38.99) 81.91,39.43 v4(81.89,39.45)
N64745824: length 1.7
  TOP w0.127: v1(78.88,40.72) 79.26,40.34 RC436.2 RC434.1
N64746013: length 6.4
  BOTTOM w0.076: UCPU1.F37 68.39,32.75 68.76,32.38 69.14,32.38 69.6,31.91 69.8,31.91
  BOTTOM w0.127: 69.8,31.91 71.47,30.24 T16.1
N64746015: length 8.7
  BOTTOM w0.076: UCPU1.F34 68.05,33.85 68.4,33.5 68.58,33.5 69,33.08 69.23,33.08 70.39,31.91
  BOTTOM w0.127: 70.39,31.91 71.71,30.6 74.42,30.6 T17.1
N64746017: length 7
  BOTTOM w0.102: 112.37,35.67 110.25,33.55 109.38,33.55 109.21,33.38 UCPU1.CP36
  BOTTOM w0.127: 112.37,35.67 114.58,35.67 T18.1
N64746019: length 7.6
  BOTTOM w0.102: 110,34.18 109.51,34.18 109.36,34.03 109.36,33.88 109.18,33.7 108.9,33.7 108.58,33.38 UCPU1.CN36
  BOTTOM w0.127: 110,34.18 112.07,36.25 112.93,36.25 113.28,36.6 113.71,36.6 T19.1
N64746021: length 4.8
  BOTTOM w0.127: UCPU1.BK34 94.61,34.05 94.61,32.29 93.32,31 T20.1
N64746023: length 2.2
  TOP w0.127: v2(97.83,44.99) 98.65,45.81 T21.1
  IN1 w0.061: v2(97.83,44.99) 97.85,44.99 v4(98.1,45.25)
  IN3 w0.076: v4(98.1,45.25) 98.1,45.25 v5(97.81,44.96)
N64746045: length 5.1
  BOTTOM w0.076: UCPU1.A34 64.68,34.51
  BOTTOM w0.127: 64.68,34.51 64.56,34.51 64.11,34.05 64.11,33.04 63.09,32.02 T27.1
N64746047: length 7.3
  BOTTOM w0.076: 64.68,33.99 64.87,34.18 65.53,34.18 UCPU1.B35
  BOTTOM w0.127: 64.68,33.99 64.49,33.8 64.49,33.04 62.84,31.39 60.93,31.39 T28.1
N64746049: length 6.5
  BOTTOM w0.127: RC420.1 62.67,33.17 65.03,35.52 65.53,35.52 65.57,35.56 66.26,35.56 66.44,35.38 UCPU1.C34
N64746051: length 7.2
  IN1 w0.061: v2(98.22,28.82) 98.3,28.82 98.99,29.52 98.99,29.84 98.83,30 98.83,32.58 97.67,33.74 97.67,34 v4(97.46,34.21)
  IN3 w0.061: v4(97.46,34.21) 97.73,34.48 v5(97.73,34.57)
  BOTTOM w0.127: UCPU1.BP34 97.71,34.5 v5(97.73,34.57)
N64746053: length 4.1
  IN1 w0.061: v2(98.11,30.1) 98.31,30.31 98.31,32.61 v4(97.58,33.34)
  IN3 w0.061: v5(97.44,33.72) 97.58,33.59 v4(97.58,33.34)
N64747389: length 2.4
  TOP w0.127: v1(22.71,7.56) 23.05,7.22 RC119.2 22.94,6.38 SW3.1
N64796589: length 2.3
  TOP w0.127: v1(124.97,32.43) 124.81,32.28 C73.1 124.35,31.05 U12.10
N64796626: length 2
  TOP w0.127: v1(122.75,31.51) C71.1 123.61,31.18 123.55,31.12 U12.12
N65319885:
  vias: v1(290.38,60.55)
N65324745: length 4.6
  TOP w0.127: v1(16.46,11.26) 16.72,11.26 17.6,12.13 UI5.8 16.98,12.48 16.69,12.76 16.52,12.76 RI144.2 16.49,13.05 17.02,13.05 17.09,12.98 UI5.7
N65324759: length 1.3
  TOP w0.127: RI67.1 21.61,13.73 21.37,13.98 UI5.16
N65514253: length 2.3
  TOP w0.127: v1(287.84,65.03) 287.54,64.73 RI55.1 287.01,64.7 UI4.16
N65905221: length 3.7
  TOP w0.127: QN4.4 269.22,33.71 270.22,34.71 QN4.1 270.22,35.32 270.51,35.6 v1(271.47,35.6)
N67238504: length 8.4
  BOTTOM w0.127: T138.1 115.77,36.28 114.91,35.41 112.46,35.41 110.25,33.21 UCPU1.CR36
N67241110: length 7.6
  BOTTOM w0.127: T139.1 115.22,38.66 113.51,36.96 113.27,36.96 112.82,36.51 111.9,36.51 109.9,34.51 UCPU1.CR34
N67242383: length 5.3
  BOTTOM w0.127: T140.1 112.72,58.46 109.64,55.38 UCPU1.CP1
N67243636: length 6.7
  BOTTOM w0.127: UCPU1.CN1 108.92,55.72 109.55,55.72 113.28,59.45 T141.1
N67244875: length 7.3
  BOTTOM w0.076: UCPU1.A36 64.68,32.83
  BOTTOM w0.127: 64.68,32.83 62.99,31.13 59.92,31.13 T142.1
N67247327: length 6.4
  BOTTOM w0.127: T143.1 62.63,33.57 64.89,35.83 UCPU1.A32
N67247377: length 8.6
  BOTTOM w0.127: UCPU1.D1 66.63,55.51 66.31,55.83 63.92,55.83 63.19,55.1 59.82,55.1 T144.1
N67250001: length 5.5
  BOTTOM w0.127: T145.1 61.59,54.83 63.37,54.83 63.92,55.38 UCPU1.C1
N67278610: length 6.8
  TOP w0.127: QN5.4 210.66,28.33 210.4,28.59 v1(209.82,28.59) 208.99,28.59 208.65,28.25 208.65,25.93 208.94,25.63 QN5.1
N67571971: length 1.7
  TOP w0.127: RT129.1 23.46,75.33 v2(23.54,75.25)
  IN1 w0.061: v4(23.22,75.37) 23.32,75.37 23.44,75.25 v2(23.54,75.25)
  IN3 w0.061: v5(22.89,75.04) 23.22,75.36 v4(23.22,75.37)
  BOTTOM w0.127: UT5.E11 23,74.93 v5(22.89,75.04)
N67571980: length 0.8
  IN1 w0.061: v2(24.91,73.19) 25.03,73.07 v4(25.25,73.07)
  IN3 w0.061: v5(25.22,73.43) 25.23,73.43 25.23,73.09 v4(25.25,73.07)
N67571982: length 1.2
  IN1 w0.061: v2(27.52,74) 27.24,73.72 v4(27.13,73.72)
  IN3 w0.061: v5(27.47,73.75) 27.16,73.75 v4(27.13,73.72)
  BOTTOM w0.127: v5(27.47,73.75) 27.66,73.93 UT5.G2
N67572033: length 1.3
  TOP w0.127: v2(26.11,73.79) 26.26,73.63 TC6.1
  IN1 w0.061: v2(26.11,73.79) v4(26.35,74.03)
  IN3 w0.061: v4(26.35,74.03) 26.44,73.93 v5(26.73,73.93)
N67572034: length 1.7
  TOP w0.127: v2(26.48,74.67) 26.38,74.77 TC7.1
  IN1 w0.061: v4(26.14,74.56) 26.16,74.57 26.39,74.57 v2(26.48,74.67)
  IN3 w0.061: v4(26.14,74.56) 26.27,74.43 v5(26.73,74.43)
N67572050: length 2
  TOP w0.127: RT61.1 27.98,74.57 v2(28.35,74.21)
  IN1 w0.061: v4(28.76,74.36) 28.61,74.21 v2(28.35,74.21)
  IN3 w0.061: v4(28.76,74.36) 28.69,74.43 v5(28.23,74.43)
N67601552: length 2.5
  TOP w0.127: RV80.2 35.03,68.36 35.21,68.18 QV11.3 35.47,67.69 35.57,67.58 35.57,67.18 35.43,67.04 QV11.2
N67681387: length 0.8
  TOP w0.127: RB35.1 309.92,1.8 QB6.3
N67847342: length 1.8
  TOP w0.127: RT289.2 RT294.2 31.55,56.17 UT15.1
N67847355: length 1.4
  TOP w0.127: RT290.2 30.11,55.81 30.25,55.67 UT15.3
N67960376: length 3.1
  BOTTOM w0.127: R282.2 R281.2 87.35,63.16 87.2,63.32 86.59,63.32 86.41,63.49 86.41,64.03 86.25,64.19 U5.2
N67960444: length 26.2
  TOP w0.127: v1(108.24,68.66) 107.18,68.66 v6(107.03,68.52) 107.03,67.79 R273.2
  IN3 w0.061: v5(85.79,64.84) 85.79,63.91 85.98,63.72 88.76,63.72 91.36,66.32 99.97,66.32 101.96,68.3 106.82,68.3 v6(107.03,68.52)
N68666777: length 2.1
  TOP w0.127: v1(16.57,20.91) RM107.2 16.47,22.09 QM3.2
N68671545: length 13.5
  TOP w0.127: DV2.1 44.37,67.2 v1(44.37,67.82) 43.92,68.27 41.66,68.27 40.92,69 39.17,69 38.59,69.58 38.59,70.2 37.63,71.16 37.63,72.18 36.66,73.15 36.15,73.15 35.76,73.54 RV83.1
N68671579: length 4.2
  TOP w0.254: RV84.1 35.1,74.5 35.1,73.39 36.02,72.47 v1(36.38,72.47) 36.74,72.47 37.1,72.12 DV3.1
N68771268: length 1.4
  TOP w0.127: RV54.2 247.18,41.19 246.86,40.87 UV5.2
N68776898: length 5.1
  BOTTOM w0.254: v1(288.85,68.57) 289.42,69.15 QN11.2 289.42,69.98 289.03,70.38 287.12,70.38 286.63,69.88 U33.4
N68781752: length 2.7
  TOP w0.127: U8.6 224.81,61.43 C59.1 v1(226.21,61.51)
N68785059: length 2.4
  BOTTOM w0.127: U15.6 185.01,16.92 185.33,17.24 C27.1 184.56,17.51 v1(184.39,17.34)
N68785597: length 2.2
  TOP w0.127: UC17.6 48.05,74.77 C30.1 v1(49,74.81)
N68787020: length 5
  TOP w0.127: QN2.3 255.21,46.76 255.21,46.01 254.93,45.73 RN106.2 254.86,45.42 254.93,45.36 RN71.1 254.93,44.69 v1(254.39,44.15) DN7.2
N68787104: length 2.3
  TOP w0.127: U4.12 255.52,38.2 255.19,37.88 v1(255.19,37.56) 255.19,37 C37.1
N68787277: length 4.2
  TOP w0.127: U4.10 254.72,37.83 254.86,37.69 C38.1 254.72,36.7 254.52,36.49 254.52,35.52 254.77,35.26 v1(255.15,35.26)
N68787388: length 5.4
  TOP w0.127: RN111.2 RN109.1 251.05,46.49 251.31,46.74 QN6.1 251.31,49.32 v1(250.24,50.39)
N68788728: length 2.3
  TOP w0.127: UA8.12 266.63,37.98 v1(266.25,37.61) 266.25,37.13 266.55,36.84 CA144.1
N68788738: length 2.1
  TOP w0.127: CA145.1 265.83,36.84 UA8.10
N68793308: length 6.7
  IN1 w0.061: v4(303.96,60.86) v2(304.46,60.86)
  IN3 w0.061: v5(301.72,61) 301.85,60.86 v4(303.96,60.86)
  BOTTOM w0.127: QV12.2 300.79,60.99 300.54,60.74 300.54,59.24 300.79,58.98 C93.1 R258.2
N69252412: length 3
  BOTTOM w0.127: CV50.1 56.64,61.49 56.82,61.31 UV6.5
N69266710: length 2.9
  BOTTOM w0.127: CV51.1 54.38,57.92 v1(55.32,57.92) 55.87,57.92 56.42,58.47 UV6.11
N69266720: length 2.9
  BOTTOM w0.127: v1(58.48,60.71) 58.48,61.25 58.01,61.72 RV89.1 57.72,61.83 57.22,61.32 UV6.6
N69961719: length 5.5
  TOP w0.127: v1(35.56,54.4) 34.94,55.02 UT14.1 34.28,54.65 34.04,54.41 32.76,54.41 32.57,54.6 32.57,55.79 RT285.2
N69961744: length 2.7
  TOP w0.127: v1(35.39,56.01) 34.57,56.01 34.38,56.2 RT284.2 34.16,56.04 33.63,55.51 UT14.2
N70275813: length 2.4
  TOP w0.127: v1(283.68,15.93) 283.44,15.69 CA155.1 283,14.64 UA7.6
N70634990: length 1.4
  TOP w0.127: UV1.5 43.27,70.77 43.41,70.63 RV90.1
N70635655: length 5.6
  TOP w0.127: RV91.1 38.1,71.13 38.92,70.3 41.03,70.3 41.51,69.82 UV1.4
N70788772: length 1.7
  TOP w0.127: RV92.1 44.12,68.7 44.43,68.39 DV1.1
N70846965: length 6.7
  TOP w0.127: RR20.1 285.85,38.22 286.85,39.22 287.51,39.22 288.49,40.2 UR2.4 288.8,40.86 289.06,40.6 289.06,39.96 v1(289.69,39.34)
N70846994: length 5.1
  TOP w0.127: UR2.5 287.54,41.51 287.77,41.74 289.28,41.74 RR19.1 289.66,41.4 290.78,42.51 v1(290.78,43.03)
N71314969: length 2.4
  BOTTOM w0.127: RZ1412.1 148.51,17.96 v1(147.71,17.96) QZ20.1
N71426147: length 1.8
  TOP w0.127: QV6.2 63.78,64.53 RV46.1
N71426226: length 1.6
  TOP w0.127: RV39.1 53.42,64.48 QV4.2
N71426333: length 3.1
  TOP w0.127: v1(56.6,60.23) RV41.2
  TOP w0.381: QV4.1 56.6,62.41 RV41.2
N71426344: length 3.6
  TOP w0.127: QV6.1 66.36,62.29 v1(67.21,61.44)
  TOP w0.508: QV6.1 66.36,63.77 RV47.2
N71525133: length 5.1
  TOP w0.127: v1(109.28,64.84) 108.6,65.51 107.46,65.51 QE5.2 106.37,65.32 106.37,66.07 106.11,66.33 RE198.2
N71576104: length 2.9
  TOP w0.127: CN60.2 RN117.1 198.14,74.45 198.3,74.3 199.49,74.3 v1(200.02,74.83)
N71576192: length 1.9
  TOP w0.127: UN3.10 197.73,73.39 197.95,73.62 RN117.2 v1(199.06,73.87)
N71690509: length 1.6
  BOTTOM w0.254: RT302.2 CT205.1 17.06,74.1 QT3.2
N71690515: length 5.5
  BOTTOM w0.254: 17.06,69.98 17.06,68.88 QT4.2 ; 17.06,69.98 16.94,69.98 16.46,70.47 RT300.1 ; 17.06,69.98 17.55,69.98 17.73,70.16 RT303.1 17.73,70.72 17.06,71.39 QT3.5
N71690517: length 1.4
  BOTTOM w0.254: QT3.6 16.41,71.41 17.14,70.67 RT303.2
N71690519: length 8.1
  IN3 w0.254: v5(16.8,72.66) 16.8,73.55 17.54,74.29 v5(17.54,74.94)
  BOTTOM w0.254: v5(16.8,72.66) 15.91,72.66 15.26,73.31 QT2.2 14.13,72.51 14.13,71.28 CT204.1 RT298.1
N71690560: length 0.9
  BOTTOM w0.254: QT3.3 17.71,74.18 RT299.2
N71690933: length 7.7
  BOTTOM w0.254: QT1.1 10.16,72.46 RT297.1 10.16,70.67 10.07,70.58 CT206.1 10.28,69.86 UT16.4 11.78,69.86 12.57,69.07 13.46,69.07 14.18,69.79 RT296.2
N71697328: length 5
  TOP w0.127: v1(226.8,36.14) QN10.2 223.9,36.14 222.87,35.11 RN118.2
N72527102: length 4.8
  BOTTOM w0.127: UCPU1.CR35 110.04,33.86 112.15,35.97 113.32,35.97 T151.1
N122282431: length 1.7
  TOP w0.127: RR11.1 293.03,38.12 293.29,37.86 UR1.28

## Copper pours and planes (outline as drawn)
3V_LX on BOTTOM (solid shape): 198.92,56.21 198.92,54.68 200.91,52.69 200.91,48.89 199.25,47.24 199.25,46.61 199.11,46.47 198.59,46.47 198.47,46.35 198.47,45.5 198.53,45.44 198.53,43.18 198.44,43.09 198.31,43.09 198.21,43.19 198.21,44.48 197.4,45.29 197.4,46.75 197.14,47.01 197.14,56.2 197.29,56.34 198.79,56.34
3V_VIN on BOTTOM (solid shape): 199.15,46.29 199.15,40.74 199.24,40.66 200.38,40.66 201.14,39.9 201.14,37.74 201.59,37.29 203.55,37.29 203.62,37.23 203.62,36.28 203.36,36.02 198.09,36.02 198.03,36.09 198.03,41.74 198.73,42.44 198.73,45.42 198.59,45.56 198.59,46.27 198.62,46.31 199.13,46.31
5VALW_LX on TOP (solid shape): 39.54,40.62 39.54,38.94 39.41,38.81 37.62,38.81 37.54,38.89 37.54,40.63 37.65,40.74 39.42,40.74
5VALW_LX on BOTTOM (solid shape): 41.92,40.47 41.92,40.27 41.83,40.19 41.35,40.19 39.4,38.23 35.55,38.23 35.44,38.34 35.44,40.45 35.53,40.54 41.85,40.54
5VALW_VIN on BOTTOM (solid shape): 48.11,42.04 48.11,40.3 47.98,40.18 44.81,40.18 44.47,40.52 43.31,40.52 43.13,40.7 41.57,40.7 41.5,40.77 41.5,40.92 41.6,41.02 43.09,41.02 43.56,41.5 43.56,42.07 43.59,42.1 48.05,42.1
5VALWB_LX on TOP (solid shape): 299.82,66.58 299.82,65.09 299.4,64.66 298.55,64.66 298.42,64.79 298.42,65.42 298.17,65.68 298.17,65.69 297.91,65.69 297.75,65.85 297.75,67.26 297.83,67.34 299.06,67.34
5VALWB_LX on BOTTOM (solid shape): 299.48,66.69 299.73,66.53 300,66.39 300,62.45 299.24,61.69 297.74,61.69 297.13,61.08 297.13,59.43 297.03,59.33 296.95,59.33 296.85,59.43 296.85,65.8 297.74,66.69
5VALWB_VIN on BOTTOM: 297.56,59.76 297.43,59.76 297.36,59.68 297.36,58.18 296.77,57.6 296.77,52.9 296.9,52.77 298.53,52.77 298.7,52.95 298.7,57.4 297.64,58.46 297.64,59.68
+0.6VS on BOTTOM (solid shape): 55.47,27.31 55.47,26 55.34,25.87 53.22,25.87 53.17,25.91 53.17,26.64 53.17,26.64 52.62,26.64 52.61,26.64 52.61,26.82 53.17,26.82 53.17,27.24 53.17,27.41 53.24,27.47 53.24,27.47 53.33,27.56 55.21,27.56
+0.6VS on IN3: 88.41,15.22 90.71,15.22 90.87,15.07 90.87,14.6 90.72,14.45 88.45,14.45 88.29,14.62 88.29,15.1
+0.6VSP on BOTTOM (solid shape): 53.03,27.25 53.03,26.97 52.46,26.97 52.46,26.97 52.46,26.49 52.46,26.48 53.02,26.48 53.02,26.23 53.02,26.22 53.02,25.79 52.72,25.49 52.72,24.59 52.56,24.43 51.2,24.43 51.01,24.24 50.32,24.24 50.27,24.29 50.27,24.9 50.31,24.94 51.49,24.94 51.78,25.24 51.78,26.28 51.95,26.45 51.95,27.3 52,27.35 52.93,27.35
+1.0V_AMPHYPLL on BOTTOM (solid shape): 100.07,60.24 100.07,60.03 100.21,59.89 102.62,59.89 102.71,59.81 102.71,58.82 102.4,58.52 102.4,58.11 102.37,58.08 101.95,58.08 101.88,58.15 101.88,58.62 101.8,58.69 100.16,58.69 100.01,58.54 100.01,57.28 99.94,57.21 99.57,57.21 99.5,57.27 99.5,57.71 99.52,57.79 99.5,57.87 99.5,58.02 99.3,58.22 99.3,60.28 99.35,60.33 99.98,60.33
+1.0V_CLK on BOTTOM: 109.8,52.65 109.96,52.48 109.97,52.49 110.85,52.49 111.01,52.65 113.36,52.65 113.41,52.69 113.41,53.71 113.45,53.75 113.45,56.76 112.6,56.76 111.25,55.42 111.25,53.6 111.04,53.38 110.16,53.38 109.93,53.16 109.37,53.16 109.3,53.08 109.3,52.86 109.31,52.86 109.31,52.73 109.39,52.65
+1.0V_PRIM_CORE on BOTTOM: 119.72,44.98 119.9,45.15 119.9,45.51 119.37,45.51 119.37,46.06 119.91,46.06 119.91,46.31 119.37,46.31 119.37,46.86 119.9,46.86 119.9,47.54 119.7,47.75 118.15,47.75 117.94,47.54 117.94,45.05 118.01,44.98
+1.0V_PRIM_CORE on IN1: 99.25,42.37 99.11,42.51 99.11,42.94 99.37,43.2 101.41,43.2 101.6,43.39 101.6,43.78 101.54,43.84 101.54,45.77 101.71,45.94 101.71,46.39 102.32,46.99 102.32,47.74 102.48,47.9 102.75,47.9 102.82,47.83 102.82,46.58 102.29,46.05 102.29,45.9 102.19,45.8 102.19,42.59 101.97,42.37
+1.0V_PRIM_CORE on VCC: 97.51,38.88 97.51,42.18 98.96,42.18 99.16,42.38 99.16,42.89 99.21,42.94 99.47,42.94 99.8,43.27 99.8,46.19 100.36,46.75 102.2,46.75 102.83,47.39 109.04,47.39 111.46,49.8 114.12,49.8 116.24,51.92 116.24,54.12 128.5,54.12 128.5,45.61 121.47,45.61 119.44,43.58 113.09,43.58 112.56,43.05 112.56,41.14 110.42,39.01 106.68,39.01 106.55,38.88
+1.0V_PRIM_CORE on IN3: 102.15,46.12 102.15,43.07 102.04,42.96 101.29,42.96 100.63,42.31 99.1,42.31 98.97,42.44 98.97,48.66 99.35,49.04 102.53,49.04 102.78,48.79 102.78,46.75
+1.0V_PRIM_COREP on BOTTOM (solid shape): 121.36,47.01 121.36,46.4 121.62,46.14 124.41,46.14 124.5,46.05 124.5,44.02 124.34,43.86 123.5,43.86 122.48,42.85 119.04,42.85 118.98,42.91 118.98,43.63 119.28,43.93 119.28,44.27 120.06,45.06 120.06,45.66 120.03,45.66 119.51,45.66 119.51,45.91 120.06,45.91 120.06,45.91 120.06,46.46 120.06,46.46 119.51,46.46 119.51,46.46 119.51,46.71 119.51,46.71 120.06,46.71 120.06,46.71 120.06,47.21 120.07,47.21 121.15,47.21
+1.0V_VCCPLL on TOP (solid shape): 97.93,49.96 98.65,49.96 98.75,49.85 98.75,48.3 98.71,48.25 98.21,48.25 98.16,48.2 98.16,47.89 98.11,47.85 97.19,47.85 96.91,48.13 96.11,48.13 96.01,48.23 96.01,49.32 96.05,49.36 96.69,49.36 97,49.67 97,50.13 97.03,50.15 97.73,50.15
+1.0V_VCCST on TOP (solid shape): 98.8,51.02 98.8,50.17 98.72,50.08 98.01,50.08 97.59,50.5 97.02,50.5 97,50.52 97,51.01 97.08,51.1 98.73,51.1
+1.0V_VCCST on IN1 (solid shape): 98.63,50.36 98.63,49.87 98.53,49.76 97.92,49.76 97.66,49.51 97.66,49.27 97.57,49.18 97.17,49.18 97.08,49.27 97.08,49.62 97.92,50.46 98.53,50.46
+1.0V_VCCST on TOP: 105.99,64.75 105.64,64.75 105.21,64.32 104.32,64.32 104.25,64.25 104.25,63.64 104.33,63.56 105.67,63.56 106.04,63.92 106.04,64.71
+1.0V_VCCST on BOTTOM: 95.73,59.7 95.04,59.7 94.75,59.41 94.13,59.41 94.07,59.47 94.07,60.48 94.18,60.59 94.42,60.59 95.27,61.44 96.02,61.44 96.23,61.23 96.23,60.68 97.17,59.74 97.17,59.15 97.25,59.07 97.45,59.07 97.76,58.76 97.76,58.18 97.87,58.07 98.03,58.07 98.08,58.02 98.12,58.02 98.25,57.88 98.25,57.41 97.97,57.13 97.03,57.13 96.56,57.6 96.56,58 96.16,58.39 96.16,59.26
+1.0V_VCCST_R on BOTTOM (solid shape): 100.47,61.72 100.47,61.33 99.58,60.45 97.82,60.45 97.67,60.29 96.81,60.29 96.69,60.41 96.69,61.38 96.81,61.5 96.81,61.51 97.45,61.51 97.57,61.38 97.57,61.11 97.7,60.98 98.21,60.98 98.34,61.11 98.34,61.54 98.66,61.86 100.32,61.86
+1.0VA on TOP (solid shape): 109.39,57.92 109.81,57.92 109.84,57.95 109.91,57.99 109.97,58.05 113.81,58.05 115.94,55.92 115.94,55.01 115.65,54.72 115.48,54.72 115.47,54.73 115.3,54.77 115.14,54.73 115.13,54.72 115.07,54.72 114.5,54.15 110.43,54.15 110.15,53.87 105.12,53.87 104.35,53.1 102.73,53.1 102.53,52.9 102.53,52.22 102.17,51.87 102.15,51.87 101.97,51.69 101.97,51.67 101.87,51.56 101.87,49.61 101.12,48.87 101.12,47.15 101.05,47.08 99.2,47.08 99.15,47.12 99.15,48.41 98.94,48.62 98.94,54.49 102.51,58.05 109.26,58.05
+1.0VA on BOTTOM (solid shape): outline of 89 points within 79.08,54.96 118.1,65.22
+1.0VA on BOTTOM: 97.94,48.72 103.16,48.72 103.29,48.59 103.29,48.04 103.09,47.84 102.28,47.84 102,47.56 102,47.29 101.88,47.17 101.88,47.17 101.47,46.76 101.47,43.11 101.1,42.74 99.01,42.74 98.83,42.57 98.83,42.21 98.77,42.16 97.14,42.16 96.99,42.31 96.99,43.71 97.14,43.86 97.9,43.86 98.1,44.07 98.1,46.06 96.99,47.17 96.99,47.77
+1.0VA on IN1: 115.8,55.03 115.8,56.43 114.79,57.45 114.78,57.45 114.61,57.63 113.98,57.63 113.68,57.33 113.68,55.94 114.59,55.03
+1.0VA on IN1: 97.33,42.27 97,42.6 97,43.83 97.43,44.26 97.43,46.96 97.09,47.3 97.09,47.84 98.04,48.8 101.53,48.8 101.53,48.8 101.64,48.69 101.64,48.39 101.8,48.24 102.75,48.24 102.92,48.41 102.92,48.67 103.02,48.77 103.35,48.77 103.47,48.66 103.47,48.37 103.08,47.98 102.41,47.98 102.18,47.75 102.18,47.25 102.11,47.17 101.87,47.17 101.56,46.86 101.56,45.96 100.9,45.29 100.9,44.34 101.5,43.74 101.5,43.43 101.37,43.3 99.32,43.3 98.97,42.95 98.97,42.71 98.97,42.7 98.97,42.42 98.82,42.27
+1.0VA on VCC: 97.51,42.44 97.51,49.29 98.83,49.29 99.54,50 99.54,53.81 100.82,55.09 100.9,55.01 115.73,55.01 115.73,52.13 113.91,50.31 111.25,50.31 108.83,47.9 107.25,47.9 107.1,47.75 107.1,47.64 102.73,47.64 102.09,47.01 100.25,47.01 99.54,46.3 99.54,43.38 99.36,43.2 99.11,43.2 98.91,43 98.91,42.49 98.85,42.44
+1.0VA on IN3: 97.01,42.23 96.79,42.45 96.79,44.04 96.8,44.04 96.8,44.22 97.46,44.88 97.46,46.03 96.8,46.7 96.8,48.56 96.8,48.57 96.8,48.68 96.95,48.84 98.82,48.84 98.91,48.75 98.91,42.48 98.65,42.23
+1.0VA on IN3: 113.93,55.3 113.59,55.64 113.59,57.61 113.64,57.67 114.77,57.67 115.38,57.05 115.38,55.57 115.12,55.3
+1.0VA_XDP on TOP: 56.59,69.75 56.78,69.75 56.85,69.68 56.85,69.14 56.93,69.06 56.93,65.76 56.52,65.35 55.17,65.35 55.12,65.39 55.12,66.58 55.2,66.65 55.76,66.65 56.07,66.97 56.36,66.97 56.45,67.06 56.45,69.01 56.51,69.07 56.51,69.68
+1.0VAP on BOTTOM (solid shape): 125.86,63.06 125.86,60.17 125.75,60.05 120.52,60.05 119.82,59.35 118.3,59.35 118.2,59.45 118.2,59.89 117.76,59.89 117.69,59.96 117.69,60.14 118.2,60.14 118.2,60.69 117.69,60.69 117.69,60.95 118.2,60.95 118.2,61.41 118.2,61.42 118.2,61.54 118.27,61.61 120.74,61.61 121.16,62.03 121.16,62.65 122,63.49 125.43,63.49
+1.0VS_VCCIO on TOP (solid shape): 104.9,27.8 104.9,27.58 104.76,27.44 102.78,27.44 102.66,27.56 102.66,27.84 102.76,27.94 104.76,27.94
+1.0VS_VCCIO on TOP (solid shape): 83.6,41.73 83.6,40.22 83.52,40.14 83.52,39.69 83.4,39.56 82.22,39.56 82.12,39.66 82.12,40.07 81.97,40.21 81.97,41.74 82.08,41.84 83.48,41.84
+1.0VS_VCCIO on TOP (solid shape): 97.09,46.32 97.32,46.09 97.32,45.26 96.61,44.55 96.04,44.55 95.82,44.32 95.82,43.64 95.92,43.54 96.13,43.54 96.33,43.34 96.33,41.91 96.2,41.78 95.47,41.78 95.3,41.95 95.3,45.35 95.02,45.62 95.02,46.18 95.17,46.33 97.09,46.33
+1.0VS_VCCIO on BOTTOM (solid shape): 83.86,41.42 83.86,40.65 83.86,40.65 83.86,40.26 83.82,40.19 83.75,40.16 83.49,39.92 83.75,39.68 83.82,39.65 83.86,39.58 83.86,38.75 83.73,38.63 82.33,38.63 82.16,38.8 82.16,39.13 82.2,39.21 82.29,39.22 82.61,39.46 82.29,39.69 82.2,39.7 82.16,39.78 82.16,40.06 82.2,40.14 82.29,40.15 82.61,40.38 82.29,40.61 82.2,40.63 82.16,40.71 82.16,41.37 82.31,41.52 83.76,41.52
+1.0VS_VCCIO on BOTTOM (solid shape): 94.4,41.42 94.4,40.72 94.36,40.64 94.27,40.62 93.97,40.38 94.27,40.15 94.36,40.13 94.4,40.05 94.4,39.79 94.36,39.71 94.27,39.69 93.97,39.46 94.27,39.22 94.36,39.2 94.4,39.12 94.4,39.01 94.14,38.75 93.26,38.75 93.13,38.88 93.13,39.12 93.17,39.2 93.25,39.22 93.54,39.46 93.25,39.69 93.17,39.72 93.13,39.79 93.13,40.05 93.17,40.12 93.25,40.15 93.54,40.38 93.25,40.62 93.18,40.63 93.13,40.7 93.13,41.4 93.26,41.52 94.3,41.52
